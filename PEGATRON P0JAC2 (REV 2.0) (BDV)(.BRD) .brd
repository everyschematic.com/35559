# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on L2-SIG (solid shape): 38.23,35.57 38.29,35.66 38.4,35.64 38.46,35.58 38.46,35.56 38.54,35.4 38.71,35.34 38.79,35.32 38.82,35.24 38.82,30.66 38.76,30.56 38.65,30.58 38.23,31.01
GND on L2-SIG (solid shape): 5.52,120.5 5.58,120.59 5.69,120.57 5.75,120.51 5.75,118.9 9.84,114.81 9.84,109.77 19.62,100 20.72,100 20.8,99.95 20.81,99.86 20.92,99.52 21.28,99.56 21.35,99.6 21.43,99.56 21.67,99.48 21.88,99.62 21.96,99.68 22.05,99.63 22.09,99.59 22.13,99.55 22.17,99.48 22.14,99.4 22.11,99.36 20.06,99.36 9.72,109.7 9.72,114.76 5.04,119.43 5.04,119.8 5.1,119.88 5.2,119.88 5.57,119.94 5.54,120.32 5.53,120.35 5.52,120.39
GND on L2-SIG (solid shape): 81.9,71.23 81.93,71.21 84.54,68.59 84.54,65.23 84.48,65.13 84.37,65.16 84.33,65.19 83.35,65.19 83.21,65.05 83.19,65.05 82.85,64.55 83.44,64.46 83.48,64.48 83.52,64.46 83.54,64.44 83.54,55.07 82,53.52 81.89,53.5 81.82,53.59 81.82,57.41 81.89,57.5 82.61,57.34 82.96,57.86 82.96,59.84 82.41,60.39 81.85,59.84 81.85,58 81.79,57.91 81.68,57.93 80.21,59.39 80.18,59.48 80.23,59.55 80.34,59.73 80.27,59.92 80.27,62.53 82.13,64.4 82.13,67.97 81.79,68.31 81.79,71.29 81.87,71.29
GND on L2-SIG (solid shape): outline of 292 points within 74.7,87.92 81.13,106.79
GND on L2-SIG (solid shape): outline of 769 points within 47.04,26.79 79.02,51.65
GND on L2-SIG (solid shape): outline of 937 points within 43.87,4.15 83.9,66.25
GND on L2-SIG (solid shape): outline of 7422 points within 0.51,0.51 101.1,124.29
GND on L3-GND (solid shape): outline of 57617 points within 0.51,0.51 101.1,124.29
GND on L4-SIG (solid shape): 29.03,63.93 28.53,63.42 25.35,63.42 25.25,63.53 25.25,64.6 29.03,64.6
GND on L4-SIG (solid shape): 78.98,52.25 78.98,46.07 78.79,45.88 78.71,45.88 76,48.6 76,52.32 76.07,52.39 78.84,52.39
GND on L4-SIG (solid shape): 86.16,51.19 86.16,48.48 85.9,48.22 85.22,48.22 84.94,48.5 84.94,50.33 85.9,51.29 86.07,51.29
GND on L4-SIG (solid shape): 27.91,69.04 27.91,67.44 29.3,66.05 29.89,66.05 30,65.94 30,65.7 29.36,65.06 25.25,65.06 25.25,67.89 25.35,67.99 26.62,67.99 27.03,68.4 27.03,69.14 27.17,69.27 27.67,69.27
GND on L4-SIG (solid shape): 33.27,28.07 33.27,22.43 33.26,22.39 33.25,22.33 33.22,22.27 33.15,22.2 33.1,22.11 33.08,22.08 32.75,22.08 32.6,22.23 32.6,28.05 32.72,28.17 33.18,28.17
GND on L4-SIG (solid shape): 36.21,27.96 36.21,22.25 35.67,21.71 33.82,21.71 33.74,21.75 33.73,21.85 33.75,22.07 33.62,22.25 33.6,22.29 33.58,22.34 33.58,28.32 33.88,28.62 35.55,28.62
GND on L4-SIG (solid shape): 64.11,12.47 70.98,12.47 71.03,12.42 71.03,12.33 70.98,12.28 60.55,12.28 60.47,12.32 60.46,12.42 60.42,12.71 60.16,12.86 60.14,12.86 60,13 59.98,13.12 60.07,13.18 63.41,13.18
GND on L4-SIG (solid shape): 13.04,70.52 13.13,70.46 13.11,70.35 11.77,69.01 11.5,69.01 11.09,69.19 10.83,68.82 10.83,68.79 10.31,68.28 3.9,68.28 3.8,68.34 3.82,68.45 5.9,70.52
GND on L4-SIG (solid shape): 49.19,18.88 49.27,18.83 49.27,18.37 49.58,18.2 57.22,18.2 57.31,18.13 57.29,18.02 57.21,17.94 46.97,17.94 46.9,17.98 46.87,18.06 46.89,18.13 46.89,18.21 46.89,18.22 47.56,18.88
GND on L4-SIG (solid shape): 32.56,94.01 32.56,94 32.82,93.75 32.81,93.72 32.84,93.51 33,93.36 33,91.66 32.65,91.31 30.24,91.31 26.82,87.89 23.25,87.89 22.66,88.48 22.66,96.96 22.71,97 22.75,97.03 22.8,97.04 23.13,97.18 23.14,97.54 23.14,97.64 23.23,97.7 28.88,97.7
GND on L4-SIG (solid shape): 86.76,87.15 86.8,87.14 86.84,87.12 87,87 87.2,86.99 87.29,86.98 87.34,86.9 87.34,84.34 82.47,79.47 82.36,79.45 82.3,79.54 82.3,81.68 84.59,83.97 84.59,86.56 84.6,86.6 84.62,86.63 84.74,86.78 84.76,86.96 84.77,87 84.79,87.04 84.9,87.15
GND on L4-SIG (solid shape): 88.57,95.76 88.69,95.78 88.75,95.69 88.75,94.16 87.38,92.79 87.29,92.76 87.22,92.82 86.92,93.02 86.6,92.87 86.55,92.84 86.5,92.82 86.4,92.82 86.29,92.71 85.79,92.71 85.08,92 85.02,91.99 84.99,92.04 84.99,92.18
GND on L4-SIG (solid shape): 85.06,14.69 85.06,14.12 85.06,13.4 81.96,10.3 81.93,10.28 81.9,10.27 81.87,10.27 81.85,10.28 81.81,10.31 81.81,12.71 82.67,13.56 83.13,13.56 83.14,13.5 83.15,13.44 83.16,13.38 83.19,13.32 83.22,13.27 83.26,13.22 83.3,13.18 83.35,13.14 83.41,13.11 83.46,13.09 83.52,13.07 83.59,13.07 83.65,13.07 83.71,13.07 83.77,13.09 83.83,13.11 83.88,13.14 83.93,13.18 83.98,13.22 84.01,13.27 84.05,13.32 84.07,13.38 84.09,13.44 84.1,13.5 84.1,13.56 84.09,13.63 84.08,13.69 84.06,13.74 84.03,13.8 84,13.85 83.95,13.9 83.91,13.94 83.85,13.97 83.8,14 83.74,14.02 83.68,14.03 83.62,14.03 83.56,14.03 83.49,14.02 83.44,14 83.38,13.97 83.33,13.94 83.28,13.9 83.24,13.85 83.2,13.8 83.18,13.74 83.15,13.69 83.14,13.63 83.13,13.56 82.67,13.56 85.06,15.96
GND on L4-SIG (solid shape): 19.15,63.63 19.15,61.3 19.09,61.2 18.98,61.22 16.49,63.71 13.69,63.71 13.68,63.75 13.22,64.06 12.88,63.62 12.85,63.54 12.78,63.51 11.59,63.51 11.25,64.07 10.92,63.51 4.9,63.51 4.6,63.81 4.6,64.17 4.68,64.25 18.54,64.25
GND on L4-SIG (solid shape): outline of 88 points within 43.52,17.94 47.32,20.35
GND on L4-SIG (solid shape): 16.87,75.94 16.93,76.03 17.04,76.01 17.19,75.87 18.05,75.87 21.36,72.55 21.38,72.55 22,71.93 22.06,71.93 22.11,71.9 22.1,71.84 21.91,71.65 20.5,71.65 20.5,71.7 20.28,72.02 19.91,71.96 19.84,71.93 19.77,71.96 19.17,71.83 19.56,71.37 19.62,71.34 19.67,71.31 19.71,71.3 19.88,71.13 20.02,71.13 20.11,71.07 20.09,70.96 19.41,70.27 19.41,68.03 18.79,67.42 11.96,67.42 11.95,67.44 11.95,68.04 16.68,72.77 16.68,72.96 16.87,73.15
GND on L4-SIG (solid shape): 85.5,89.01 85.58,88.97 85.59,88.87 85.58,88.7 85.65,88.54 85.68,88.48 85.65,88.41 85.57,88.22 85.62,88.03 85.62,87.92 85.53,87.87 85.16,87.87 85.12,87.89 85.08,87.91 84.78,88.04 84.51,87.85 84.51,87.84 83.8,87.13 83.8,83.92 83.28,83.4 83.17,83.38 83.1,83.48 83.1,88.41 83.19,88.49 83.25,88.43 83.24,88.4 83.4,87.96 83.86,88.07 83.91,88.1 83.97,88.12 84.25,88.12 85.14,89.01
GND on L4-SIG (solid shape): outline of 107 points within 39.22,19.67 49.24,26.01
GND on L4-SIG (solid shape): 88.68,89.36 88.78,89.38 88.85,89.29 88.85,85.73 88.82,85.66 88.75,85.63 88.41,85.27 88.75,84.92 88.82,84.89 88.85,84.82 88.85,83.3 91.77,80.38 91.77,80.32 91.75,80.28 91.7,80.28 91.43,80.29 91.23,80.09 86.53,75.39 82.3,75.39 82.3,78.57 87.85,84.12 87.85,87.96 87.91,88.05 88.01,88.04 88.53,88.2 88.2,88.63 88.1,88.69 88.12,88.8
GND on L4-SIG (solid shape): outline of 159 points within 41.39,13.52 63.46,20.44
GND on L4-SIG (solid shape): outline of 163 points within 40.49,22.08 50.31,30.95
GND on L4-SIG (solid shape): outline of 205 points within 82.04,62.11 91.77,79.7
GND on L4-SIG (solid shape): 16.66,97.09 16.77,97.11 16.83,97.02 16.83,91.42 16.79,91.34 16.7,91.33 16.53,91.34 16.37,91.27 16.31,91.25 16.24,91.27 15.69,91.03 16.24,90.77 16.3,90.79 16.37,90.77 16.56,90.69 16.76,90.73 16.81,90.74 16.83,90.69 16.83,90.59 16.68,90.44 16.68,87.04 16.63,86.95 16.53,86.95 16.1,86.85 16.16,86.41 16.19,86.33 16.15,86.25 16.08,85.8 16.52,85.7 16.63,85.7 16.68,85.61 16.68,85.42 16.63,85.34 16.52,85.34 16.03,85.05 16.52,84.76 16.63,84.76 16.68,84.67 16.68,83.95 16.63,83.86 16.52,83.86 16.07,83.74 16.2,83.28 16.26,83.19 16.03,82.81 16.26,82.43 16.03,82.05 16.26,81.67 16.03,81.29 16.26,80.91 16.2,80.82 16.03,80.49 16.27,80.21 16.34,80.14 16.31,80.04 15.46,79.18 15.46,73.72 15.4,73.66 15.35,73.65 15.31,73.7 15.31,76.12 14.85,76.59 14.85,79.54 15.38,80.07 15.38,92.43 16.33,93.38 16.33,96.76
GND on L4-SIG (solid shape): outline of 391 points within 33.53,2.78 63.12,6.91
GND on L4-SIG (solid shape): outline of 609 points within 40.24,94.97 87.73,114.44
GND on L4-SIG (solid shape): outline of 768 points within 38.67,5.75 74.75,17.87
GND on L4-SIG (solid shape): outline of 742 points within 45.95,13.21 78.8,19.72
GND on L4-SIG (solid shape): outline of 1065 points within 72.94,18.59 82.99,46.97
GND on L4-SIG (solid shape): outline of 2379 points within 4.52,1.93 52.43,61.96
GND on L4-SIG (solid shape): outline of 6615 points within 0.51,0.51 101.1,124.29
GND on L5-SIG (solid shape): 78.87,32.34 78.87,31.42 78.38,30.93 77.9,30.93 77.76,31.08 77.76,31.7 78.43,32.37 78.84,32.37
GND on L5-SIG (solid shape): 78.89,50.07 78.89,49.67 78.61,49.39 76.07,49.39 75.92,49.54 75.92,50.2 76.01,50.29 78.68,50.29
GND on L5-SIG (solid shape): 12.69,76.16 18.26,76.16 18.26,75.95 11.77,75.95 11.56,75.75 11.53,75.75 11.44,75.81 11.46,75.92 12.03,76.49 12.35,76.49
GND on L5-SIG (solid shape): 16.12,82.46 16.12,82.28 16.05,82.18 16.03,82.07 16,82.01 15.93,81.98 13.92,81.98 13.85,82.06 13.85,82.39 14.11,82.66 15.91,82.66
GND on L5-SIG (solid shape): 65.93,14.39 65.93,12.99 68.12,10.8 68.12,9.28 67.9,9.06 66.87,9.06 66.71,9.21 66.71,10.83 64.99,12.55 64.99,13.12 65.21,13.37 65.1,13.69 65.1,14.08 65.24,14.19 65.3,14.35 65.47,14.51 65.81,14.51
GND on L5-SIG (solid shape): 7.8,121.59 7.9,121.53 7.9,121.25 8.02,121.13 8.02,121.09 8.81,120.3 8.81,113.34 10.39,111.77 10.61,111.77 10.71,111.7 10.68,111.59 10.65,111.56 10.63,111.53 10.59,111.51 10.55,111.5 10.44,111.5 7.75,114.19 7.75,119.4 7.32,119.84 7.32,121.54 7.36,121.55 7.4,121.57 7.55,121.58 7.68,121.65 7.7,121.67 7.73,121.68
GND on L5-SIG (solid shape): 2.4,78.23 2.45,78.32 2.56,78.32 2.67,78.27 2.8,78.27 2.86,78.25 2.91,78.21 2.95,78.2 5.44,75.71 5.46,75.6 5.37,75.53 4.79,75.53 3.21,77.11 3.16,77.11 3.13,77.13 3.06,77.14 3.01,77.17 2.8,77.3 2.55,77.27 2.45,77.27 2.4,77.36
GND on L5-SIG (solid shape): 83.61,98.51 83.63,98.51 83.65,98.5 83.68,98.49 83.7,98.46 83.71,98.44 83.71,98.41 83.7,98.37 83.69,98.32 83.69,98.27 83.7,98.22 83.71,98.17 83.73,98.12 83.76,98.08 83.79,98.04 83.81,98.02 83.82,98.01 83.82,94.68 82.32,93.18 82.31,93.17 82.28,93.16 82.25,93.15 82.22,93.15 82.19,93.17 82.17,93.18 82.15,93.21 82.14,93.24 82.14,93.25 82.14,97.16 82.94,97.16 82.94,97.1 82.95,97.05 82.97,97 82.99,96.95 83.02,96.91 83.05,96.87 83.1,96.83 83.14,96.81 83.19,96.79 83.24,96.78 83.3,96.77 83.35,96.78 83.4,96.79 83.45,96.81 83.5,96.83 83.54,96.87 83.58,96.91 83.61,96.95 83.63,97 83.65,97.05 83.65,97.1 83.65,97.16 83.65,97.21 83.63,97.26 83.61,97.31 83.58,97.35 83.54,97.39 83.5,97.42 83.45,97.45 83.4,97.47 83.35,97.48 83.3,97.49 83.24,97.48 83.19,97.47 83.14,97.45 83.1,97.42 83.05,97.39 83.02,97.35 82.99,97.31 82.97,97.26 82.95,97.21 82.94,97.16 82.14,97.16 82.14,98.51
GND on L5-SIG (solid shape): outline of 83 points within 34.29,1.49 45.52,6.93
GND on L5-SIG (solid shape): outline of 89 points within 20.28,6.5 23.24,15.77
GND on L5-SIG (solid shape): 23.64,38.24 23.64,32.24 23.6,32.21 23.56,32.2 23.28,32.08 23.19,31.76 23.18,31.73 21.43,29.98 21.43,16.3 19.58,14.45 19.58,9.89 19.55,9.84 19.5,9.85 19.42,9.93 19.42,9.96 18.8,10.33 19.07,9.66 19.15,9.63 19.18,9.56 19.18,8.51 19.12,8.42 19.01,8.44 18.96,8.48 18.95,8.52 18.92,8.57 18.9,8.62 18.89,8.77 18.81,8.91 18.6,9.04 18.35,9.01 18.25,9.02 18.21,9.11 18.21,43.31 18.34,43.44 18.43,43.44
GND on L5-SIG (solid shape): 86.32,51.36 86.32,39.82 86.15,39.65 85.88,39.65 85.69,39.84 85.68,39.84 85.31,40.21 85.32,40.24 85.34,40.44 85.25,40.63 85.23,40.66 85.37,40.97 85.27,41.24 85.26,41.27 85.27,41.31 85.11,41.89 84.58,41.58 84.58,41.54 84.07,41.54 83.44,42.17 83.44,46.7 83.66,46.92 84.79,46.92 85.22,46.5 85.22,46.24 84.19,45.21 84.19,44.54 84.54,44.19 84.68,44.19 84.68,44.14 85.18,43.83 85.29,44.41 85.27,44.45 85.28,44.48 85.36,44.79 85.16,45.04 85.15,45.04 84.99,45.2 84.99,45.32 85.93,46.25 85.93,48.48 85.29,49.12 85.29,51.3 85.47,51.48 86.2,51.48
GND on L5-SIG (solid shape): 84.48,37.68 84.48,37.07 83.18,35.77 83.07,35.75 83.01,35.83 82.63,36.15 82.3,35.79 82.3,35.77 81.67,35.14 79.64,35.14 79.07,34.91 79.64,34.68 81.84,34.68 81.94,34.62 81.92,34.51 81.54,34.13 78.81,34.13 77.31,32.63 77.27,32.61 77.22,32.59 77.17,32.6 77.11,32.59 77.06,32.61 77.02,32.63 76.91,32.74 76.88,32.83 76.94,32.9 77.08,33.39 76.58,33.44 76.54,33.4 76.1,33.85 76.07,33.96 76.17,34.02 77.52,34.02 81.25,37.75 84.41,37.75
GND on L5-SIG (solid shape): 95.44,92.67 95.47,92.72 95.52,92.71 95.61,92.62 95.61,78.98 95.56,78.89 95.46,78.89 94.97,78.6 95.46,78.31 95.56,78.3 95.61,66.25 93.88,64.52 93.76,64.49 93.7,64.59 93.7,78.29 93.76,78.38 93.88,78.36 94.44,78.6 93.88,78.83 93.76,78.81 93.7,78.9 93.7,85.68 93.79,86 93.56,86.24 93.49,86.31 93.51,86.41 95.44,88.34
GND on L5-SIG (solid shape): 81.51,30.98 81.59,31.01 81.66,30.98 81.66,27.78 81.61,27.75 81.54,27.75 81.21,27.74 81.04,27.46 81,27.39 80.93,27.36 80.58,26.52 81.38,26.96 81.39,27.04 81.46,27.08 81.5,27.09 81.54,27.1 81.61,27.11 81.66,27.08 81.66,26.03 81.62,25.96 81.54,25.94 81.08,25.61 81.44,25.18 81.46,25.18 81.51,25.13 81.42,25.04 81.39,25.04 81.07,24.98 80.92,24.69 80.86,24.59 80.75,24.62 79.8,25.56 79.8,27.87 78.57,29.1 78.6,29.17 78.67,29.2 79.09,29.2 80.42,30.53 81.06,30.53
GND on L5-SIG (solid shape): outline of 171 points within 25.22,7.05 31.47,11.58
GND on L5-SIG (solid shape): 28.65,74.48 28.65,72.36 28.27,71.99 27.77,71.99 27.42,72.33 26.84,72.92 25.26,72.92 24.85,73.33 24.84,73.37 24.8,73.43 24.78,73.49 24.42,73.9 24.07,73.48 24.08,73.48 24.08,73.02 23.97,72.91 22.72,72.91 22.2,73.43 15.16,73.43 15.09,73.5 15.08,73.53 15.04,73.59 15.02,73.65 14.75,74.05 14.33,73.8 14.32,73.79 14.04,73.51 14,73.53 13.58,73.48 13.51,73.06 13.52,73.05 13.52,72.82 13.41,72.71 10.9,72.71 10.82,72.76 10.81,72.86 10.49,73.37 10.17,72.86 10.16,72.76 10.08,72.71 7.48,72.71 6.89,73.31 6.87,73.34 6.86,73.39 6.46,73.76 6.27,73.25 6.27,73.06 6.14,72.94 5.73,72.94 5.43,73.23 5.43,74.25 5.77,74.59 28.54,74.59
GND on L5-SIG (solid shape): 82.21,34.33 82.3,34.36 82.38,34.3 82.45,34.19 82.56,34.11 82.61,34.04 82.6,33.96 82.6,23.91 82.04,23.35 78.89,23.35 78.81,23.39 78.8,23.49 78.81,23.55 78.87,23.62 78.97,23.61 79.28,23.57 79.52,23.78 79.59,23.84 79.69,23.81 79.86,23.63 80.36,23.63 80.36,24.14 78.83,25.67 78.25,26.25 78.2,26.25 77.18,27.27 77.16,27.37 77.23,27.44 77.35,27.49 77.46,27.59 77.53,27.62 77.6,27.6 78.04,27.59 78.15,28.02 78.17,28.12 78.26,28.16 78.49,28.19 78.66,28.35 78.7,28.4 78.75,28.41 79.45,27.72 79.45,25.42 80.62,24.24 80.63,24.21 80.67,24.16 80.69,24.1 81.12,23.67 81.42,24.2 81.42,24.27 81.47,24.33 81.65,24.51 81.68,24.76 81.67,24.79 82.02,25.13 82.02,32.86 81.37,33.51 79.86,33.51 79.81,33.56 79.81,33.75 79.86,33.8 81.68,33.8
GND on L5-SIG (solid shape): 82.25,46.64 82.29,46.63 82.33,46.6 82.53,46.47 82.77,46.51 82.87,46.51 82.92,46.42 82.92,40.9 82.61,40.6 81.06,40.6 79.94,41.72 75.95,41.72 75.37,42.29 75.37,44 75.43,44.08 75.53,44.08 76.06,44.29 75.7,44.74 75.61,44.79 75.61,44.89 75.37,45.4 74.93,45.05 74.94,45.02 74.92,45 74.92,42.1 75.76,41.26 79.75,41.26 80.44,40.57 80.44,39.57 76.38,35.52 76.3,35.5 76.21,35.49 75.86,35.44 75.76,35.1 75.74,35.01 75.66,34.97 75.43,34.97 74.41,35.98 74.35,35.98 74.27,36.02 74.25,36.11 74.18,36.47 73.82,36.57 73.79,36.57 73.63,36.74 73.63,39.93 70.26,43.29 64.85,43.29 64.08,42.52 64.08,41.82 63.32,41.06 63.23,41.03 63.16,41.08 62.76,41.24 62.54,40.88 62.52,40.83 62.5,40.79 62.03,40.31 62.03,38.59 62.03,38.56 62.05,38.51 62.05,38.44 62,38.39 61.89,38.37 61.82,38.46 61.82,41.04 66.35,45.57 80.84,45.57 81.9,46.64
GND on L5-SIG (solid shape): outline of 208 points within 59.95,41.5 82.92,48.6
GND on L5-SIG (solid shape): outline of 214 points within 4.06,54.92 32.94,68.42
GND on L5-SIG (solid shape): outline of 264 points within 29.79,3.87 38.68,12.76
GND on L5-SIG (solid shape): outline of 291 points within 82.14,70.17 85.8,95.18
GND on L5-SIG (solid shape): outline of 273 points within 2.4,67.26 22.53,76.78
GND on L5-SIG (solid shape): outline of 407 points within 62.26,23.35 79.08,30.49
GND on L5-SIG (solid shape): outline of 460 points within 19.43,7.08 29.85,58.43
GND on L5-SIG (solid shape): outline of 602 points within 40.59,12.2 55.71,26.1
GND on L5-SIG (solid shape): outline of 582 points within 63.12,35.98 73.58,42.99
GND on L5-SIG (solid shape): outline of 716 points within 30.23,19.61 50.86,39.63
GND on L5-SIG (solid shape): outline of 1256 points within 1.76,75.75 33.51,102.19
GND on L5-SIG (solid shape): outline of 2682 points within 39.78,1.71 84.08,24.52
GND on L5-SIG (solid shape): outline of 8486 points within 0.51,0.51 101.1,124.29
GND on L6-GND (solid shape): outline of 66072 points within 0.51,0.51 101.1,124.29
GND on L7-SIG (solid shape): 29.24,105.75 29.24,104.43 28.14,103.34 26.44,103.34 26.26,103.51 26.26,104.3 28.02,106.06 28.92,106.06
GND on L7-SIG (solid shape): 38.04,51.06 38.04,50.37 37.79,50.12 37.61,50.12 37.21,50.52 37.21,51.46 37.22,51.48 37.63,51.48
GND on L7-SIG (solid shape): 41.37,55.53 41.37,54.49 41.17,54.29 39.76,54.29 39.57,54.47 39.57,55.06 40.29,55.78 41.12,55.78
GND on L7-SIG (solid shape): 68.43,4.35 68.43,3.69 68.1,3.36 67.26,3.36 67.13,3.49 67.13,4.19 67.44,4.49 68.29,4.49
GND on L7-SIG (solid shape): 23.01,72.48 23.01,71.92 22.9,71.8 20.61,71.8 20.47,71.94 20.47,72.32 20.68,72.52 22.97,72.52
GND on L7-SIG (solid shape): 62.54,4.1 62.54,2.72 62.12,2.31 60.42,2.31 60.2,2.52 60.2,3.18 61.29,4.28 62.36,4.28
GND on L7-SIG (solid shape): 75.4,33.33 75.4,32.55 75.34,32.5 74.35,32.5 74.22,32.62 74.22,33.23 74.45,33.46 75.27,33.46
GND on L7-SIG (solid shape): 69.7,55.41 69.7,54.31 69.47,54.09 69.22,54.09 68.55,54.76 63.63,54.76 63.22,55.17 63.22,55.61 63.42,55.82 69.29,55.82
GND on L7-SIG (solid shape): 79.49,57.4 79.49,56.94 79.3,56.75 71.32,56.75 71.15,56.93 71.15,57.39 71.15,57.39 77.78,57.39 77.88,57.49 79.39,57.49
GND on L7-SIG (solid shape): 33.99,57.29 33.99,55.12 33.82,54.95 33.82,54.65 33.63,54.47 32.5,54.47 32.5,56 32.86,56.35 32.86,57.14 33.13,57.41 33.86,57.41
GND on L7-SIG (solid shape): 29.79,11.31 31.04,11.31 31.15,11.2 31.15,10.44 30.76,10.04 30.04,10.04 29.21,10.87 28.35,10.87 27.79,11.43 27.79,12.25 28.22,12.68 28.42,12.68
GND on L7-SIG (solid shape): 29.87,50.76 29.87,50.61 29.82,50.56 26.59,50.56 26.53,50.62 26.53,50.97 26.57,51.01 29.62,51.01
GND on L7-SIG (solid shape): 30.04,68.1 30.04,65.57 29.92,65.45 29.72,65.45 27.82,63.55 27.82,63.42 25.35,63.42 25.25,63.53 25.25,67.89 25.35,67.99 26.62,67.99 26.87,68.24 29.9,68.24
GND on L7-SIG (solid shape): 37.42,10.85 37.44,10.74 37.34,10.68 35.62,10.68 34.27,12.04 34.27,12.64 34.44,12.82 35.45,12.82
GND on L7-SIG (solid shape): 17.9,98.27 18.01,98.29 18.07,98.2 18.07,89.15 17.57,88.65 17.52,88.7 17.52,88.73 17.52,97.89
GND on L7-SIG (solid shape): 64.89,57.32 64.9,57.32 64.98,57.24 65,57.13 64.91,57.07 62.57,57.07 62.5,57.13 62.5,57.39 64.26,57.39 64.35,57.48 64.73,57.48
GND on L7-SIG (solid shape): 51.59,57.48 55.2,57.48 55.24,57.45 55.23,57.4 55.12,57.28 55.01,57.28 54.99,57.27 53.41,57.27 52.82,56.68 47.63,56.68 47.4,56.91 47.4,57.48 48.16,58.25 50.83,58.25
GND on L7-SIG (solid shape): 43.54,22.71 43.65,22.73 43.71,22.64 43.71,22.4 42.58,21.27 42.22,21.27 41.91,21.58 41.91,21.95 42.78,21.95
GND on L7-SIG (solid shape): 41.12,53.57 41.22,53.51 41.2,53.4 39.53,51.73 39.42,51.71 39.35,51.8 39.35,52.55 40.37,53.57
GND on L7-SIG (solid shape): 49.07,49.19 51.25,49.19 51.35,49.13 51.32,49.02 51.24,48.93 51.23,48.93 51.13,48.83 47.82,48.83 47.81,48.84 47.72,48.84 47.65,48.9 47.65,49.64 47.73,49.72 48.54,49.72
GND on L7-SIG (solid shape): 26.7,43.54 26.76,43.63 26.87,43.61 28.64,41.84 28.64,41.08 29.51,40.21 29.53,40.1 29.44,40.04 26.8,40.04 26.7,40.14
GND on L7-SIG (solid shape): 51.5,50.32 51.52,50.2 51.42,50.14 49.52,50.14 49.35,50.31 47.76,50.31 47.66,50.38 47.69,50.49 47.85,50.66 51.16,50.66
GND on L7-SIG (solid shape): 55.34,55.59 55.43,55.53 55.41,55.42 54.27,54.28 48.44,54.28 48.09,54.28 47.51,53.71 46.11,53.71 45.97,53.85 45.97,54.25 45.76,54.45 45.76,54.89 45.87,55 53.52,55 54.11,55.59
GND on L7-SIG (solid shape): 84.28,16.14 84.35,16.11 84.38,16.04 84.41,15.91 84.49,15.81 84.49,15.7 82.35,13.57 81.85,13.06 81.66,12.87 80.49,12.87 80.39,12.93 80.42,13.04 83.51,16.14
GND on L7-SIG (solid shape): 28.33,45.65 28.41,45.23 28.83,45.15 29.75,44.22 29.75,40.87 29.66,40.78 29.56,40.78 29.05,41.28 29.05,42.15 25.6,45.6 25.6,45.9 25.71,46 27.97,46
GND on L7-SIG (solid shape): 28.2,52.58 29.18,52.58 29.24,52.51 29.24,51.9 29.14,51.8 28.81,51.8 28.81,51.85 28.52,52.13 28.24,51.85 28.24,51.8 26.55,51.8 26.26,52.09 26.26,52.75 26.67,53.16 27.62,53.16
GND on L7-SIG (solid shape): 85.02,3.49 88.04,3.49 88.22,3.31 88.22,2.13 88.08,2 88.01,1.97 87.93,2 87.68,2.07 87.53,1.86 87.53,1.84 87.44,1.75 81.34,1.75 81.01,2.08 81.01,3.3 82.34,4.62 83.89,4.62
GND on L7-SIG (solid shape): 40,60.17 41.71,60.17 41.81,60.06 41.81,59.89 41.76,59.84 41.08,59.84 40.83,59.59 41.08,59.33 42.64,59.33 42.75,59.22 42.75,59.12 41.86,58.23 41.86,57.41 41,56.55 40.05,56.55 39.85,56.75 39.85,57.39 39.82,57.42 39.82,57.64 38.78,58.68 38.78,60.79 38.84,60.86 39.31,60.86
GND on L7-SIG (solid shape): 74.05,10.32 74.04,10.28 73.99,9.95 74.17,9.67 74.2,9.55 74.11,9.48 70.32,9.48 69.94,9.1 69.54,9.1 68.5,10.15 68.47,10.26 68.57,10.32
GND on L7-SIG (solid shape): 77.96,9.79 77.98,9.68 77.89,9.62 77.42,9.62 76.91,9.1 74.84,9.1 74.53,9.41 74.5,9.51 74.58,9.58 74.9,9.86 74.89,10.28 74.89,10.38 74.98,10.43 77.32,10.43
GND on L7-SIG (solid shape): 84.7,103.04 84.7,103.01 84.78,102.81 84.98,102.74 85,102.74 88.49,99.25 88.49,99.13 88.43,99.04 88.32,99.06 87.95,99.43 87.3,99.43 87.22,99.5 87.22,99.61 85.1,101.74 85.1,101.77 85.02,101.97 84.82,102.04 84.8,102.04 84.22,102.62 79.31,102.62 78.84,103.08 78.84,103.89 79.05,104.09 83.65,104.09
GND on L7-SIG (solid shape): 44.93,38.62 44.93,37.88 46.66,36.14 46.66,35.45 46.1,34.89 46.1,34.59 45.65,34.59 45.63,34.61 45.63,34.96 44.3,36.29 44.2,36.53 43.95,36.57 43.91,36.55 43.48,36.99 43.48,37.36 43.87,37.75 43.94,37.86 43.96,37.98 43.96,38.34 44.07,38.45 44.39,38.45 44.58,38.51 44.7,38.67 44.88,38.67
GND on L7-SIG (solid shape): 24.6,3.79 24.61,3.79 24.63,3.77 24.85,3.64 25.07,3.77 25.08,3.79 25.13,3.79 25.28,3.64 25.28,2.98 25.26,2.94 25.26,2.9 25.26,2.87 25.25,2.84 25.26,2.51 25.57,2.45 25.71,2.45 25.95,2.22 25.97,2.1 25.88,2.04 25,2.04 24.89,2.12 24.76,2.14 21.68,2.14 19.61,4.21 19.61,4.84 19.76,4.99 23.41,4.99
GND on L7-SIG (solid shape): 73.45,27.63 73.62,27.43 73.88,27.49 73.92,27.52 74.63,26.81 74.63,26.32 74.14,25.84 73.15,25.84 73.07,25.87 73.04,25.95 72.82,26.2 72.59,25.95 72.56,25.87 72.49,25.84 70.98,25.84 70.79,26.02 70.79,26.4 71.5,27.11 71.57,27.25 71.54,27.4 71.53,27.44 71.76,27.67 73.45,27.67
GND on L7-SIG (solid shape): 8.21,74.38 8.26,74.35 8.25,74.3 8.2,74.25 8.2,73.47 8.09,73.35 8.09,72.92 8.52,72.92 8.79,73.19 8.84,73.14 8.84,73.09 8.84,72.3 8.86,72.19 8.92,72.09 8.94,71.98 8.85,71.92 6.03,71.92 5.94,71.98 5.96,72.09 7.47,73.61 7.54,73.71 7.56,73.82 7.56,74.05 7.89,74.38
GND on L7-SIG (solid shape): 41.96,52.03 41.96,49.89 41.45,49.39 40.48,49.39 40.4,49.43 40.38,49.51 40.15,49.78 39.93,49.51 39.91,49.43 39.83,49.39 39.29,49.39 39.22,49.46 39.22,49.94 39.41,50.12 39.57,50.12 39.71,50.22 40.03,50.22 40.08,50.17 40.44,50.17 40.44,50.53 40.25,50.72 40.25,51.11 41.32,52.18 41.8,52.18
GND on L7-SIG (solid shape): 1.62,81.73 1.63,81.77 1.64,81.79 1.66,81.81 1.69,81.82 1.72,81.83 1.79,81.81 1.84,81.8 1.87,81.8 2.95,81.8 3.22,81.53 3.22,80.67 3.22,80.66 3.21,80.63 3.19,80.61 3.17,80.59 3.14,80.57 3.11,80.57 3.08,80.58 3.05,80.59 3.04,80.6 2.89,80.75 2.87,80.77 2.83,80.8 2.79,80.81 2.74,80.82 2.72,80.82 1.88,80.82 1.86,80.82 1.82,80.82 1.78,80.8 1.75,80.79 1.72,80.78 1.69,80.79 1.67,80.8 1.64,80.82 1.63,80.84 1.62,80.87 1.62,80.89 1.62,81.44 2.49,81.44 2.49,81.42 2.5,81.38 2.51,81.34 2.54,81.3 2.56,81.27 2.6,81.25 2.64,81.23 2.68,81.22 2.72,81.21 2.76,81.22 2.8,81.23 2.84,81.25 2.87,81.27 2.9,81.3 2.92,81.34 2.94,81.38 2.95,81.42 2.95,81.46 2.94,81.5 2.92,81.54 2.9,81.58 2.87,81.61 2.84,81.64 2.8,81.66 2.76,81.67 2.72,81.67 2.68,81.67 2.64,81.66 2.6,81.64 2.56,81.61 2.54,81.58 2.51,81.54 2.5,81.5 2.49,81.46 2.49,81.44 1.62,81.44
GND on L7-SIG (solid shape): 88.94,32.27 88.95,32.25 88.96,32.23 88.96,31.15 88,30.19 87.55,30.19 87.39,30.02 86.13,30.02 86.11,30.03 86.09,30.03 86.06,30.05 86.04,30.07 86.03,30.1 86.03,30.13 86.03,30.16 86.05,30.19 86.06,30.23 86.07,30.27 86.07,30.29 86.07,30.83 87.87,30.83 87.87,30.79 87.89,30.75 87.91,30.71 87.94,30.67 87.97,30.64 88.01,30.62 88.06,30.61 88.1,30.6 88.15,30.6 88.19,30.61 88.23,30.63 88.27,30.66 88.29,30.67 88.74,31.12 88.74,31.62 88.74,31.64 88.73,31.69 88.71,31.73 88.69,31.77 88.66,31.8 88.62,31.83 88.58,31.85 88.54,31.86 88.49,31.86 88.45,31.86 88.4,31.85 88.36,31.83 88.33,31.8 88.3,31.77 88.27,31.73 88.26,31.69 88.25,31.64 88.25,31.62 88.25,31.33 87.94,31.02 87.92,31 87.9,30.97 87.88,30.92 87.87,30.88 87.87,30.83 86.07,30.83 86.07,30.92 85.8,31.19 85.8,31.79 85.8,31.82 85.82,31.84 85.86,31.85 85.9,31.86 85.94,31.88 85.98,31.9 85.99,31.92 86.35,32.28 88.9,32.28
GND on L7-SIG (solid shape): outline of 92 points within 48.06,58.73 51.82,63.15
GND on L7-SIG (solid shape): outline of 89 points within 76.02,25.43 84.42,32.98
GND on L7-SIG (solid shape): 87.01,67.09 87.13,67.05 87.25,67.04 88.85,67.04 89.45,66.45 89.45,64.55 89.43,64.52 89.39,64.5 89.38,64.5 87.14,64.5 87.09,64.53 87.1,64.59 87.17,64.66 88.34,64.66 88.58,64.91 88.34,65.15 86.97,65.15 86.26,64.44 86.19,64.41 86.12,64.44 86.09,64.46 86.05,64.55 86.1,64.64 86.26,64.86 86.17,65.12 86.09,65.2 86.06,65.28 86.1,65.36 86.18,65.45 86.2,65.56 86.2,66.58 85.87,66.92 85.84,67.03 85.94,67.09
GND on L7-SIG (solid shape): 41.08,62.07 41.15,62.03 41.23,62.02 41.99,62.02 42.04,62 42.09,62 42.65,62 42.73,61.92 42.73,61.58 42.92,61 43.53,61.06 43.62,61.09 43.7,61.03 43.81,60.86 43.99,60.75 44.04,60.7 44.05,60.63 44.05,60.6 44.04,60.56 44.04,59.79 44.6,59.23 44.6,59.21 44.38,58.99 44.31,58.96 44.24,58.99 44.16,59.04 44.06,59.06 43.69,59.06 43.63,59.12 43.63,59.89 43.63,60 43.12,60.51 43.04,60.56 42.95,60.58 42.54,60.58 42.5,60.58 42.21,60.58 42.17,60.54 40.01,60.54 39.85,60.69 39.85,61.88 40.04,62.07
GND on L7-SIG (solid shape): outline of 103 points within 32.15,67.79 36.27,68.93
GND on L7-SIG (solid shape): 19.15,63.63 19.15,61.25 19.09,61.16 18.98,61.18 16.82,63.34 13.74,63.34 13.66,63.39 13.65,63.49 13.28,64.07 12.92,63.49 12.91,63.39 12.83,63.34 11.3,63.34 11.29,63.35 11.2,63.35 11.12,63.39 11.1,63.48 10.84,63.84 10.57,63.48 10.55,63.39 10.47,63.35 10.2,63.35 9.85,63.69 4.88,63.69 4.86,63.67 4.75,63.67 4.56,63.86 4.56,64.16 4.64,64.25 18.54,64.25
GND on L7-SIG (solid shape): 84.96,15.92 85.04,15.89 85.07,15.86 86.86,15.86 86.88,15.83 86.92,15.8 86.96,15.72 86.92,15.63 86.89,15.62 86.85,15.58 86.82,15.58 85.78,14.54 85.73,14.54 85.34,14.16 85.34,14.1 85.26,14.02 85.24,14.02 84.97,13.85 85.02,13.55 85.06,13.51 83.23,11.69 79.27,11.69 79.18,11.75 79.19,11.86 79.86,12.53 81.8,12.53 82.59,13.33 82.91,13.64 83.02,13.66 83.08,13.57 84,13.17 83.6,14.08 83.5,14.14 83.52,14.25 84.83,15.56 84.83,15.81 84.86,15.84 84.89,15.87
GND on L7-SIG (solid shape): outline of 128 points within 28.93,60.49 32.76,64.79
GND on L7-SIG (solid shape): 80.98,105.3 80.98,104.61 80.75,104.38 78.51,104.38 78.23,104.66 78.23,104.99 78.38,105.13 78.68,105.13 78.88,104.93 78.95,104.9 78.98,104.83 79.2,104.53 79.57,104.59 79.64,104.62 79.71,104.59 80.29,104.77 79.88,105.21 79.84,105.22 79.81,105.28 79.86,105.32 80.25,105.69 79.83,106.02 79.76,106.04 79.7,106.07 79.42,106.35 73.67,106.35 73.57,106.41 73.6,106.52 73.78,106.71 73.79,106.71 73.87,107.09 73.5,107.01 73.49,107 73.34,106.85 64.93,106.85 64.88,106.88 64.89,106.93 64.91,106.95 65.77,107.81 78.48,107.81
GND on L7-SIG (solid shape): outline of 162 points within 14.61,73.43 24,80.61
GND on L7-SIG (solid shape): 78.5,3.85 78.5,3.4 77.03,1.92 65.53,1.92 65.45,1.97 65.44,2.06 65.46,2.23 65.37,2.37 65.34,2.45 65.37,2.53 65.21,2.98 65.05,2.53 65.09,2.45 65.05,2.37 64.96,2.23 64.98,2.06 64.97,1.97 64.89,1.92 64.28,1.92 64.2,1.97 64.19,2.06 64.21,2.23 64.12,2.37 64.09,2.45 64.12,2.53 63.96,2.98 63.8,2.53 63.84,2.45 63.8,2.37 63.71,2.23 63.73,2.06 63.72,1.97 63.64,1.92 62.94,1.92 62.87,1.99 62.87,2.64 63.35,3.13 66.91,3.13 66.96,3.07 68.22,3.07 69.29,4.14 78.22,4.14
GND on L7-SIG (solid shape): 38.51,27.29 38.51,26.14 38.44,26.12 38.38,26.15 37.98,26.55 37.36,26.55 37.31,26.6 37.29,26.69 37.24,26.76 36.12,27.87 33.8,27.87 30.88,24.95 30.07,24.95 29.82,24.7 30.07,24.44 31.09,24.44 34.02,27.36 35.91,27.36 36.79,26.48 36.42,26.11 36.42,25.39 36.24,25.2 32.29,25.2 31.94,24.86 31.94,24.5 32.3,24.5 32.5,24.7 36.45,24.7 36.64,24.88 36.75,24.91 36.81,24.81 36.81,22.57 36.35,22.1 32.36,22.1 30.84,20.58 29.55,20.58 29.05,21.07 29.05,22.74 29.08,22.81 29.15,22.84 29.38,23.07 29.15,23.3 29.08,23.33 29.05,23.4 29.05,23.5 29.08,23.58 29.15,23.6 29.38,23.83 29.15,24.06 29.08,24.09 29.05,24.17 29.05,24.19 29.09,24.27 29.17,24.29 29.31,24.31 29.44,24.39 29.69,24.64 29.69,26.52 30,26.82 30,27.23 30.06,27.29 32.5,27.29 33.56,28.36 37.44,28.36
GND on L7-SIG (solid shape): 80.57,9.95 80.59,9.91 80.6,9.86 80.59,9.83 80.6,9.8 80.5,9.43 80.86,9.3 80.86,9.31 81.51,9.31 81.63,9.18 81.6,9.15 81.74,8.71 82.11,8.98 82.14,9.05 82.21,9.08 82.41,9.08 82.41,8.98 82.41,8.53 82.65,8.29 82.65,7.14 82.64,7.13 82.51,7.13 82.38,7.26 82.38,7.53 82.39,7.54 82.2,7.92 81.85,7.68 81.85,7.67 81.71,7.53 80.82,7.53 80.51,7.85 80.51,8.11 80.47,8.15 80.72,8.39 80.74,8.39 80.95,8.87 80.47,8.67 80.47,8.64 80.31,8.49 80.25,8.55 80.27,8.58 80.25,8.84 80.03,8.98 79.95,9.04 79.97,9.15 80.09,9.26 80.1,9.27 80.28,9.45 80.24,9.7 80.26,9.78 80.26,9.86 80.27,9.91 80.29,9.95
GND on L7-SIG (solid shape): 87.45,108.13 87.53,108.1 87.55,108.02 87.55,108.01 87.55,106.27 87.49,106.18 87.38,106.2 86.77,106.8 86.77,106.81 86.2,106.92 86.3,106.34 86.31,106.34 86.87,105.78 86.87,105.77 89.39,103.24 89.39,99.06 89.72,98.73 90.05,99.06 90.05,101.9 90.12,101.99 90.23,101.97 90.6,101.6 90.6,93.79 89.03,92.22 89.03,90.81 89,90.77 88.94,90.78 88.88,90.84 88.88,99.41 85.18,103.12 85.14,103.17 85.08,103.21 83.82,104.48 82.56,104.48 82.48,104.53 82.48,104.63 82.5,104.68 82.52,104.73 82.51,104.91 82.43,105.06 82.4,105.13 82.43,105.2 82.53,105.58 82.23,105.83 81.87,105.63 81.94,105.22 81.96,105.14 81.92,105.07 81.79,105.07 78.91,107.95 78.88,108.07 78.98,108.13
GND on L7-SIG (solid shape): outline of 168 points within 67.09,13.94 74.32,21.09
GND on L7-SIG (solid shape): outline of 181 points within 71.22,34.73 84.56,44.91
GND on L7-SIG (solid shape): outline of 177 points within 38.37,41.39 44.52,48.83
GND on L7-SIG (solid shape): 59.12,56.52 59.19,56.62 59.3,56.6 60.03,55.86 60.59,55.31 62.08,55.31 63.34,54.04 65.21,54.04 65.42,53.84 65.44,53.44 65.79,53.25 65.91,53.12 65.91,52.03 65.84,51.95 63.93,51.95 62.86,53.02 62.23,53.02 62,52.79 61.86,52.79 61.86,52.86 61.88,52.88 61.99,53.28 61.68,53.57 61.65,53.59 61.64,53.63 61.44,54.06 60.97,54.01 60.94,54 60.62,54.11 60.31,53.98 60.28,53.99 60.01,54.09 59.75,53.98 59.72,53.97 59.41,54.09 59.11,53.97 59.07,53.98 58.52,53.97 58.49,53.42 58.5,53.39 58.48,53.35 58.38,53.15 58.39,52.93 58.38,52.84 58.3,52.79 58.14,52.79 57.3,53.63 57.28,53.68 57.28,53.72 57.27,53.75 57.29,53.84 57.37,53.88 58.14,53.88 58.38,54.13 58.38,54.12 59.12,54.87
GND on L7-SIG (solid shape): outline of 173 points within 31.88,38.16 38.83,43.19
GND on L7-SIG (solid shape): outline of 212 points within 39.01,8.77 48.08,21.87
GND on L7-SIG (solid shape): outline of 85 points within 21.82,7.09 26.14,50.63
GND on L7-SIG (solid shape): outline of 212 points within 83.16,3.95 87.83,10.55
GND on L7-SIG (solid shape): outline of 223 points within 29.12,85.2 43.38,104.09
GND on L7-SIG (solid shape): outline of 286 points within 64.3,18.88 77.99,24.46
GND on L7-SIG (solid shape): outline of 296 points within 80.03,93.69 87.82,101.99
GND on L7-SIG (solid shape): outline of 355 points within 67.31,37.43 86.26,54.21
GND on L7-SIG (solid shape): outline of 398 points within 23.47,11.57 33.6,40.93
GND on L7-SIG (solid shape): outline of 411 points within 25.98,42.14 38.25,50.48
GND on L7-SIG (solid shape): outline of 478 points within 47.4,45.26 79.1,56.7
GND on L7-SIG (solid shape): outline of 931 points within 30.05,1.57 53.83,11.21
GND on L7-SIG (solid shape): outline of 1100 points within 15.55,77.8 35.1,101.8
GND on L7-SIG (solid shape): outline of 1306 points within 45.92,2.74 80,13.7
GND on L7-SIG (solid shape): outline of 1403 points within 28.1,9.43 51.69,39.13
GND on L7-SIG (solid shape): outline of 3326 points within 43.36,22.98 81.36,48.5
GND on L7-SIG (solid shape): outline of 9108 points within 0.51,0.51 101.1,124.29
GND_SIGNAL on L4-SIG (solid shape): outline of 115 points within 54.04,32.55 65.18,39.07
V3.3_LVDS_AVDD on BOTTOM (solid shape): 61.24,7.38 61.24,4.25 60.71,3.72 60.71,2.75 60.66,2.7 60.35,2.7 60.3,2.75 60.3,4 60.58,4.28 60.58,7.5 60.68,7.6 61.01,7.6
V3.3_LVDS_AVDD on BOTTOM (solid shape): 53.24,14.61 53.24,14.11 53.37,13.98 54.84,13.98 54.94,13.88 54.94,11.74 54.84,11.64 53.52,11.64 53.32,11.85 53.32,12.79 53.24,12.86 52.81,12.86 52.71,12.96 52.71,14.59 52.76,14.64 53.21,14.64
V3.3_LVDS_AVDD on L2-SIG (solid shape): 54.9,11.95 54.9,11.26 58.51,7.64 61.18,7.64 61.47,7.36 61.47,6 61.24,5.78 57.43,5.78 53.01,10.2 53.01,11.83 53.39,12.21 54.64,12.21
VDD_WL_PA on BOTTOM (solid shape): 16.84,91.98 16.84,89.04 16.75,88.95 15.91,88.95 15.62,89.24 15.62,89.52 15.52,89.62 15.09,89.62 14.99,89.72 14.99,89.92 15.46,89.92 15.55,90.01 15.55,90.09 15.49,90.15 14.99,90.15 14.99,90.38 15.06,90.46 15.48,90.46 15.67,90.65 15.67,92.06 15.75,92.14 16.69,92.14
VDD_WL_PA on BOTTOM (solid shape): 3.56,93.49 3.56,90.63 3.75,90.43 4.25,90.43 4.25,90.15 3.74,90.15 3.68,90.09 3.68,90 3.74,89.94 4.25,89.94 4.25,89.65 3.51,89.65 3.4,89.54 3.4,88.66 3.33,88.58 2.36,88.58 2.29,88.66 2.29,89.19 2.26,89.22 2.26,92.9 2.66,93.3 2.66,93.69 2.8,93.83 3.22,93.83
VDD_WL_PA on L5-SIG (solid shape): 4.71,93.44 4.71,92.17 4.58,92.04 2.89,92.04 2.54,92.39 2.54,93.56 2.66,93.67 4.48,93.67
VDD_WL_PA on L5-SIG (solid shape): 16.97,93.23 16.97,90.94 16.79,90.76 15.82,90.76 15.65,90.94 15.65,92.64 15.67,92.67 15.67,93.2 15.8,93.33 16.87,93.33
VDD_WL_PA on L6-GND (solid shape): 3.66,93.2 3.66,92.67 3.48,92.49 2.57,92.49 2.46,92.59 2.46,93.58 2.64,93.76 3.1,93.76
VDD_WL_PA on L6-GND (solid shape): 16.82,91.78 16.82,90.89 16.66,90.74 15.98,90.74 15.75,90.97 15.75,91.86 15.9,92.01 16.59,92.01
+AC_ADAPTER on BOTTOM (solid shape): 36.63,22.08 36.81,22.08 36.81,17.05 36.67,16.91 35.52,16.91 35.1,17.33 35.1,21.85 35.15,21.9 35.5,21.9 35.5,22.3 35.54,22.34 36.37,22.34
+AC_ADAPTER on BOTTOM (solid shape): 68.76,8.52 68.76,7.15 68.58,6.97 68.58,6.59 68.17,6.18 66.43,6.18 66.07,6.54 66.07,7.26 66.27,7.45 66.27,8.24 66.68,8.65 68.63,8.65
+AC_ADAPTER on L2-SIG (solid shape): 69.43,11.49 69.43,6.84 68.69,6.11 63.25,6.11 61.35,8.02 58.65,8.02 57.64,9.03 57.64,11.61 58.18,12.16 68.76,12.16
+AC_ADAPTER on L3-GND (solid shape): 59.5,10.46 59.5,9.04 59.34,8.87 57.98,8.87 57.9,8.96 57.9,10.46 57.99,10.56 59.41,10.56
+AC_ADAPTER on L4-SIG (solid shape): 38.84,16.9 38.84,16.14 38.48,15.78 36.68,15.78 34.52,17.94 34.52,19.11 34.95,19.54 36.2,19.54
+AC_ADAPTER on L4-SIG (solid shape): 59.58,10.61 59.58,9.1 58.83,8.35 56.7,8.35 56.06,9 56.06,10.63 56.52,11.09 59.1,11.09
+BATT_CN on BOTTOM (solid shape): 25.25,44.54 25.25,44.23 25.43,44.05 26.16,44.05 26.47,43.75 26.47,40.62 26.29,40.45 23.39,40.45 22.28,41.56 22.28,45.12 22.61,45.45 24.33,45.45
+BATT_CN on BOTTOM (solid shape): 34.67,33.59 34.67,33.23 33.35,31.91 33.35,29.73 32.92,29.3 29.67,29.3 29.44,29.52 29.44,31.12 29.71,31.4 30.02,31.4 30.02,31.7 30.2,31.89 30.2,32.5 30.35,32.65 31.57,32.65 32.21,33.28 32.21,33.61 32.31,33.72 34.54,33.72
+BATT_CN on L2-SIG (solid shape): outline of 86 points within 22.45,28.89 33.58,44.18
+BATT_CN on L4-SIG (solid shape): outline of 212 points within 23.91,28.89 33.03,44.18
+BATT_CN on L7-SIG (solid shape): 24.1,45.33 24.76,45.33 26.24,43.84 26.24,40.9 25.73,40.39 24.34,40.39 23.37,41.36 23.37,45.22 23.5,45.35 24.08,45.35
+DC_IN_12V on BOTTOM (solid shape): 73.33,9.79 73.33,8.16 73.56,7.93 73.56,7.58 73.33,7.35 73.33,5.24 73.06,4.98 71.41,4.98 69.89,6.5 69.89,8.38 70.61,9.1 72.14,9.1 72.47,9.43 72.47,9.81 72.62,9.97 73.15,9.97
+ENPVCC on BOTTOM (solid shape): 56.34,19.21 56.34,17.99 56.19,17.84 53.9,17.84 53.72,18.02 53.72,18.5 53.57,18.65 53.24,18.65 53.19,18.7 53.19,19.29 53.24,19.34 56.21,19.34
+ENPVCC on L7-SIG (solid shape): 54.66,18.15 54.66,17.43 54.43,17.21 53.32,17.21 52.48,16.37 52.48,14.31 52.3,14.13 51.74,14.13 51.49,14.39 51.49,16.85 52.99,18.35 54.46,18.35
+SW_OUT on BOTTOM (solid shape): 74.75,23.3 74.75,20.81 74.5,20.56 73.84,20.56 73.53,20.25 72.82,20.25 72.75,20.33 72.75,20.46 73.18,20.89 73.18,23.4 73.43,23.66 74.4,23.66
+V_VCC on BOTTOM (solid shape): 69.25,53.84 69.25,52.98 69.1,52.83 68.45,52.83 68.45,52.82 68.4,52.77 68.4,52.33 68.25,52.18 68.25,51.37 68.05,51.17 66.17,51.17 66.04,51.29 66.04,51.9 65.99,51.95 65.99,53.2 65.84,53.35 65.84,53.37 65.82,53.37 65.79,53.4 65.69,53.4 65.44,53.64 65.44,53.97 65.61,54.14 68.96,54.14
+V_VCC on BOTTOM (solid shape): outline of 150 points within 51.84,70.74 54.54,72.95
+V_VCC on BOTTOM (solid shape): outline of 465 points within 55.09,64.91 63.61,72.95
+V_VCC on L2-SIG (solid shape): outline of 469 points within 51.94,51.75 73,73.72
+V_VCC on L3-GND (solid shape): 53.17,72.07 55.31,72.07 56.53,70.85 57.6,70.85 58.04,70.41 58.04,69.72 57.6,69.27 57.06,69.27 56.22,70.11 53.34,70.11 52.01,71.44 52.01,72.13 52.34,72.46 52.78,72.46
+V_VCC on L4-SIG (solid shape): 53.25,71.78 53.34,71.78 53.4,71.71 55.56,71.71 56.24,71.03 56.31,71.03 56.37,70.96 56.39,70.96 56.67,70.68 56.7,70.68 56.7,70.68 57.77,70.68 57.96,70.5 57.96,69.73 57.65,69.42 56.92,69.42 56.29,70.04 53.4,70.04 52.27,71.17 52.27,72.3 52.32,72.35 52.68,72.35
+V_VCC on L5-SIG (solid shape): 53.28,73.09 53.54,72.96 53.8,73.07 53.82,73.09 53.88,73.09 53.95,73.06 53.98,72.99 54.09,72.76 54.33,72.68 54.39,72.66 54.43,72.6 54.74,72.29 55.16,72.29 55.6,72.74 56.34,72.74 57.4,71.68 57.4,71.42 57.45,71.02 57.85,70.97 58.24,70.97 58.3,70.85 58.41,70.76 58.46,70.74 58.51,70.73 58.54,70.73 58.6,70.73 58.66,70.66 58.66,70.42 58.35,70.11 57.74,70.11 57.5,70.11 56.95,69.55 56.82,69.55 56.57,69.8 56.32,70.05 54.72,70.05 54.19,70.58 54.16,70.58 54.04,70.66 53.9,70.69 52.69,70.69 52.64,70.64 52.18,71.1 52.18,72.31 52.3,72.43 52.3,72.69 52.71,73.09
+V_VCC on L7-SIG (solid shape): outline of 230 points within 52.83,70.26 57.43,72.97
+V_VCC_PMIC on BOTTOM (solid shape): 63.63,51.93 63.63,51.85 63.86,51.62 65.35,51.62 65.96,51.01 68.17,51.01 68.4,51.24 68.4,51.6 68.61,51.8 68.94,51.8 69.16,51.57 69.16,44.03 69.11,43.94 69,43.95 68.35,43.63 69,43.3 69.11,43.31 69.16,43.22 69.16,42.63 69.11,42.58 69.11,42.22 69.05,42.16 69.05,39.63 69.52,39.16 69.52,35.29 69.39,35.16 68.68,35.16 68.5,35.34 67.34,35.34 66.52,36.15 66.52,39.88 66.31,40.1 66.31,41.97 65.81,42.47 65.81,43.2 65.69,43.32 65.18,43.32 65.18,43.41 65.32,43.55 65.34,43.55 65.46,44.33 65.01,43.67 64.87,43.53 64.87,43.5 64.84,43.46 64.79,43.47 64.77,43.48 59.71,43.48 59.43,43.76 59.43,45.76 59.83,46.16 61.9,46.16 62.08,46.34 62.08,50.61 62.15,50.68 62.71,50.68 62.99,50.96 62.99,51.93 63.12,52.05 63.5,52.05
+V_VNN on BOTTOM (solid shape): 62.36,53.91 62.36,52.94 62.24,52.83 61.41,52.83 61.16,52.59 61.16,51.13 61.04,51 59.12,51 59.06,51.07 59.06,52.36 58.59,52.83 58.59,52.9 58.57,52.9 58.41,53.07 58.41,53.82 58.7,54.11 62.15,54.11
+V_VNN on BOTTOM (solid shape): outline of 132 points within 42.67,59.8 48.23,67.02
+V_VNN on BOTTOM (solid shape): outline of 1010 points within 49.34,67.87 57,74.05
+V_VNN on L2-SIG (solid shape): outline of 202 points within 42.34,50.4 61.93,71.92
+V_VNN on L3-GND (solid shape): 53.33,69.9 56.24,69.9 56.95,69.19 56.95,69.17 57.44,68.68 57.44,67.01 57.19,66.76 51.12,66.76 50.23,67.65 56.49,67.65 56.49,67.6 56.5,67.54 56.51,67.49 56.54,67.45 56.57,67.41 56.61,67.37 56.65,67.34 56.69,67.31 56.74,67.3 56.79,67.29 56.85,67.29 56.9,67.3 56.95,67.31 56.99,67.34 57.04,67.37 57.07,67.41 57.1,67.45 57.13,67.49 57.14,67.54 57.15,67.6 57.15,67.65 57.14,67.7 57.13,67.75 57.1,67.79 57.07,67.84 57.04,67.87 56.99,67.9 56.95,67.93 56.9,67.94 56.85,67.95 56.79,67.95 56.74,67.94 56.69,67.93 56.65,67.9 56.61,67.87 56.57,67.84 56.54,67.79 56.51,67.75 56.5,67.7 56.49,67.65 50.23,67.65 49.7,68.17 49.7,68.3 49.11,68.88 49.1,68.88 49.1,70.87 49.69,71.45 51.78,71.45
+V_VNN on L4-SIG (solid shape): 52.12,71.1 52.16,71.1 53.34,69.92 56.24,69.92 57.44,68.72 57.44,67.01 57.19,66.76 51.08,66.76 50.22,67.62 56.49,67.62 56.49,67.6 56.5,67.54 56.51,67.49 56.54,67.45 56.57,67.41 56.61,67.37 56.65,67.34 56.69,67.31 56.74,67.3 56.79,67.29 56.85,67.29 56.9,67.3 56.95,67.31 56.99,67.34 57.04,67.37 57.07,67.41 57.1,67.45 57.13,67.49 57.14,67.54 57.15,67.6 57.15,67.65 57.14,67.7 57.13,67.75 57.1,67.79 57.07,67.84 57.04,67.87 56.99,67.9 56.95,67.93 56.9,67.94 56.85,67.95 56.79,67.95 56.74,67.94 56.69,67.93 56.65,67.9 56.61,67.87 56.57,67.84 56.54,67.79 56.51,67.75 56.5,67.7 56.49,67.65 56.49,67.62 50.22,67.62 49.68,68.16 49.68,68.31 49.11,68.88 49.11,70.91 49.58,71.38 49.58,71.38 49.67,71.48 51.74,71.48
+V_VNN on L5-SIG (solid shape): 51.22,73.14 51.22,68.33 50.83,67.94 49.93,67.94 49.48,68.38 49.48,68.82 49.48,68.83 49.48,71 49.46,71.01 49.46,72.31 49.95,72.79 49.95,73.02 49.99,73.06 50.68,73.06 50.88,73.26 51.11,73.26
+V_VNN on L5-SIG (solid shape): 54.59,69.89 56.25,69.89 56.46,69.68 56.92,69.22 56.92,68.83 55.87,67.78 52.86,67.78 52.64,68 52.64,69.64 52.98,69.98 53.9,69.98 54.02,70 54.12,70.05 54.42,70.05
+V_VNN on L7-SIG (solid shape): outline of 1061 points within 48.74,67.71 56.85,74.05
+V_VNN_PMIC on BOTTOM (solid shape): 58.93,52.31 58.93,51.01 59.28,50.66 59.28,45.83 59.23,45.78 59.23,44.82 59.06,44.64 59,44.64 59,43.67 58.54,43.21 51.45,43.21 51.23,43 51.23,39.49 50.93,39.19 50.01,39.19 49.84,39.01 49.84,37.2 49.58,36.94 48.39,36.94 48.03,37.3 48.03,38.39 47.87,38.55 47.87,40.14 47.63,40.38 47.63,41.49 48.14,41.49 48.52,41.87 48.52,42.18 48.52,42.22 48.52,43.1 48.53,43.11 48.53,50.57 48.22,50.88 48.22,50.92 48.17,50.92 47.85,51.24 47.85,51.5 47.98,51.62 53.44,51.62 53.82,52 56.01,52 56.87,52.87 58.37,52.87
+VHDMI on BOTTOM (solid shape): 87.83,36.87 87.83,36.43 87.61,36.2 86.54,36.2 86.31,36.43 86.31,36.92 86.46,37.07 87.63,37.07
+VHDMI_OUT on BOTTOM (solid shape): 93.02,37.68 93.02,36.63 92.48,36.08 89.97,36.08 89.85,36.2 89.1,36.2 88.98,36.08 88.98,35.54 88.91,35.48 88.63,35.48 88.63,35.47 88.05,35.47 87.96,35.56 87.96,36.75 88.11,36.9 89.02,36.9 89.05,36.87 89.05,36.81 89.17,36.69 90.22,36.69 90.63,37.1 91.61,37.1 92.33,37.82 92.88,37.82
+VNN_LX0 on BOTTOM (solid shape): 58.93,42.53 58.93,41.88 58.85,41.81 57.24,41.81 57.05,42 57.05,42.5 57.2,42.66 58.8,42.66
+VNN_LX0 on BOTTOM (solid shape): 58.9,40.13 58.9,37.69 58.79,37.59 58.69,37.59 58.6,37.68 58.6,38.09 58.57,38.12 58.57,38.52 58.46,38.63 58.46,39.98 58.67,40.18 58.84,40.18
+VNN_LX1 on BOTTOM (solid shape): 56.87,42.4 56.87,41.83 56.77,41.73 55.04,41.73 54.79,41.98 54.79,42.55 54.94,42.71 56.57,42.71
+VNN_LX2 on BOTTOM (solid shape): 54.12,42.48 54.12,42.15 55.43,40.85 55.43,40.6 55.42,40.6 55.42,39.33 56.82,37.93 56.82,37.75 56.72,37.65 56.67,37.65 56.53,37.79 56.53,37.8 56.4,37.94 56.21,37.92 56.2,37.92 55.85,38.28 55.66,38.28 54.72,39.22 54.72,39.73 54.61,39.83 54.61,39.84 54.58,39.87 54.58,39.89 52.92,41.55 52.09,41.55 51.66,41.98 51.66,42.84 51.73,42.92 53.69,42.92
+VNN_LX3 on BOTTOM (solid shape): 54.48,39.79 54.48,39.78 54.59,39.67 54.59,39.17 55.43,38.33 55.43,37.56 55.68,37.32 55.76,37.16 55.93,37.09 56,37.07 56.03,36.99 56.03,36.87 55.99,36.83 55.75,36.83 54.06,38.53 54.06,38.68 53.57,39.18 52.02,39.18 51.72,39.48 51.72,40.98 51.87,41.13 53.14,41.13
+VNN_LX4 on BOTTOM (solid shape): 51.16,38.86 51.16,37.03 51.11,36.98 50.34,36.98 50.24,37.08 50.24,38.91 50.32,38.99 51.03,38.99
+VNN_LX4 on BOTTOM (solid shape): 55.27,36.31 55.84,36.31 55.87,36.3 56.06,36.11 56.06,36.06 56.02,36.02 54.97,36.02 54.59,36.39 54.59,36.69 54.66,36.76 54.81,36.76
+VREF25 on L6-GND (solid shape): 63.17,31.18 64.19,31.18 64.24,31.12 64.24,30.92 64.21,30.9 63.68,30.9 63.67,30.91 62.83,30.91 62,31.73 62,31.84 62.1,31.94 62.41,31.94
+VREFDQ_0_PMIC on BOTTOM (solid shape): 46.56,43.75 46.56,43.22 46.23,42.88 46.23,41.64 46.18,41.59 45.24,41.59 45.19,41.64 45.19,43.32 45.64,43.77 46.53,43.77
+VREFDQ_1_PMIC on BOTTOM (solid shape): 47.35,43.77 47.35,43.04 47.55,42.83 48.11,42.83 48.39,42.55 48.39,41.92 48.08,41.61 46.56,41.61 46.41,41.77 46.41,42.86 46.76,43.22 46.76,43.72 46.84,43.8 47.32,43.8
+VSDIO on BOTTOM (solid shape): 45.15,69.79 45.24,69.67 45.38,69.6 45.39,69.6 45.49,69.5 45.52,69.45 45.56,69.42 45.6,69.39 45.6,69.26 45.56,69.23 45.53,69.19 45.52,69.17 44.45,69.17 44.14,68.86 44.04,68.86 43.93,68.97 43.93,69.47 44.28,69.83 45.14,69.83
+VSDIO on L7-SIG (solid shape): 44.33,68.94 44.33,68.37 43.93,67.96 43.03,67.96 43.03,68.17 43.14,68.28 43.42,68.28 43.42,68.24 43.43,68.2 43.45,68.16 43.48,68.13 43.51,68.1 43.54,68.08 43.58,68.07 43.62,68.06 43.66,68.06 43.7,68.07 43.74,68.09 43.78,68.11 43.8,68.14 43.83,68.18 43.84,68.22 43.85,68.26 43.85,68.3 43.84,68.34 43.83,68.38 43.8,68.41 43.78,68.44 43.74,68.47 43.7,68.48 43.66,68.49 43.62,68.49 43.58,68.49 43.54,68.47 43.51,68.45 43.48,68.43 43.45,68.39 43.43,68.36 43.42,68.32 43.42,68.28 43.14,68.28 43.22,68.36 43.24,68.36 43.45,68.59 44.01,69.15 44.13,69.15
+VSYS on BOTTOM (solid shape): 65.2,38.52 65.2,38.06 65.15,38.01 62.87,38.01 62.51,37.65 62.36,37.65 62.23,37.78 62.23,38.08 62.84,38.69 65.02,38.69
+VSYS on BOTTOM (solid shape): 54.4,34.69 55.92,34.69 56,34.6 56,34.46 55.94,34.4 52.71,34.4 52.4,34.71 52.4,35.04 52.55,35.19 53.9,35.19
+VSYS on BOTTOM (solid shape): 56.11,39.33 56.93,38.51 56.93,38.4 56.87,38.34 56.65,38.34 55.58,39.42 55.58,41.46 56.11,41.46
+VSYS on BOTTOM (solid shape): 56.44,33.79 56.44,33.69 56.39,33.64 55.19,33.64 54.22,32.66 53.52,32.66 53.3,32.45 52.48,32.45 52.39,32.53 52.39,33.17 52.48,33.26 54.31,33.26 54.89,33.84 56.39,33.84
+VSYS on BOTTOM (solid shape): 60.94,41.31 60.94,39.2 60.71,38.97 60.71,38.39 60.51,38.2 60.3,38.2 60.3,39.25 60.45,39.41 60.45,41.28 60.55,41.39 60.86,41.39
+VSYS on BOTTOM (solid shape): 65.95,28.66 65.95,27.77 65.84,27.66 64.83,27.66 64.69,27.52 64.69,26.88 64.54,26.73 63.04,26.73 62.69,27.09 62.69,28.03 63.28,28.62 64.8,28.62 64.94,28.76 65.85,28.76
+VSYS on BOTTOM (solid shape): 32.97,15.45 32.97,15.35 33.22,15.1 33.78,15.1 33.91,14.97 33.91,14.41 33.66,14.16 33.2,14.16 32.97,13.93 32.97,13.37 32.79,13.19 31.78,13.19 31.45,13.52 31.45,15.61 31.55,15.71 32.72,15.71
+VSYS on BOTTOM (solid shape): 55.72,36.67 55.98,36.67 56.05,36.59 56.05,36.56 56.06,36.53 56.06,36.5 55.98,36.42 55.95,36.45 55.87,36.47 55.4,36.47 53.61,38.26 51.67,38.26 51.44,38.49 51.44,38.85 51.54,38.95 53.44,38.95
+VSYS on BOTTOM (solid shape): 40.06,16.29 40.06,12.61 39.5,12.05 38.02,12.05 37.62,12.46 37.62,13.58 37.82,13.93 37.62,14.28 37.62,15.83 38.25,16.47 39.88,16.47
+VSYS on BOTTOM (solid shape): 59.65,32.61 59.65,31.41 60.94,30.12 60.94,29.25 60.81,29.12 60.45,29.12 60.35,29.22 60.35,30.03 59.46,30.92 59.46,32.08 59.45,32.11 59.44,32.14 59.45,32.16 59.46,32.19 59.46,32.48 59.44,32.59 59.48,32.63 59.53,32.64 59.62,32.64
+VSYS on BOTTOM (solid shape): 57.42,32.24 57.5,32.27 57.58,32.27 57.6,32.26 57.66,32.2 57.66,31.4 57.44,31.18 57.44,30.06 57.18,29.8 56.67,29.8 56.52,29.96 56.52,30.87 57.35,31.7 57.35,31.95 57.36,31.98 57.38,32 57.38,32.03 57.39,32.04 57.4,32.1 57.4,32.15
+VSYS on BOTTOM (solid shape): 61.57,35.01 63.14,35.01 63.2,34.96 64.39,34.96 64.42,34.93 64.42,34.47 64.36,34.41 62.8,34.41 62.79,34.4 62.64,34.4 62.57,34.33 62.43,34.33 62.12,34.64 61.77,34.64 61.61,34.79 61.52,34.79 61.49,34.79 61.45,34.78 61.4,34.82 61.38,34.87 61.39,34.92 61.39,34.96 61.42,35.01 61.48,35.03
+VSYS on BOTTOM (solid shape): 71.7,40.65 71.81,40.27 72.19,40.16 72.72,39.63 72.72,38.85 72.71,38.83 72.71,38.15 72.85,38.01 72.85,36.97 73.03,36.79 73.03,36.23 72.9,36.1 72.14,36.1 72.06,36.03 71.07,36.03 70.99,36.1 70.99,36.28 71.15,36.43 71.91,36.43 72.11,36.64 72.11,38.14 71.98,38.26 71.17,38.26 71.02,38.41 71.02,39.48 70.84,39.66 70.49,39.66 70.31,39.84 70.31,40.6 70.38,40.68 71.68,40.68
+VSYS on BOTTOM (solid shape): 36.4,41.21 36.45,41.21 36.58,41.08 36.58,40.22 36.91,39.89 38.76,39.89 39.14,39.51 39.14,36.84 38.89,36.59 38.89,32.8 36.04,29.96 36.04,28.48 35.18,27.62 34.65,27.62 34.34,27.31 34.34,24.98 33.59,24.98 33.59,25.82 33.5,25.9 33.5,31.71 35.08,33.28 35.08,36.64 35.46,37.02 36.78,37.02 37.41,37.65 38.3,37.65 38.41,37.75 38.41,38.9 38.18,39.13 36.5,39.13 36.07,39.56 36.07,40.62 35.94,40.75 35.94,40.78 35.33,40.78 35.18,40.93 35.18,41.21 35.23,41.26 36.35,41.26
+VSYS on BOTTOM (solid shape): 62.12,34.17 62.09,33.8 62.41,33.61 62.48,33.61 62.62,33.55 62.77,33.6 64.94,33.6 64.97,33.56 64.97,33.06 62.79,33.06 62.56,33.28 62.21,33.28 61.9,33.59 61.04,33.59 61,33.63 60.99,33.68 60.99,33.79 61,33.84 61.04,33.88 61.14,33.87 61.25,33.9 61.4,34.05 61.4,34.19 61.41,34.23 62.06,34.23
+VSYS on L3-GND (solid shape): 68.61,40.5 68.61,39.79 68.48,39.66 67.23,39.66 67.03,39.86 67.03,40.47 67.23,40.68 68.43,40.68
+VSYS on L4-SIG (solid shape): 36.63,15.25 37.66,15.25 39.24,13.67 39.24,12.43 38.7,11.9 36.12,11.9 34.86,13.15 32.38,13.15 32.1,13.43 32.1,15.26 32.57,15.73 36.14,15.73
+VSYS on L4-SIG (solid shape): outline of 860 points within 48.82,26.96 72.87,43.72
+VSYS on L5-SIG (solid shape): outline of 772 points within 30.31,12.1 53.69,37.02
+VSYS on L6-GND (solid shape): 53.14,39.23 53.14,38.31 52.96,38.14 51.28,38.14 50.85,38.57 50.85,39.1 51.13,39.38 52.99,39.38
+VSYS on L6-GND (solid shape): 53.67,32.57 53.67,32.06 53.59,31.99 52.5,31.99 52.27,32.22 52.27,32.6 52.43,32.75 53.49,32.75
+VSYS on L6-GND (solid shape): 52.73,35.21 53.39,35.21 53.49,35.11 53.49,34.82 53.33,34.66 51.97,34.66 51.87,34.76 51.87,35.47 51.99,35.6 52.35,35.6
+VSYS on L6-GND (solid shape): 61.01,29.8 61.01,29.25 60.33,28.56 59.97,28.56 59.92,28.61 59.92,29.45 60.22,29.75 60.22,30.13 60.25,30.16 60.66,30.16
+VSYS on L6-GND (solid shape): 65.3,39.89 65.3,38.21 65.08,37.98 63.15,37.98 63.09,38.03 63.09,38.41 63.2,38.52 63.5,38.52 63.68,38.69 63.68,39.84 63.86,40.01 65.18,40.01
+VSYS on L6-GND (solid shape): 64.37,34.86 64.39,34.86 64.47,34.78 65.71,34.78 65.94,34.55 65.94,33.59 65.46,33.11 64.21,33.11 64.11,33.21 64.11,33.89 63.48,34.53 63.48,34.88 63.55,34.96 64.27,34.96
+VSYS on L6-GND (solid shape): 72.8,40.45 72.8,38.49 72.44,38.14 71.37,38.14 70.92,38.59 70.92,39.13 70.66,39.38 70.66,40.52 70.82,40.68 72.57,40.68
