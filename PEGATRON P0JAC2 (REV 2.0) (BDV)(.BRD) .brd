# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
42_M0_DATA32: length 23.3
  L5-SIG w0.06: v6(57.11,76.45) 57.06,76.4 56.83,76.4 56.75,76.48 56.75,76.59 56.83,76.67 57,76.67 57.09,76.76 57.09,76.9 57.02,76.97 56.91,76.97 56.75,77.13 56.75,77.64 57.62,78.5 57.62,78.62
  L5-SIG w0.076: 62.15,90.25 63.11,91.21 63.11,91.63 63.65,92.18 63.65,92.23 63.35,92.53 v1(63.28,92.53)
  L5-SIG w0.109: 62.05,88.26 62.12,88.33 62.12,88.47 61.99,88.61 61.99,88.74 62.12,88.87 62.12,89 61.94,89.18 61.94,89.33 62.17,89.56 62.17,89.8 62.08,89.89 61.75,89.89 61.59,90.05 61.59,90.18 61.66,90.25 62.15,90.25 ; 60.07,80.46 59.39,79.79 58.96,79.79 58.76,79.99 58.53,79.99 57.62,79.08 57.62,78.62
  L5-SIG w0.127: 60.07,80.46 60.31,80.71 60.46,80.71 60.66,80.5 60.85,80.5 60.97,80.62 60.97,80.75 60.71,81 60.71,81.12 60.91,81.32 60.91,85.37 61.56,86.03 61.91,86.03 62.01,86.14 62.01,86.46 61.92,86.55 61.92,86.78 62.01,86.87 62.01,87.14 61.92,87.23 61.92,87.42 62.07,87.57 62.07,87.77 61.93,87.91 61.93,88.14 62.05,88.26
42_M0_DATA33: length 23.4
  L5-SIG w0.06: 57.79,78.51 56.87,77.59 56.87,77.29 57.21,76.95 57.21,76.83 57.52,76.52 57.52,76.11 v6(57.17,75.77)
  L5-SIG w0.076: 62.35,90.08 62.35,90.24 63.26,91.14 63.26,91.57 63.92,92.23 63.92,92.42 63.84,92.5 63.61,92.5 63.51,92.59 63.51,92.72 63.61,92.81 63.77,92.81 63.9,92.94 63.9,93.18 63.77,93.31 63.53,93.31 63.41,93.18 v1(63.41,93)
  L5-SIG w0.109: 57.79,78.51 57.79,79.01 58.39,79.61 59.5,79.61 60.18,80.29 60.92,80.29 61.19,80.56 61.19,81.82 ; 62.35,88.26 62.35,90.08
  L5-SIG w0.127: 61.19,81.82 61.19,85.26 61.67,85.74 62.14,85.74 62.29,85.89 62.29,86.79 62.35,86.85 62.35,88.26
42_M0_DATA34: length 24.1
  L5-SIG w0.06: v6(55.68,76.08) 55.57,76.08 55.5,76.15 55.5,76.26 55.6,76.36 55.6,76.51 55.48,76.63 55.48,76.8 55.56,76.87 55.56,76.87 55.68,76.99 55.7,76.99 55.92,77.21 55.92,77.4 55.84,77.47 55.84,77.52 55.8,77.56 55.7,77.56 55.66,77.6 55.66,78.42 55.69,78.45
  L5-SIG w0.109: 55.69,78.45 55.76,78.52 55.93,78.52 56.01,78.6 56.01,78.75 56.08,78.82 56.25,78.82 56.35,78.92 56.35,79.55 58.73,81.94 58.73,82.32 ; 59.24,92.82 59.53,92.82 59.7,92.65 59.89,92.65 60.08,92.84 60.28,92.84 60.45,92.67 60.62,92.67 60.8,92.84 60.81,92.84 60.82,92.86 60.93,92.86 61,92.78 61,92.72 61.09,92.63 61.09,92.49 61,92.4 61,92.29 60.93,92.21 60.66,92.21 60.58,92.14 60.58,91.81 60.65,91.74 60.74,91.74 60.83,91.83 61.05,91.83 61.15,91.74 61.44,91.74 61.68,91.98 v1(61.86,91.98)
  L5-SIG w0.127: 59.24,92.82 59.06,92.82 58.73,92.5 58.73,82.32
42_M0_DATA35: length 23.7
  L5-SIG w0.06: v6(56.52,76.38) 56.63,76.5 56.63,76.64 56.77,76.78 56.77,76.94 56.63,77.08 56.63,77.74 56.81,77.91
  L5-SIG w0.076: v1(62.92,92.48) 62.92,92.34 62.98,92.28 63.32,92.28 63.39,92.21 63.39,92.13 63.33,92.06 63.19,92.06 63.14,92.02 63.14,91.88 62.96,91.7 62.96,91.27 62.41,90.72 62.26,90.72 62.02,90.47
  L5-SIG w0.109: 60.57,81.38 60.57,81.23 60.36,81.02 60.12,81.02 59.97,80.86 59.97,80.63 59.79,80.45 59.68,80.45 59.37,80.76 59.2,80.76 59.09,80.66 59.09,80.52 59.4,80.21 59.4,80.1 59.27,79.96 59.1,79.96 58.76,80.3 58.6,80.3 57.44,79.14 57.44,78.54 56.81,77.91
  L5-SIG w0.127: 60.57,81.38 60.57,85.62 60.68,85.74 60.88,85.74 61.64,86.5 61.64,87.29 61.46,87.48 61.46,87.6 61.64,87.79 61.64,89.06 61.5,89.2 61.12,89.2 61.03,89.29 61.03,89.63 61.12,89.72 61.29,89.72 61.41,89.83 61.41,89.98 61.32,90.07 61.14,90.07 61.05,90.16 61.05,90.37 61.15,90.47 62.02,90.47
42_M0_DATA36: length 24
  L5-SIG w0.06: 56.6,77.96 56.51,77.88 56.51,76.97 56.54,76.94 56.61,76.94 56.64,76.9 56.64,76.82 56.58,76.75 56.5,76.75 56.45,76.71 56.45,76.62 56.22,76.38 56.22,76.21 56.26,76.17 56.45,76.17 56.52,76.1 56.52,75.86 v6(56.45,75.8)
  L5-SIG w0.076: v1(62.9,92.02) 62.81,91.93 62.81,91.33 62.36,90.89 62.19,90.89 62.01,90.71 61.42,90.71
  L5-SIG w0.109: 60.29,82.33 60.29,82.07 60.19,81.98 60.19,81.78 60.29,81.68 60.29,81.42 60.2,81.33 60.02,81.33 59.82,81.13 59.82,80.95 59.71,80.84 59.55,80.84 59.31,81.08 59.14,81.08 58.88,80.82 58.88,80.56 58.79,80.47 58.53,80.47 57.26,79.2 57.26,78.62 56.6,77.96
  L5-SIG w0.127: 60.29,82.33 60.29,85.95 60.36,86.02 60.76,86.02 61.36,86.62 61.36,87.18 61.16,87.38 61.16,87.7 61.36,87.9 61.36,88.84 61.26,88.94 60.78,88.94 60.67,89.05 60.67,89.22 60.83,89.38 60.83,90.24 60.73,90.34 60.11,90.34 60,90.45 60,90.59 60.12,90.71 61.42,90.71
42_M0_DATA37: length 24.9
  L5-SIG w0.06: 55.61,78.61 55.61,78.61 55.56,78.56 55.56,78.55 55.53,78.52 55.53,77.49 v6(55.69,77.34)
  L5-SIG w0.076: v1(62.24,92) 62.24,92.21 62.21,92.24 61.77,92.24 61.77,92.22
  L5-SIG w0.109: 55.61,78.61 55.85,78.85 55.86,78.85 56.14,79.13 56.14,79.14 56.17,79.17 56.17,79.65 58.45,81.94 58.45,82.21 ; 61.77,92.22 61.64,92.22 61.35,91.93 61.24,91.93 61.19,91.98 61.19,92.33 61.35,92.49 61.35,92.63 61.19,92.79 61.19,92.88 61.28,92.97 61.62,92.97 61.79,92.8 61.94,92.8 62.22,93.09 62.22,93.22 62.16,93.28 61.99,93.28 61.91,93.2 61.81,93.2 61.72,93.28 60.99,93.28 60.73,93.03 59.61,93.03
  L5-SIG w0.127: 59.61,93.03 59.41,93.23 58.79,93.23 58.45,92.89 58.45,82.21
42_M0_DATA38: length 24
  L5-SIG w0.06: v6(55.69,76.71) 55.69,76.81 56.03,77.16 56.03,77.45 55.96,77.52 55.96,77.61 55.8,77.77
  L5-SIG w0.076: v1(62.25,91.56) 62.28,91.59 62.28,91.7 62.23,91.76 62.14,91.76 62.11,91.78 62.03,91.78 61.97,91.72 61.69,91.72
  L5-SIG w0.109: 61.69,91.72 61.52,91.55 60.55,91.55 60.4,91.7 60.4,92.21 60.48,92.29 60.48,92.38 60.38,92.48 60.24,92.62 60.12,92.62 60,92.5 60,91.71 59.89,91.6 59.49,91.6 59.39,91.7 59.39,91.93 59.63,92.18 59.63,92.46 59.5,92.59 59.31,92.59 59.12,92.4 ; 55.8,77.77 55.8,77.86 55.91,77.96 55.91,78.09 55.8,78.19 55.8,78.29 55.86,78.35 56.02,78.35 56.52,78.85 56.52,79.43 59.01,81.92 59.01,82.33
  L5-SIG w0.127: 59.01,82.33 59.01,92.29 59.12,92.4
42_M0_DATA39: length 25.1
  L5-SIG w0.06: 56.12,77.98 56.12,77.66 56.15,77.62 56.15,77.11 55.89,76.85 55.89,76.63 55.75,76.48 55.75,76.38 55.93,76.19 56.06,76.19 56.22,76.03 56.22,75.64 56.28,75.57 57.1,75.57 57.23,75.45 57.23,75.23 57.41,75.05 57.41,74.91 57.3,74.8 56.98,74.8 56.92,74.86 56.92,75.2 56.86,75.26 56.05,75.26 55.97,75.35 55.97,75.51 55.86,75.62 55.86,75.77 v6(55.96,75.87)
  L5-SIG w0.109: 59.29,82.33 59.29,81.94 56.72,79.37 56.72,78.81 56.12,78.21 56.12,77.98 ; 59.29,91.17 59.48,91.37 61.74,91.37 v1(61.85,91.48)
  L5-SIG w0.127: 59.29,82.33 59.29,86.5 59.5,86.71 59.5,86.98 59.29,87.19 59.29,87.97 59.56,88.23 59.56,88.38 59.29,88.64 59.29,89.32 59.52,89.55 59.52,89.82 59.29,90.05 59.29,91.17
  BOTTOM w0.203: U1601.P16 62.09,91.28
42_M0_DATA40: length 24.1
  L7-SIG w0.06: 57.52,79.15 57.26,79.15 57.2,79.08 57.2,78.98 56.99,78.77 56.99,78.6 57.11,78.48 57.23,78.36 57.23,78.29 57.2,78.27 57.2,78.16 57.03,77.99 57.03,77.82 56.99,77.78 56.83,77.78 v6(56.82,77.78)
  L7-SIG w0.064: v1(62.42,93.45) 62.48,93.38 62.48,93.3 62.4,93.21 62.19,93.21 62.12,93.14 62.12,92.8 62.05,92.72 61.7,92.72 61.62,92.65 61.62,92.39 61.46,92.23 61.17,92.23 61.11,92.16 61.11,91.71 60.78,91.39 60.78,90.57 60.44,90.24 60.44,89.47 60.8,89.11 60.86,89.11 60.99,89.24 61.08,89.24 61.14,89.19 61.14,89.11 61.09,89.07 61.09,88.55 61.27,88.38 61.27,88.26 61.77,87.75 61.77,81.92 61.54,81.68 61.42,81.68 61.25,81.85 61.12,81.85 60.99,81.72 60.99,81.66 61.19,81.45 61.19,81.26 61.13,81.2 60.98,81.2 60.79,81.39 60.72,81.39 60.55,81.22 60.55,81.17 60.73,80.99 60.73,80.88 60.58,80.72 60.58,79.93 60.54,79.89 60.28,79.89 60.24,79.93 60.24,80.38 60.18,80.44 60.03,80.44 59.95,80.35 59.95,79.98 59.9,79.93 59.67,79.93 59.39,79.65 58.31,79.65 58.17,79.51 58.09,79.51 57.95,79.37 57.95,79.3 57.89,79.23 57.61,79.23 57.52,79.15
42_M0_DATA41: length 24.4
  L7-SIG w0.06: v6(56.8,78.32) 56.8,78.44 56.74,78.5 56.74,78.7 56.6,78.84 56.6,79.23 56.67,79.29 56.79,79.29 56.84,79.35 56.94,79.44 57.42,79.44
  L7-SIG w0.064: 57.42,79.44 57.53,79.56 57.73,79.56 57.81,79.64 57.81,79.91 58.05,80.15 58.5,80.15 58.55,80.1 58.55,80.02 58.6,79.97 59.13,79.97 60.13,80.97 60.13,81.96 60.18,82 60.79,82 60.88,82.1 60.88,82.25 60.81,82.33 60.45,82.33 60.41,82.37 60.41,82.61 60.46,82.65 60.76,82.65 60.84,82.74 60.84,82.91 60.77,82.98 60.49,82.98 60.41,83.06 60.41,83.27 60.44,83.3 60.75,83.3 60.86,83.41 60.86,83.55 60.78,83.63 60.44,83.63 60.35,83.72 60.35,83.83 60.5,83.98 60.77,83.98 61.03,84.23 61.22,84.23 61.29,84.3 61.29,87.55 60.78,88.05 60.78,88.68 60.72,88.74 60.67,88.74 60.55,88.63 60.5,88.63 60.43,88.71 60.43,88.78 60.53,88.88 60.53,88.93 60.45,89.01 60.35,89.01 60.26,88.92 60.15,88.92 60.08,88.98 60.08,90.61 60.13,90.66 60.41,90.66 60.46,90.71 60.46,90.94 60.41,90.99 60.13,90.99 60.07,91.05 60.07,91.24 60.15,91.31 60.4,91.31 60.46,91.37 60.46,91.6 60.79,91.93 60.79,92.46 60.8,92.46 61.33,93 61.47,93 61.67,93.21 61.85,93.21 61.89,93.24 v1(61.89,93.37)
  BOTTOM w0.203: U1601.K16 62.09,93.28
42_M0_DATA42: length 24.6
  L7-SIG w0.06: 57.59,78.3 57.47,78.18 57.47,77.89 v6(57.39,77.81) ; 58.34,79.03 58.42,79.11
  L7-SIG w0.064: v1(63.36,93.48) 63.59,93.25 63.92,93.25 64.07,93.4 64.07,94.07 64.14,94.14 64.42,94.14 64.49,94.07 64.49,93.69 64.7,93.48 64.7,93.31 64.62,93.23 64.36,93.23 64.1,92.97 64.1,92.88 63.96,92.74 63.87,92.74 63.6,92.47 63.6,91.88 63.45,91.72 62.79,91.72 62.66,91.6 62.66,91.25 62.61,91.2 62.61,90.87 62.48,90.74 62.18,90.74 62.08,90.64 62.08,90.11 62.11,90.08 62.11,89.77 61.93,89.58 61.93,88.68 62.52,88.09 62.52,87.38 62.8,87.1 62.8,86.19 62.52,85.91 62.52,85.35 62.64,85.24 62.64,82 62.63,82 62.63,81.96 61.08,80.41 61.08,79.59 60.87,79.38 60.02,79.38 59.63,78.98 58.81,78.98 58.68,79.11 58.42,79.11 ; 57.59,78.3 57.86,78.57 58.14,78.57 58.15,78.59 58.16,78.59 58.34,78.77 58.34,79.03
42_M0_DATA43: length 23.3
  L7-SIG w0.06: 57.54,78.44 57.32,78.22 57.32,78.11 57.16,77.95 57.16,77.65 v6(57.08,77.57)
  L7-SIG w0.064: 57.54,78.44 57.8,78.7 58.04,78.7 58.21,78.87 58.21,79.13 58.43,79.36 58.87,79.36 58.93,79.3 58.93,79.18 58.99,79.12 59.57,79.12 59.69,79.24 59.69,79.31 59.61,79.38 59.61,79.47 59.69,79.55 60.81,79.55 60.9,79.65 60.9,80.49 62.39,81.98 62.39,85.13 62.28,85.25 62.28,86.22 62.36,86.31 62.45,86.31 62.54,86.39 62.54,86.55 62.45,86.63 62.36,86.63 62.28,86.71 62.28,87.92 62.26,87.94 62.26,87.95 61.45,88.76 61.45,88.84 61.77,89.16 61.77,89.23 61.67,89.33 61.67,89.52 61.77,89.62 61.77,89.73 61.62,89.88 61.62,90.18 61.57,90.23 61.17,90.23 61.09,90.31 61.09,91.11 61.22,91.24 62.27,91.24 62.51,91.48 62.51,91.66 62.65,91.8 62.65,92.6 62.79,92.74 63.11,92.74 63.17,92.79 63.17,93.34 63.12,93.38 63.12,93.38 63.06,93.45 v1(62.86,93.45)
42_M0_DATA44: length 24.9
  L7-SIG w0.064: v1(62.36,94.08) 62.2,94.08 61.96,94.33 61.6,94.33 61.52,94.25 ; v6(55.97,78.73) 55.97,79.5 56.16,79.69 56.29,79.69 56.37,79.77 56.37,79.85 56.65,80.13 57.14,80.13 57.81,80.81 58.42,80.81 58.68,81.06 58.68,81.66 58.98,81.96 58.98,87.73 59.01,87.76 59.31,87.76 59.39,87.85 59.39,88.2 59.39,88.27 59.35,88.32 59.18,88.32 59.1,88.41 59.1,88.52 59.39,88.82 59.39,88.88 59.33,88.94 59.09,88.94 58.99,89.04 58.99,89.21 59.06,89.29 59.34,89.29 59.4,89.34 59.4,89.56 59.35,89.61 59.07,89.61 59.01,89.67 59.01,89.9 59.05,89.94 59.33,89.94 59.4,90 59.4,90.2 59.33,90.26 59.06,90.26 59.01,90.32 59.01,90.5 59.04,90.54 59.27,90.54 59.4,90.66 59.4,91.67 59.72,91.99 59.72,92.31 59.79,92.39 60.01,92.39 60.08,92.47 60.08,92.57 60.08,92.69 60.13,92.74 60.19,92.8 60.19,92.93 59.97,93.15 59.97,93.35 60.04,93.42 60.14,93.42 60.41,93.15 60.54,93.15 60.82,93.43 60.82,93.79 60.61,94 60.31,94 60.21,94.1 60.21,94.38 60.3,94.47 60.48,94.47 60.66,94.29 60.88,94.29 60.95,94.23 60.95,94.09 61.01,94.03 61.07,94.03 61.28,94.25 61.51,94.25
  L7-SIG w0.076: 61.51,94.25 61.52,94.25
42_M0_DATA45: length 24.1
  L7-SIG w0.06: v6(55.69,77.78) 55.75,77.84 55.75,78.14 55.86,78.24 56.01,78.24 56.05,78.2 56.18,78.2 56.34,78.36 56.34,78.57
  L7-SIG w0.064: 59.93,91.98 59.56,91.6 59.56,88.76 59.46,88.67 59.46,88.54 59.64,88.36 59.64,88.1 59.64,87.75 59.43,87.54 59.43,87.46 59.69,87.21 59.69,87.13 59.65,87.08 59.28,87.08 59.22,87.02 59.22,81.97 59.32,81.88 59.54,81.88 59.59,81.83 59.59,81.25 59.5,81.16 59.41,81.16 59.3,81.26 59.3,81.34 59.39,81.42 59.39,81.49 59.28,81.59 59.23,81.59 59.14,81.51 59.06,81.51 59.03,81.54 59.01,81.56 58.88,81.56 58.82,81.49 58.82,81.31 59.23,80.89 59.23,80.81 59.07,80.65 58.84,80.65 58.7,80.78 58.63,80.78 58.5,80.65 57.86,80.65 57.2,79.99 56.82,79.99 56.11,79.29 56.11,78.95 56.19,78.88 56.19,78.72 56.34,78.57 ; 61.04,93.86 60.98,93.8 60.98,93.67 61.09,93.56 61.09,93.48 60.28,92.68 60.24,92.63 60.24,92.29 60.13,92.18 ; v1(61.86,94.08) 61.65,94.08 61.6,94.04 61.6,93.87 61.39,93.66 61.32,93.66 61.11,93.86
  L7-SIG w0.076: 61.04,93.86 61.11,93.86 ; 60.13,92.18 59.96,92.18 59.93,92.15 59.93,91.98
  BOTTOM w0.203: U1601.J16 62.09,93.78
42_M0_DATA46: length 24.6
  L7-SIG w0.06: 57.51,79.32 57.24,79.32 57.05,79.13 57.05,79 56.86,78.82 56.86,78.55 57.01,78.41 57.01,78.14 56.91,78.04 56.78,78.04 56.63,77.89 56.62,77.89 56.36,77.63 56.36,77.49 56.33,77.45 56.17,77.45 56.12,77.4 56.06,77.4 55.97,77.49 v6(55.97,77.53)
  L7-SIG w0.064: 57.51,79.32 57.57,79.38 57.75,79.38 58,79.63 58,79.9 58.11,80.01 58.23,80.01 58.27,79.97 58.27,79.87 58.32,79.82 59.21,79.82 60.02,80.63 60.33,80.63 60.39,80.68 60.39,81.35 60.46,81.43 60.55,81.43 60.66,81.54 60.66,81.59 60.58,81.67 60.45,81.67 60.39,81.74 60.39,81.8 60.45,81.86 60.91,81.86 61.04,82 61.45,82 61.53,82.08 61.53,82.28 61.45,82.36 61.12,82.36 61.04,82.44 61.04,82.6 61.08,82.63 61.08,82.64 61.13,82.68 61.45,82.68 61.53,82.77 61.53,82.93 61.45,83.01 61.12,83.01 61.04,83.09 61.04,83.25 61.13,83.34 61.45,83.34 61.53,83.42 61.53,83.58 61.45,83.66 61.12,83.66 61.04,83.74 61.04,83.9 61.13,83.99 61.45,83.99 61.53,84.07 61.53,87.65 61.02,88.16 61.02,88.36 60.94,88.45 60.94,88.74 60.61,89.07 60.61,89.08 60.28,89.41 60.28,90.3 60.62,90.64 60.62,91.48 60.95,91.81 60.95,92.4 61.13,92.58 61.13,92.58 61.27,92.72 61.4,92.85 61.53,92.85 61.65,92.97 v1(61.86,92.97)
  BOTTOM w0.203: U1601.L16 62.09,92.78
42_M0_DATA47: length 24.4
  L7-SIG w0.064: v6(57.19,78.69) 57.19,78.59 57.29,78.49 57.37,78.49 57.48,78.6 57.48,78.71 57.54,78.77 57.65,78.77 57.71,78.83 57.71,79 57.76,79.05 57.93,79.05 58.37,79.5 59.04,79.5 59.11,79.44 59.11,79.33 59.17,79.27 59.35,79.27 59.39,79.31 59.39,79.44 59.67,79.73 60.65,79.73 60.75,79.83 60.75,80.62 60.89,80.76 60.89,81.01 60.94,81.06 61.19,81.06 61.35,81.22 61.35,81.44 61.45,81.54 61.67,81.54 62.15,82.02 62.15,82.14 62.02,82.27 62.02,82.39 62.15,82.52 62.15,82.67 62.03,82.79 62.03,82.98 62.15,83.1 62.15,83.26 62.03,83.38 62.03,83.57 62.15,83.69 62.15,83.84 62.03,83.96 62.03,84.12 62.15,84.24 62.15,84.48 62.04,84.59 62.04,84.76 62.15,84.87 62.15,85.03 62.02,85.16 62.02,87.85 61.51,88.36 61.51,88.36 61.29,88.58 61.29,89.08 61.39,89.18 61.39,89.29 61.28,89.4 60.73,89.4 60.61,89.52 60.61,89.64 60.67,89.7 61.36,89.7 61.43,89.77 61.43,89.93 61.37,89.99 60.67,89.99 60.61,90.05 60.61,90.19 60.72,90.29 60.9,90.29 60.94,90.33 60.94,91.31 61,91.37 61.12,91.37 61.16,91.41 61.16,91.55 61.27,91.65 61.32,91.65 61.37,91.6 61.37,91.45 61.42,91.4 61.56,91.4 61.61,91.45 61.61,91.58 61.72,91.7 61.72,91.78 61.61,91.89 61.61,92.15 61.71,92.24 61.98,92.24 62.05,92.31 62.11,92.31 62.18,92.24 62.45,92.24 62.5,92.29 62.5,92.66 62.65,92.81 62.65,93.08 62.59,93.13 62.52,93.13 62.46,93.06 62.46,93.06 v1(62.36,92.97)
42_M0_DATA48: length 25.7
  L7-SIG w0.06: v6(55.41,77.53) 55.41,77.79 55.63,78.01 55.63,78.17 55.5,78.29 55.5,78.49 55.47,78.51 55.47,78.95 55.5,78.98 55.5,79.64 56.41,80.55 56.93,80.55 56.97,80.59
  L7-SIG w0.064: v1(63.36,97.04) 63.42,96.98 63.46,96.98 63.76,96.68 63.76,95.86 63.62,95.73 63.62,95.42 63.48,95.28 63.26,95.28 63.1,95.12 63.1,94.94 62.95,94.78 62.7,94.78 62.66,94.74 62.23,94.74 62.05,94.92 60.73,94.92 60.69,94.96 60.02,94.96 59.65,94.59 59.65,93.78 59.19,93.32 59.19,93.23 58.98,93.02 58.98,92.79 58.15,91.96 58.15,82.11 57.81,81.78 57.81,81.43 56.97,80.59
42_M0_DATA49: length 26.7
  L7-SIG w0.06: 55.12,79.32 55.22,79.22 55.22,78.39 v6(55.17,78.34)
  L7-SIG w0.064: 55.12,79.32 54.96,79.32 54.9,79.37 54.9,79.69 54.97,79.76 55.24,79.76 56.49,81.01 56.96,81.01 57.31,81.36 57.31,81.74 57.66,82.09 57.66,92.46 58.22,93.02 58.22,93.45 58.61,93.84 59.12,93.84 59.24,93.95 59.24,94.74 59.28,94.77 59.28,95.52 59.82,96.06 60.82,96.06 60.98,95.91 60.98,95.51 61.25,95.24 61.45,95.24 61.6,95.4 61.6,95.63 61.73,95.76 62.95,95.76 63.1,95.91 63.1,96.58 62.96,96.72 62.44,96.72 62.36,96.8 v1(62.36,96.98)
42_M0_DATA50: length 25.4
  L7-SIG w0.06: 54.01,78.72 54.01,78.62 54.11,78.52 54.11,78.29 53.99,78.17 v6(53.99,77.81)
  L7-SIG w0.064: v1(61.86,97.48) 61.73,97.61 58.73,97.61 55.6,94.48 55.6,93.77 55.59,93.76 55.65,93.7 55.65,82.23 54.67,81.24 54.57,81.24 54.01,80.68 54.01,78.72
  BOTTOM w0.203: v1(61.86,97.48) 62.09,97.28
42_M0_DATA51: length 26.1
  L7-SIG w0.06: 55.37,79.08 55.34,79.05 55.34,78.48 55.38,78.44 55.38,78.11 v6(55.41,78.08)
  L7-SIG w0.064: 59.44,95.41 59.44,93.8 58.46,92.82 58.46,92.64 57.9,92.08 57.9,82.09 57.53,81.72 57.53,81.36 56.98,80.81 56.49,80.81 55.37,79.68 55.37,79.08 ; 61.75,95.28 62.96,95.28 63.1,95.42 63.1,95.59 63.28,95.76 63.44,95.76 63.6,95.93 63.6,96.62 63.45,96.78 63.22,96.78 63.02,96.98 v1(62.86,96.98)
  L7-SIG w0.076: 61.62,95.15 61.75,95.28
  L7-SIG w0.081: 61.62,95.15 61.55,95.08 61.18,95.08 60.39,95.87 59.9,95.87 59.44,95.41
42_M0_DATA52: length 27.1
  L7-SIG w0.06: v6(55.12,77.81) 54.89,77.81 54.69,77.61 54.47,77.61 54.35,77.73 54.35,77.92 54.48,78.04 54.48,78.24 54.35,78.37 54.35,79.08 54.31,79.12 54.31,79.56
  L7-SIG w0.064: v1(61.86,96.98) 61.73,96.98 61.65,97.06 61.61,97.1 60.71,97.1 60.63,97.02 60.63,96.86 60.55,96.78 60.39,96.78 60.15,97.02 58.85,97.02 57.85,96.02 57.85,95.93 57.9,95.89 57.9,95.8 57.81,95.71 57.72,95.71 57.67,95.75 57.58,95.75 57.49,95.66 57.49,95.57 57.54,95.53 57.54,95.44 57.45,95.35 57.36,95.35 57.31,95.39 57.22,95.39 57.13,95.3 57.13,95.21 57.18,95.17 57.18,95.08 57.09,94.99 57,94.99 56.95,95.03 56.87,95.03 56.12,94.29 56.12,93.91 56.16,93.88 56.16,82.15 55.82,81.81 55.82,81.25 55.45,80.88 54.62,80.88 54.31,80.57 54.31,79.56
  BOTTOM w0.203: v1(61.86,96.98) 62.09,96.78
42_M0_DATA53: length 25.9
  L7-SIG w0.06: 55.64,79.03 55.64,78.94 55.6,78.9 55.6,78.62 55.7,78.52 v6(55.7,78.39)
  L7-SIG w0.064: 55.64,79.03 55.64,79.55 56.51,80.42 57.02,80.42 57.73,81.14 58.15,81.14 58.32,81.31 58.32,81.77 58.39,81.84 58.39,91.86 58.9,92.37 59.23,92.37 59.39,92.54 59.39,93.29 59.85,93.75 59.85,94.55 60.1,94.81 60.63,94.81 60.71,94.72 61.59,94.72 61.67,94.63 62.12,94.63 62.2,94.55 62.68,94.55 62.76,94.63 63.09,94.63 63.25,94.79 63.51,94.79 64.1,95.38 64.1,96.74 v1(63.36,97.48)
42_M0_DATA54: length 26.3
  L7-SIG w0.064: v1(62.36,97.48) 61.92,97.93 58,97.93 55.32,95.25 55.32,93.68 55.41,93.59 55.41,82.19 54.61,81.39 54.37,81.39 53.85,80.87 53.85,78.47
  L7-SIG w0.081: v6(53.91,78.41) 53.85,78.47
  BOTTOM w0.203: v1(62.36,97.48) 62.59,97.28
42_M0_DATA55: length 26.6
  L7-SIG w0.06: v6(54.27,78.13) 54.23,78.18 54.23,78.88 54.17,78.94 54.17,79.45
  L7-SIG w0.064: v1(62.86,97.48) 62.86,97.3 62.8,97.23 61.74,97.23 61.62,97.35 60.79,97.35 60.69,97.25 60.53,97.25 60.44,97.35 60.28,97.35 60.18,97.25 60.03,97.25 59.93,97.35 59.77,97.35 59.68,97.25 59.52,97.25 59.42,97.35 58.84,97.35 55.88,94.39 55.88,93.81 55.92,93.78 55.92,82.23 55.42,81.73 55.42,81.48 55.48,81.42 55.48,81.12 55.39,81.02 55.11,81.02 55.05,81.09 54.62,81.09 54.17,80.64 54.17,79.45
  BOTTOM w0.203: v1(62.86,97.48) 62.64,97.69
42_M0_DATA56: length 29.1
  L5-SIG w0.06: 54.38,77.67 54.38,77.6 54.23,77.45 54.23,77.03 v6(54.3,76.96)
  L5-SIG w0.109: v1(62.35,95.52) 62.35,95.39 62.17,95.21 62.17,95.06 62.09,94.99 61.64,94.99 61.25,95.37 60.94,95.37 60.87,95.43 60.87,95.6 60.95,95.67 61.16,95.67 61.23,95.74 61.23,95.85 61.01,96.07 60.94,96.07 60.85,95.98 60.76,95.98 60.64,96.11 60.64,96.18 60.71,96.26 60.71,96.35 60.62,96.45 ; 55.58,82.21 55.58,81.42 54.64,80.48 54.64,79.46 54.38,79.21 54.38,77.67
  L5-SIG w0.127: 60.62,96.45 60.46,96.61 60.34,96.61 60.12,96.39 60.02,96.39 59.8,96.61 59.73,96.61 59.49,96.37 59.38,96.37 59.17,96.58 58,96.58 57.9,96.48 57.68,96.48 57.58,96.58 57.4,96.58 57.3,96.48 57.08,96.48 56.98,96.58 56.74,96.58 55.58,95.41 55.58,83.62 55.58,82.21
42_M0_DATA57: length 29.4
  L5-SIG w0.06: v6(55.41,75.83) 55.41,75.96 55.36,76 55.02,76 54.97,76.05 54.97,76.21 55,76.24 55.15,76.24 55.19,76.28 55.19,76.37 54.96,76.6 54.96,76.77 55.02,76.83 55.02,78.81 55.49,79.28 55.49,79.38
  L5-SIG w0.109: v1(63.36,96.03) 63.57,96.03 63.64,95.96 63.64,94.72 63.7,94.65 63.94,94.65 64.01,94.58 64.01,94.45 63.93,94.36 63.7,94.36 63.65,94.31 63.65,94.13 63.58,94.07 61.14,94.07 60.74,94.47 60.11,94.47 60.02,94.56 59,94.56 58.96,94.6 ; 55.49,79.38 55.49,79.98 57.23,81.73
  L5-SIG w0.127: 58.96,94.6 58.85,94.71 58.54,94.71 58.2,94.36 57.78,94.36 57.63,94.21 57.63,93.8 57.23,93.4 57.23,81.73
42_M0_DATA58: length 28.6
  L5-SIG w0.06: v6(54.56,76.11) 54.27,76.11 53.98,76.41 53.98,77.72 54.04,77.78
  L5-SIG w0.109: 59.95,97.14 60.47,97.14 61.6,96 61.6,95.78 v1(61.86,95.52) ; 55.02,81.36 54.29,80.63 54.29,79.61 54.04,79.36 54.04,77.78
  L5-SIG w0.127: 59.95,97.14 57.93,97.14 56.51,97.14 55.02,95.65 55.02,83.86 55.02,81.36
42_M0_DATA59: length 29.8
  L5-SIG w0.06: 54.21,77.66 54.09,77.54 54.09,76.8 54.2,76.7 54.2,76.47 v6(54.31,76.36)
  L5-SIG w0.076: v1(62.39,96) 62.39,96 62.39,96.37 62.31,96.44 62.18,96.44 62.1,96.37 62.1,95.39 61.97,95.26 61.67,95.26 61.41,95.51
  L5-SIG w0.109: 54.21,77.66 54.21,79.28 54.47,79.53 54.47,80.56 55.3,81.39 55.3,82.24 ; 59.67,96.86 60.48,96.86 61.41,95.93 61.41,95.51
  L5-SIG w0.127: 55.3,82.24 55.3,82.55 55.3,82.55 55.3,83.74 55.3,83.74 55.3,95.53 56.62,96.86 57.81,96.86 57.81,96.86 59.67,96.86
42_M0_DATA60: length 29
  L5-SIG w0.06: v6(55.16,76.68) 55.16,76.7 55.15,76.71 55.15,78.77 55.66,79.27 55.66,79.33
  L5-SIG w0.076: 63.76,96.27 63.19,96.27 63,96.47 62.78,96.47 62.68,96.37 62.68,96.19 v1(62.86,96.01)
  L5-SIG w0.109: 57.51,81.74 55.66,79.89 55.66,79.33 ; 63.76,96.27 63.86,96.18 63.86,95.06 64.22,94.69 64.22,94.31 63.77,93.87 61.04,93.87 60.64,94.27 59.51,94.27
  L5-SIG w0.127: 59.51,94.27 58.5,94.27 58.31,94.08 58.06,94.08 57.91,93.94 57.91,93.68 57.51,93.28 57.51,81.74
42_M0_DATA61: length 29.1
  L5-SIG w0.06: 53.86,78.24 53.86,76.35 54.27,75.93 v6(54.27,75.89)
  L5-SIG w0.109: 54.74,81.62 54.74,81.32 54.11,80.69 54.11,79.71 53.86,79.46 53.86,78.24 ; 60.23,97.41 60.45,97.41 v1(61.86,96)
  L5-SIG w0.127: 60.23,97.41 58.05,97.41 56.39,97.42 54.74,95.76 54.74,83.97 54.74,83.97 54.74,82.32 54.74,81.62
  BOTTOM w0.203: U1601.E16 62.09,95.78
42_M0_DATA62: length 29.1
  L5-SIG w0.06: v6(54.84,75.88) 54.84,76.12 54.39,76.58 54.39,76.77 54.5,76.88 54.5,77.05 54.35,77.2 54.35,77.37 54.53,77.56 54.53,79.13 54.8,79.4
  L5-SIG w0.076: v1(62.86,95.52) 62.74,95.52 62.37,95.14 62.37,94.9 62.26,94.8
  L5-SIG w0.109: 54.8,79.4 54.8,80.38 55.86,81.43 55.86,82.08 ; 62.26,94.8 61.56,94.8 61.18,95.18 60.82,95.18 60.69,95.31 60.69,95.79 60.32,96.16 59.19,96.16 59.09,96.27
  L5-SIG w0.127: 59.09,96.27 59.06,96.3 58.12,96.3 58.02,96.2 56.77,96.2 55.86,95.29 55.86,83.51 55.86,82.08
42_M0_DATA63: length 29
  L5-SIG w0.06: 55.83,79.39 55.83,79.26 55.73,79.16 55.72,79.16 55.27,78.72 55.27,76.91 55.36,76.82 55.36,76.45 v6(55.38,76.43)
  L5-SIG w0.109: 55.83,79.39 55.83,79.8 57.71,81.68 57.71,81.68 ; 59.42,93.89 59.59,94.06 60.58,94.06 60.98,93.66 63.83,93.66 64.4,94.23 64.4,94.86 64.08,95.18 64.08,96.76 63.88,96.96 63.55,96.96 63.35,96.76 v1(63.35,96.54)
  L5-SIG w0.127: 57.71,81.68 57.79,81.77 57.79,93.17 58.52,93.89 59.42,93.89
42_M0_DM0: length 33.1
  L5-SIG w0.06: v6(58.27,74.67) 58.27,74.48 58.49,74.25 58.86,74.25 58.92,74.19 59.23,74.19 59.27,74.23 59.48,74.23 59.59,74.13
  L5-SIG w0.076: v1(66.86,92) 66.98,91.88 67.53,91.88 67.66,91.76 68.01,91.76
  L5-SIG w0.109: 69.5,91.71 69.43,91.79 68.04,91.79 68.01,91.76 ; 59.59,74.13 59.64,74.07
  L5-SIG w0.127: 69.5,91.71 69.65,91.71 70.62,90.75 70.62,89.93 70.71,89.83 70.93,89.83 71.05,89.72 71.05,89.5 71.81,88.74 71.81,78.37 67.48,74.03 59.69,74.03 59.64,74.07
42_M0_DM1: length 30
  L7-SIG w0.06: v6(60.21,74.98) 60.52,74.98 60.72,75.19 60.89,75.19 61.02,75.06 61.25,75.06 61.38,75.19 61.57,75.19
  L7-SIG w0.064: v1(67.86,91.48) 67.52,91.14 67.24,91.14 67.12,91.02 67.12,90.38 67.57,89.92 67.57,89.82 67.83,89.57 67.98,89.57 68.13,89.72 68.28,89.72 69.7,88.3 69.7,83.09 69.45,82.84 69.45,79.78 69.18,79.51 69.18,79.22 69.27,79.12 69.51,79.12 69.63,79 69.63,78.63 69.47,78.47 69.32,78.47 68.82,78.97 68.64,78.97 68.46,78.79 68.46,78.61 68.92,78.16 68.92,77.94 68.77,77.8 68.56,77.8 67.83,78.52 67.64,78.52 66.88,77.76 66.88,77.58 66.52,77.23 66.19,77.23 65.89,76.92 65.53,76.92 65.45,77 65.45,77.22 65.37,77.3 65.21,77.3 65.12,77.22 65.12,77 65.04,76.92 64.67,76.92 62.71,74.97 62.64,74.97 62.54,75.07 62.46,75.07 62.38,74.99 62.38,74.86 62.33,74.81 62.21,74.81 62.15,74.86 62.15,74.99 62.07,75.07 61.98,75.07 61.82,74.91 61.7,74.91 61.63,74.99 61.63,75.13 61.57,75.19
42_M0_DM2: length 23.8
  L7-SIG w0.06: v6(60.22,76.66) 60.22,76.42 60.02,76.22 60.02,76.04 60.14,75.92 60.31,75.92 60.42,76.04 60.63,76.04 60.71,75.96 61.72,75.96 61.82,76.06 62.22,76.06
  L7-SIG w0.064: v1(64.39,91.39) 64.5,91.27 64.88,91.27 65.02,91.13 65.02,90.85 64.72,90.55 64.72,90.01 64.72,90 64.72,89.65 65.62,88.75 66.12,88.75 67.24,87.63 67.24,87.54 67.32,87.46 67.56,87.46 67.62,87.41 67.62,87.24 67.56,87.18 67.36,87.18 67.24,87.06 67.24,85.86 67.65,85.45 67.65,81.01 65.56,78.93 64.78,78.93 64.35,78.49 64.35,78.19 62.22,76.06
42_M0_DM3: length 24.7
  L5-SIG w0.06: 59.85,75.47 59.83,75.45 59.55,75.45 59.08,75.91 59.04,75.91 58.92,76.03 58.92,76.42 v6(59.08,76.59)
  L5-SIG w0.076: v1(65.86,91.42) 66.01,91.27 66.01,90.22 66.68,89.54
  L5-SIG w0.109: 65.36,77.66 65.36,77.11 64.33,76.07 62.61,76.07 62.38,75.84 60.61,75.84 60.24,75.47 59.85,75.47 ; 67.85,87.79 67.85,88.12 66.73,89.24 66.73,89.5 66.68,89.54
  L5-SIG w0.127: 67.85,87.79 67.85,87.69 68.44,87.1 68.44,82.84 66.93,81.33 66.93,79.22 65.36,77.66
42_M0_DM4: length 25.8
  L5-SIG w0.06: 55.42,78.61 55.41,78.6 55.41,77.14 v5(55.48,77.07)
  L5-SIG w0.076: v1(62.89,92.98) 62.86,92.96 62.86,92.83 62.92,92.77 63.11,92.77 63.16,92.82 63.16,93.15 63.32,93.31 63.32,93.43 63.28,93.48 62.78,93.48 62.75,93.44 62.75,93.24 62.64,93.12
  L5-SIG w0.109: 55.42,78.61 55.42,78.66 55.78,79.02 55.79,79.02 55.97,79.2 55.97,79.21 56,79.24 56,79.72 58.17,81.9 58.17,82.17 ; 62.64,93.12 62.51,93.12 62.45,93.18 62.45,93.42 62.4,93.47 60.86,93.47 60.6,93.21 60.06,93.21 59.97,93.3 59.97,93.49 60.07,93.59 60.07,93.83 60.02,93.88 59.71,93.88 59.63,93.79
  L5-SIG w0.127: 58.17,82.17 58.17,93.01 58.67,93.51 59.35,93.51 59.63,93.79
  L7-SIG w0.06: v6(55.97,76.96) 55.59,76.96 v5(55.48,77.07)
42_M0_DM5: length 25.3
  L7-SIG w0.06: 55.79,79 55.79,78.86 55.75,78.83 55.75,78.65 55.96,78.44 v6(56.13,78.44)
  L7-SIG w0.064: v1(62.86,94.39) 62.86,94.29 62.8,94.22 62.76,94.22 62.71,94.17 62.64,94.17 62.59,94.22 62.59,94.35 62.54,94.4 62.14,94.4 62.06,94.48 61.42,94.48 61.36,94.42 61.11,94.42 61.06,94.48 60.74,94.48 60.57,94.65 60.17,94.65 60.05,94.53 60.05,93.7 59.77,93.42 59.77,93.3 59.72,93.25 59.6,93.25 59.55,93.2 59.55,92.98 59.6,92.93 59.87,92.93 59.92,92.87 59.92,92.65 59.88,92.61 59.63,92.61 59.55,92.53 59.55,92.14 59.47,92.06 59.04,92.06 58.73,91.75 58.73,91.63 58.79,91.57 59.19,91.57 59.25,91.51 59.25,90.77 59.17,90.69 59.07,90.69 58.99,90.77 58.99,91.26 58.91,91.33 58.8,91.33 58.73,91.26 58.73,88.33 58.92,88.13 58.92,88.09 58.73,87.89 58.73,82.19 58.6,82.07 58.6,81.85 58.51,81.75 58.51,81.09 58.4,80.98 57.79,80.98 57.07,80.27 56.54,80.27 55.79,79.52 55.79,79
42_M0_DM6: length 26.2
  L7-SIG w0.06: 54.75,79.82 54.75,79.1 54.85,79 55.05,79 55.1,78.95 55.1,78.55 54.97,78.42 54.97,78.22 v6(54.56,77.81)
  L7-SIG w0.064: 54.75,79.82 54.88,79.95 54.88,80.21 54.96,80.28 55.09,80.28 55.23,80.14 55.43,80.14 56.5,81.21 56.96,81.21 57.17,81.42 57.17,81.83 57.37,82.04 57.37,93 57.47,93.1 57.59,93.1 57.7,92.98 57.82,92.98 57.93,93.1 57.93,93.21 57.82,93.33 57.82,93.44 58.59,94.22 58.89,94.22 59.08,94.41 59.08,95.55 59.75,96.22 61.09,96.22 61.17,96.14 61.17,95.9 61.25,95.83 61.48,95.83 61.53,95.88 61.53,96.01 61.76,96.24 62.77,96.24 62.86,96.33 v1(62.86,96.48)
42_M0_DM7: length 29.9
  L5-SIG w0.06: v6(54.56,77.29) 54.65,77.39 54.65,78.99 54.97,79.31 54.97,79.36
  L5-SIG w0.076: 62.66,94.61 62.67,94.6 62.81,94.6 62.84,94.62 62.84,94.72 62.7,94.85 62.56,94.85 62.52,94.9 62.52,95.08 62.71,95.28 62.96,95.28 63.03,95.21 63.12,95.21 63.17,95.26 63.17,95.34 63.1,95.4 63.1,95.62 63.02,95.7 63.02,95.79 63.09,95.87 63.18,95.87 63.26,95.78 63.38,95.78 63.45,95.72 63.45,95.59 v1(63.38,95.52)
  L5-SIG w0.109: 56.13,82.03 56.13,81.42 54.97,80.26 54.97,79.36 ; 62.66,94.61 61.48,94.61 61.1,95 60.66,95 60.5,95.15 60.5,95.71 60.24,95.98 59.73,95.98 59.42,95.67 59.33,95.67 58.98,96.02 58.96,96.02
  L5-SIG w0.127: 56.13,82.03 56.13,82.9 56.13,93.84 56.32,94.02 56.32,94.22 56.13,94.41 56.13,95.17 56.88,95.92 57.64,95.92 57.84,95.72 57.94,95.72 58.23,96.02 58.96,96.02
42_M0_ODT0: length 30.1
  L2-SIG w0.081: v8(61.01,77.96) 60.84,77.96 60.68,78.12 60.68,78.24 60.81,78.37 61.2,78.37 61.32,78.49 61.32,78.66 61.2,78.78 60.7,78.78 60.58,78.9 60.58,82.61 60.7,82.74 63.38,82.74 63.43,82.79 63.43,83.05 63.38,83.1 60.72,83.1 60.59,83.23 60.59,84.15 60.7,84.26 60.85,84.26 60.96,84.15 60.96,83.64 61.09,83.52 63.36,83.52 63.43,83.59 63.43,92.5 63.93,93 64.19,93 64.29,92.9 64.29,92.69 v8(64.2,92.6)
  L3-GND w0.06: v8(61.01,77.96) 61.2,77.96 v3(61.38,77.79)
  L3-GND w0.076: v8(64.2,92.6) 64.2,92.91 64.25,92.96 v3(64.26,92.96)
  L6-GND w0.06: v6(61.14,77.53) 61.22,77.61 61.22,77.63 v3(61.38,77.79)
  L6-GND w0.076: v3(64.26,92.96) v4(64.64,92.96)
  L7-SIG w0.076: v4(64.64,92.96) 64.96,92.64 65.32,92.64 65.86,92.1 v1(65.86,91.98)
42_M0_ODT2: length 30.5
  L2-SIG w0.081: v8(63.83,93.27) 63.2,92.64 63.2,84.62 63.07,84.5 62.57,84.5 62.52,84.44 62.52,84.16 62.57,84.11 63.08,84.11 63.18,84.01 63.18,83.87 63.08,83.77 62.2,83.77 62.11,83.85 62.11,84.9 62,85.02 61.83,85.02 61.71,84.9 61.71,83.85 61.63,83.77 61.38,83.77 61.3,83.85 61.3,85.27 61.18,85.39 60.47,85.39 60.34,85.27 60.34,85.12 60.47,84.99 60.8,84.99 60.91,84.87 60.91,84.71 60.8,84.6 60.47,84.6 60.34,84.47 60.34,78.65 59.82,78.13 59.82,77.83 59.94,77.72 60.47,77.72 60.58,77.83 60.58,77.96 60.5,78.04 60.5,78.1 60.43,78.17 v8(60.28,78.17)
  L3-GND w0.06: v8(60.28,78.17) 60.2,78.1 v3(60.2,77.81)
  L3-GND w0.076: v8(63.83,93.27) 63.95,93.27 v3(64.21,93.53)
  L6-GND w0.06: v6(60.78,77.81) v3(60.2,77.81)
  L6-GND w0.076: v4(63.82,93.49) 63.86,93.53 v3(64.21,93.53)
  L7-SIG w0.076: v4(63.82,93.49) 63.82,94.03 v1(63.36,94.48)
42_M1_CA0: length 44.2
  L2-SIG w0.076: 49,93.28 49.2,93.07 49.2,92.72
  L2-SIG w0.081: v8(49,93.25) 49,93.28 48.69,93.58 48.69,94.34 49.31,94.96 49.78,94.96 50.02,95.19 50.02,95.53 49.75,95.79 49.3,95.79 49.03,96.06 49.03,97.45 49.07,97.48 49.07,97.88 48.83,98.12 48.83,100.32 48.88,100.37 v8(48.88,100.49) ; v8(47.91,76.01) 47.89,75.98 47.24,75.98 47.13,75.87 47.13,74.98 47.01,74.86 46.84,74.86 46.73,74.98 46.73,75.92 46.64,76 46.49,76 46.34,76.16 46.34,76.34 46.44,76.44 48.32,76.44 48.5,76.62 48.5,76.91 48.83,77.23 48.83,77.53 48.86,77.57 48.89,77.6 48.89,77.6 48.89,78.19 49.49,78.79 49.49,79.5 49.87,79.88 49.87,84.68 50.33,85.14 50.33,91.88 50.19,92.02 49.5,92.02 49.29,92.23 49.29,92.63 49.2,92.72
  L3-GND w0.06: v3(48.38,75.98) 47.94,75.98 v8(47.91,76.01)
  L3-GND w0.076: v3(49.23,93.74) 49.23,93.64 49.2,93.61 49.2,93.43 49.02,93.25 v8(49,93.25)
  L3-GND w0.102: v3(49.18,100.72) 48.95,100.49 48.88,100.49 v8(48.88,100.49)
  L6-GND w0.06: v6(48.53,76.4) 48.53,76.13 v3(48.38,75.98)
  L6-GND w0.076: v3(49.23,93.74) 49.33,93.84 v4(49.33,94.35)
  L6-GND w0.102: v3(49.18,100.72) 49.44,100.98 v1(49.44,101.16)
  L7-SIG w0.076: v1(51.11,92.98) 51.13,93 51.18,93 51.28,92.9 51.28,92.8 51.18,92.7 50.88,92.7 50.82,92.75 50.82,93.38 50.83,93.39 50.83,94.07 50.67,94.23 50.45,94.23 50.31,94.38 49.76,94.38 49.68,94.31 49.37,94.31 v4(49.33,94.35) 49.33,95.45 50.04,96.17 50.11,96.24 50.11,97.01 49.68,97.44 49.68,97.45 49.64,97.48 v1(49.58,97.48)
42_M1_CA1: length 43.4
  L2-SIG w0.081: v8(49.33,76.36) 49.12,76.56 49.12,76.98 49.31,77.17 49.31,77.78 50.81,79.28 50.81,92.45 50.68,92.58 49.82,92.58 49.7,92.7 49.7,92.88 49.82,93.01 50.38,93.01 50.49,93.11 50.49,93.26 50.38,93.37 49.95,93.37 49.82,93.5 49.82,93.62 49.95,93.75 50.45,93.75 50.56,93.86 50.56,94.08 50.33,94.31 50.33,94.58 50.45,94.69 50.73,94.69 50.81,94.77 50.81,94.93 50.68,95.06 50.59,95.06 50.47,95.18 50.47,95.32 50.59,95.44 50.68,95.44 50.81,95.57 50.81,96.14 50.57,96.38 49.54,96.38 v8(49.48,96.31)
  L3-GND w0.06: v8(49.33,76.36) 49.29,76.32 v3(48.97,76.32)
  L3-GND w0.076: v8(49.48,96.31) 48.95,95.78 v3(48.95,95.52)
  L5-SIG w0.16: v3(48.95,95.52) 48.95,95.74 48.74,95.95 48.74,97.37 48.09,98.02 48.09,98.39 45.98,100.5 45.98,100.64 v3(45.97,100.66)
  L6-GND w0.06: v3(48.97,76.32) 48.8,76.48 v6(48.8,76.65)
  L6-GND w0.076: v4(48.37,95.06) 48.49,95.06 v3(48.95,95.52)
  L6-GND w0.102: v1(45.8,101.06) 45.8,100.85 45.97,100.67 v3(45.97,100.66)
  L7-SIG w0.076: v1(49.58,96.98) 49.37,96.98 49.33,96.94 49.33,96.9 49.3,96.87 49.3,96.76 49.35,96.71 49.73,96.71 49.81,96.63 49.81,96.37 49.67,96.23 49.38,96.23 49.34,96.18 49.34,95.9 49.01,95.56 48.73,95.56 48.67,95.5 48.67,95.38 48.91,95.14 48.91,95.02 48.82,94.93 48.7,94.93 48.58,95.06 v4(48.37,95.06) 48.37,94.68 48.49,94.56 48.49,93.71 48.75,93.45 49.71,93.45 49.98,93.72 50.18,93.72 50.34,93.57 50.34,93.39 50.58,93.14 v1(50.58,92.98)
42_M1_CA2: length 43.1
  L2-SIG w0.081: v8(48.16,76.79) 46.82,76.79 46.7,76.92 46.7,77.16 46.81,77.28 46.97,77.28 47.06,77.36 47.06,77.47 47.14,77.56 47.3,77.56 47.38,77.47 47.38,77.36 47.46,77.28 48.31,77.28 48.71,77.67 48.71,77.68 48.71,77.95 48.62,78.04 48.62,78.34 49.22,78.94 49.22,79.84 49.3,79.93 49.55,79.93 49.63,80.01 49.63,80.25 49.55,80.33 49.3,80.33 49.22,80.41 49.22,80.66 49.3,80.74 49.55,80.74 49.63,80.82 49.63,81.06 49.55,81.14 49.3,81.14 49.22,81.23 49.22,81.47 49.3,81.55 49.55,81.55 49.63,81.63 49.63,81.88 49.55,81.96 49.3,81.96 49.22,82.04 49.22,82.28 49.3,82.36 49.55,82.36 49.63,82.45 49.63,82.69 49.55,82.77 49.3,82.77 49.22,82.85 49.22,83.1 49.3,83.18 49.55,83.18 49.63,83.26 49.63,83.5 49.55,83.58 49.3,83.58 49.22,83.66 49.22,83.91 49.3,83.99 49.55,83.99 49.63,84.07 49.63,84.31 49.55,84.4 49.3,84.4 49.22,84.48 49.22,84.74 49.55,85.07 49.91,85.07 50.09,85.25 50.09,91.1 48.97,92.21 48.97,92.9 48.4,93.47 48.4,93.48 v8(48.2,93.68) 48.43,93.91 48.43,94.3 49.25,95.12 49.72,95.12 49.86,95.26 49.86,95.46 49.69,95.63 49.24,95.63 48.87,96 48.87,97.52 48.91,97.55 48.91,97.75 48.6,98.06 48.6,100.23 v8(48.31,100.52)
  L3-GND w0.06: v8(48.16,76.79) 48.06,76.69 v3(48.06,76.44)
  L3-GND w0.076: v3(48.24,94.07) 48.2,94.04 v8(48.2,93.68)
  L3-GND w0.102: v8(48.31,100.52) 48.54,100.75 v3(48.54,100.8)
  L6-GND w0.06: v6(48.33,76.68) 48.09,76.44 v3(48.06,76.44)
  L6-GND w0.076: v4(48.24,94.47) 48.18,94.42 48.18,94.12 v3(48.24,94.07)
  L6-GND w0.102: v1(48.68,101.16) v3(48.54,100.8)
  L7-SIG w0.076: v1(49.57,96.47) 49.4,96.47 49.32,96.39 49.32,96.38 49.18,96.24 49.18,96.23 49.17,96.22 48.98,96.22 48.84,96.08 48.84,95.82 48.77,95.74 48.4,95.74 48.11,95.45 48.11,94.6 v4(48.24,94.47) 48.08,94.32 48.08,93.79 48.64,93.23 49.86,93.23 50.08,93.01 v1(50.08,93.02)
42_M1_CA3: length 42.6
  L2-SIG w0.081: v8(49.4,95.36) 48.95,95.36 48.71,95.13 48.71,94.81 48.48,94.58 48.47,94.58 47.96,94.07 47.96,93.57 48.68,92.85 48.68,92.11 49.86,90.94 49.86,85.45 49.73,85.33 49.19,85.33 49.06,85.2 49.06,84.93 48.97,84.83 48.84,84.83 48.74,84.93 48.74,85.24 48.67,85.32 48.51,85.32 48.42,85.23 48.42,84.41 48.5,84.33 48.9,84.33 48.98,84.24 48.98,84 48.9,83.92 48.5,83.92 48.42,83.84 48.42,83.59 48.5,83.51 48.9,83.51 48.98,83.43 48.98,83.19 48.9,83.11 48.5,83.11 48.42,83.03 48.42,82.78 48.5,82.7 48.9,82.7 48.98,82.62 48.98,82.38 48.9,82.29 48.5,82.29 48.42,82.21 48.42,81.97 48.5,81.89 48.9,81.89 48.98,81.81 48.98,81.56 48.9,81.48 48.5,81.48 48.42,81.4 48.42,81.16 48.5,81.07 48.9,81.07 48.98,80.99 48.98,80.75 48.9,80.67 48.5,80.67 48.42,80.59 48.42,80.34 48.5,80.26 48.82,80.26 48.93,80.15 48.93,78.96 48.39,78.42 v8(48.39,77.74)
  L3-GND w0.06: v8(48.39,77.74) 48.39,77.41 v3(48.44,77.35)
  L3-GND w0.076: v8(49.4,95.36) 49.64,95.6 v3(49.64,95.82)
  L5-SIG w0.16: v3(47.8,100.77) 47.8,100 49.03,98.78 49.03,98.66 49.64,98.04 v3(49.64,95.82)
  L6-GND w0.06: v6(48.36,77.81) 48.36,77.43 v3(48.44,77.35)
  L6-GND w0.076: v4(50.34,95.77) 50.27,95.84 49.67,95.84 v3(49.64,95.82)
  L6-GND w0.102: v1(47.94,101.16) 47.8,101.03 v3(47.8,100.77)
  L7-SIG w0.076: v1(51.08,93.48) 51.51,93.91 51.51,94.17 51.59,94.24 51.82,94.24 51.89,94.32 51.89,94.42 51.82,94.5 51.56,94.5 51.51,94.55 51.51,94.68 50.95,95.24 50.54,95.24 50.34,95.44 v4(50.34,95.77) 50.34,96.04 50.55,96.24 50.68,96.24 50.82,96.38 50.82,97.12 50.56,97.38 50.26,97.38 49.76,97.88 49.42,97.88 49.08,97.54 v1(49.08,97.48)
42_M1_CA4: length 45.8
  L2-SIG w0.081: v8(49.61,100.44) 49.06,99.9 49.06,98.25 49.3,98.01 49.3,97.48 49.19,97.37 49.19,96.13 49.37,95.95 49.82,95.95 50.18,95.59 50.18,95.46 50.18,95.13 49.85,94.8 49.38,94.8 49.02,94.45 v8(49.02,94.17) 49.1,94.09 49.33,94.09 49.61,94.37 49.75,94.37 49.86,94.26 49.86,94.14 49.51,93.79 49.51,92.36 49.56,92.31 50.31,92.31 50.57,92.05 50.57,83.92 50.39,83.74 50.39,83.53 50.57,83.35 50.57,83.11 50.49,83.02 50.23,83.02 50.15,82.94 50.15,82.7 50.23,82.62 50.49,82.62 50.57,82.54 50.57,82.29 50.49,82.21 50.23,82.21 50.15,82.13 50.15,81.89 50.23,81.8 50.49,81.8 50.57,81.72 50.57,81.48 50.49,81.4 50.23,81.4 50.15,81.32 50.15,81.07 50.23,80.99 50.49,80.99 50.57,80.91 50.57,80.63 50.46,80.53 50.25,80.53 50.12,80.4 50.12,80.23 50.25,80.1 50.42,80.1 50.53,80 50.53,79.85 50.42,79.74 50.11,79.74 50.02,79.65 50.02,79.47 50.09,79.4 50.21,79.4 50.3,79.31 50.3,79.16 50.18,79.04 49.89,79.04 49.76,78.91 49.76,78.62 49.1,77.96 49.1,77.22 48.81,76.94 48.81,76.32 48.98,76.15 48.98,75.91 48.92,75.85 48.92,75.61 49.07,75.45 49.44,75.45 49.61,75.62 49.61,75.8 49.53,75.88 v8(49.35,75.88)
  L3-GND w0.06: v8(49.35,75.88) 49.36,75.89 v3(49.73,75.89)
  L3-GND w0.076: v8(49.02,94.17) 48.66,93.81 v3(48.66,93.66)
  L3-GND w0.102: v3(49.89,100.7) 49.86,100.7 v8(49.61,100.44)
  L6-GND w0.06: v3(49.73,75.89) 49.71,75.89 v6(49.46,76.14)
  L6-GND w0.076: v3(48.66,93.66) 48.66,94.1 v4(48.73,94.17)
  L6-GND w0.102: v1(50.17,101.16) 50.17,100.98 v3(49.89,100.7)
  L7-SIG w0.076: v1(50.58,93.48) 50.65,93.55 50.65,93.66 50.57,93.74 50.39,93.74 50.32,93.8 50.32,94.15 50.24,94.23 49.9,94.23 49.84,94.17 49.84,93.8 49.65,93.61 48.97,93.61 48.87,93.71 48.87,93.81 48.95,93.89 49.25,93.89 49.3,93.94 49.3,94.03 49.17,94.17 v4(48.73,94.17) 48.73,94.42 49.18,94.86 49.18,95.52 49.84,96.18 49.96,96.3 49.96,96.95 49.68,97.22 49.39,97.22 49.16,97 v1(49.09,97)
42_M1_CA5: length 41
  L2-SIG w0.081: v8(49.59,76.84) 49.59,76.43 49.69,76.33 49.86,76.33 50,76.47 50,76.8 50.12,76.92 50.3,76.92 50.5,77.12 50.5,77.2 50.26,77.44 50.13,77.44 50.05,77.36 50.05,77.36 49.99,77.3 49.99,77.28 49.84,77.12 49.61,77.12 49.49,77.24 49.49,77.63 51.07,79.21 51.07,92.69 50.74,93.02 50.74,94.16 51.07,94.49 51.07,96.21 50.42,96.86 50.26,96.86 50.06,97.05 50.06,98.49 49.97,98.58 49.84,98.58 49.75,98.49 49.75,98.14 49.61,98 49.61,97.66 49.75,97.52 49.75,97.05 v8(49.56,96.86)
  L3-GND w0.06: v3(49.21,76.88) 49.56,76.88 v8(49.59,76.84)
  L3-GND w0.076: v8(49.56,96.86) 49.31,96.61 v3(49.13,96.61)
  L5-SIG w0.076: v1(50.58,94.98) 50.34,94.74 49.68,94.74 49.3,95.11 49.3,95.67 49.3,95.67 49.3,95.96 49.3,95.96 49.3,96.4 49.13,96.57 v3(49.13,96.61)
  L5-SIG w0.16: v3(49.13,96.61) 49.13,96.62 49.13,98.11 48.71,98.53 48.71,98.65 47.12,100.25 v3(47.12,100.77)
  L6-GND w0.06: v6(49.52,76.68) 49.4,76.68 v3(49.21,76.88)
  L6-GND w0.076: v3(49.13,96.61) 49.13,96.75 49.07,96.82 48.87,96.82 v4(48.79,96.74)
  L6-GND w0.102: v1(47.2,101.16) 47.12,101.08 v3(47.12,100.77)
  L7-SIG w0.076: v1(47.58,96.98) 47.51,96.91 47.51,96.82 47.59,96.74 47.82,96.74 47.91,96.65 48.01,96.65 48.24,96.88 48.24,97.06 48.42,97.24 48.75,97.24 48.84,97.14 48.84,96.79 v4(48.79,96.74)
42_M1_CA6: length 41.4
  L2-SIG w0.081: v8(49.71,75.33) 50.04,75.66 50.04,76.26 50.95,77.17 50.95,77.29 50.89,77.35 50.89,77.47 51,77.58 51.12,77.58 51.18,77.52 51.3,77.52 51.54,77.76 51.54,78.44 51.46,78.52 51.42,78.52 51.33,78.61 51.33,78.77 51.42,78.85 51.46,78.85 51.54,78.93 51.54,92.74 51.12,93.16 51.12,93.97 51.54,94.39 51.54,96.38 51.47,96.45 51.33,96.45 51.25,96.53 51.25,96.65 51.33,96.73 51.46,96.73 51.54,96.81 51.54,97.4 51.34,97.59 51.22,97.59 51.16,97.54 51.16,97.11 51.08,97.02 50.99,97.02 50.87,97.15 50.87,97.38 50.82,97.43 v8(50.66,97.43)
  L3-GND w0.06: v8(49.71,75.33) 49.63,75.25 v3(49.35,75.25)
  L3-GND w0.076: v3(50.29,97.47) 50.32,97.43 v8(50.66,97.43)
  L5-SIG w0.109: v1(50.05,95.02) 50.3,95.26 51.17,95.26 51.24,95.33 51.24,95.53 51.14,95.64 50.41,95.64 50.29,95.76 50.29,96.22 50.56,96.49 50.56,96.64 50.29,96.92 v3(50.29,97.47)
  L5-SIG w0.16: v3(50.29,97.47) 50.55,97.73 50.55,98.52 51.73,99.7 51.73,100.52 v3(51.42,100.83)
  L6-GND w0.06: v3(49.35,75.25) 49.35,75.55 v5(49.39,75.6)
  L6-GND w0.076: v3(50.29,97.47) 50.16,97.59 v4(50.16,97.81)
  L6-GND w0.102: v1(51.66,101.17) 51.66,101.07 v3(51.42,100.83)
  L7-SIG w0.06: v5(49.39,75.6) 49.39,75.92 49.18,76.13 v6(49.18,76.4)
  L7-SIG w0.076: v1(47.58,96.48) 47.34,96.72 47.34,97.1 47.48,97.24 48.18,97.24 48.32,97.38 48.32,97.57 48.53,97.77 49.1,97.77 49.36,98.03 49.95,98.03 v4(50.16,97.81)
42_M1_CA7: length 41.6
  L2-SIG w0.081: v8(48.5,79.17) 48.5,78.88 48.41,78.8 48.18,78.8 48.05,78.94 48.05,79.35 48.18,79.49 48.18,85.02 48.01,85.19 47.86,85.19 47.76,85.29 47.76,85.42 47.89,85.56 49.5,85.56 49.62,85.69 49.62,90.76 48.35,92.03 48.35,92.81 47.8,93.36 47.8,94.14 48.4,94.74 48.41,94.74 48.56,94.88 48.56,96.23 48.47,96.31 48.16,96.31 48.08,96.39 48.08,96.55 48.16,96.63 48.47,96.63 48.56,96.72 48.56,97.54 v8(48.66,97.65)
  L3-GND w0.06: v3(48.23,78.92) 48.25,78.92 v8(48.5,79.17)
  L3-GND w0.102: v8(48.66,97.65) v3(48.66,98.01)
  L5-SIG w0.16: v3(48.66,98.01) 48.66,98.13 48.4,98.4 48.4,98.52 46.53,100.4 v3(46.53,100.68)
  L6-GND w0.06: v6(48.37,78.42) 48.37,78.78 v3(48.23,78.92)
  L6-GND w0.102: v3(46.53,100.68) 46.5,100.71 v1(46.5,101.06) ; v3(48.66,98.01) v4(48.66,98.38)
  L7-SIG w0.076: v1(51.08,95.48) 51.82,96.22 51.82,97.88 51.51,98.19
  L7-SIG w0.081: v1(47.08,97.48) 47.16,97.48 47.3,97.63 47.6,97.63 47.67,97.7 47.67,98.15 47.82,98.3 47.97,98.3 48.03,98.23 48.16,98.23 48.29,98.36 48.29,98.59 48.21,98.66 47.91,98.66 47.87,98.7 47.87,98.91 47.86,98.92 47.86,99.27 47.94,99.35 48.26,99.35 48.34,99.27 48.34,99 48.42,98.92 48.54,98.92 48.62,98.99 48.62,99.22 48.69,99.3 48.95,99.3 49.02,99.22 49.02,98.77 48.94,98.69 48.62,98.69 48.53,98.6 48.53,98.51 v4(48.66,98.38) 48.72,98.43 49.66,98.43 49.77,98.54 51.25,98.54 51.51,98.28 51.51,98.19
42_M1_CA8: length 39.5
  L2-SIG w0.081: v8(48.84,75.22) 49.01,75.06 49.82,75.06 50.27,75.5 50.27,76.15 51.77,77.66 51.77,92.92 52.07,93.22 52.07,93.76 51.77,94.06 51.77,95.62 51.85,95.69 51.96,95.69 52.05,95.77 52.05,95.94 51.96,96.02 51.86,96.02 51.77,96.1 51.77,97.39 51.39,97.78 v8(50.85,97.78)
  L3-GND w0.06: v8(48.84,75.22) 48.84,75.54 v3(48.89,75.58)
  L3-GND w0.076: 51.05,98.19 51.05,97.98 v8(50.85,97.78)
  L3-GND w0.102: 51.05,98.19 51.05,98.44 v3(51.05,98.44)
  L5-SIG w0.16: v3(51.05,98.44) 52.12,99.51 v3(52.12,100.82)
  L6-GND w0.06: v6(49.15,75.83) 49.14,75.83 v3(48.89,75.58)
  L6-GND w0.102: v3(52.12,100.82) 52.4,101.1 v1(52.4,101.17) ; v4(50.37,98.27) 50.53,98.44 v3(51.05,98.44)
  L7-SIG w0.076: v1(47.08,96.98) 47.08,97.12 47.38,97.41 47.76,97.41 47.83,97.48 47.83,97.67 47.9,97.74 48.25,97.74 48.44,97.93 48.75,97.93 49,98.18 49.86,98.18 49.86,98.19 ; v1(50.65,95.48) 50.88,95.71 50.88,96.17 50.95,96.24 51.18,96.24 51.32,96.38 51.32,98.09 51.23,98.19
  L7-SIG w0.081: 51.23,98.19 51.14,98.27 v4(50.37,98.27) 50.35,98.3 49.97,98.3 49.86,98.19
42_M1_CA9: length 39.2
  L2-SIG w0.081: v8(50.32,98.82) 50.32,98.81 50.32,97.19 51.3,96.2 51.3,94.5 50.9,94.1 50.9,93.08 51.3,92.68 51.3,79.04 49.83,77.57 v8(49.83,77.55)
  L3-GND w0.06: v3(49.56,77.31) 49.6,77.31 v8(49.83,77.55)
  L3-GND w0.102: v8(50.32,98.82) 50.32,99.15 v3(50.17,99.3)
  L5-SIG w0.16: v3(50.6,100.75) 50.17,100.32 v3(50.17,99.3) 50.91,100.03 51.09,100.03 51.27,99.85 51.27,99.67 49.89,98.3 49.89,96.96 50.04,96.81 50.04,95.56 v1(50.08,95.51)
  L6-GND w0.06: v6(49.75,76.96) 49.56,77.15 v3(49.56,77.31)
  L6-GND w0.102: v1(50.93,101.17) 50.93,101.08 v3(50.6,100.75) ; v3(50.17,99.3) 49.94,99.06 v4(49.94,98.92)
  L7-SIG w0.076: v1(47.08,96.48) 46.84,96.72 46.84,97.58 47,97.74 47.18,97.74 47.4,97.96 47.4,98.19
  L7-SIG w0.081: v4(49.94,98.92) 49.94,98.99 49.34,99.59 47.82,99.59 47.63,99.4 47.63,98.43 47.4,98.21 47.4,98.19
42_M1_CKE0: length 29.6
  L2-SIG w0.081: v8(47.43,94.4) 47.75,94.73 47.9,94.73 47.98,94.64 47.98,94.55 47.4,93.96 47.22,93.96 47.02,93.76 47.02,92.9 47.27,92.64 47.27,92.43 47.22,92.37 47.22,92 48.87,90.34 48.87,86.83 48.33,86.29 46.75,86.29 46.59,86.13 46.59,85.53 46.5,85.44 46.19,85.44 46.06,85.31 46.06,85.08 46.19,84.95 46.57,84.95 46.65,84.87 46.65,84.63 46.57,84.55 46.2,84.55 46.08,84.43 46.08,84.26 46.2,84.14 46.57,84.14 46.65,84.06 46.65,83.82 46.57,83.74 46.21,83.74 46.09,83.62 46.09,83.45 46.21,83.33 46.57,83.33 46.65,83.25 46.65,83 46.57,82.92 46.18,82.92 46.06,82.8 46.06,82.64 46.18,82.52 46.57,82.52 46.65,82.43 46.65,82.19 46.57,82.11 46.26,82.11 46.18,82.03 46.18,81.78 46.26,81.7 46.57,81.7 46.65,81.62 46.65,81.38 46.57,81.3 46.26,81.3 46.18,81.22 46.18,80.97 46.26,80.89 46.57,80.89 46.65,80.81 46.65,80.57 46.57,80.48 46.26,80.48 46.18,80.4 46.18,80.2 46.25,80.13 46.5,80.13 46.63,80 46.63,79.75 46.73,79.65 46.78,79.65 47.01,79.42 v8(47.01,79.31)
  L3-GND w0.06: v3(47.21,79.01) 47.21,79.11 v8(47.01,79.31)
  L3-GND w0.076: v8(47.43,94.4) 47.53,94.4 v3(47.74,94.6)
  L5-SIG w0.076: v3(47.74,94.6) 47.87,94.74 48.4,94.74 48.64,94.5 49.04,94.5 49.15,94.38 50.18,94.38 v1(50.58,93.98)
  L6-GND w0.06: v6(47.46,78.76) v3(47.21,79.01)
42_M1_CKE1: length 29.3
  L2-SIG w0.081: v8(45.6,78.91) 45.6,78.51 45.37,78.29 45.19,78.29 45.07,78.41 45.07,79.33 44.97,79.42 44.66,79.42 44.48,79.6 44.48,79.81 44.6,79.94 44.79,79.94 44.92,80.06 44.92,80.32 44.79,80.45 44.54,80.45 44.48,80.51 44.48,86.35 46.14,88.01 46.14,88.47 46.22,88.56 46.6,88.56 46.69,88.64 46.69,88.8 46.6,88.88 46.22,88.88 46.14,88.96 46.14,89.12 46.22,89.21 46.6,89.21 46.69,89.29 46.69,89.45 46.6,89.53 46.22,89.53 46.14,89.61 46.14,89.77 46.22,89.86 46.6,89.86 46.69,89.94 46.69,90.1 46.6,90.18 46.22,90.18 46.14,90.26 46.14,90.42 46.22,90.51 46.6,90.51 46.69,90.59 46.69,90.75 46.6,90.83 46.22,90.83 46.14,90.91 46.14,96.46 46.29,96.62 46.73,96.62 46.79,96.56 v8(46.79,96.22)
  L3-GND w0.06: v3(45.94,78.75) 45.76,78.75 v8(45.6,78.91)
  L3-GND w0.076: v8(46.79,96.22) 47.18,95.83 v3(47.18,95.67)
  L6-GND w0.06: v6(46.11,78.45) 46.11,78.58 v3(45.94,78.75)
  L6-GND w0.076: v4(47.05,96.02) 47.05,95.8 v3(47.18,95.67)
  L7-SIG w0.076: v1(48.5,96.98) 48.5,96.92 48.05,96.48 47.92,96.48 47.68,96.24 47.28,96.24 v4(47.05,96.02)
42_M1_CKE2: length 29.4
  L2-SIG w0.081: v8(47.91,78.39) 48.06,78.39 48.11,78.44 48.11,78.6 48.01,78.7 47.83,78.7 47.78,78.75 47.78,78.93 47.73,78.98 47.52,78.98 47.47,79.03 47.47,79.21 47.52,79.26 47.73,79.26 47.78,79.31 47.78,79.51 47.73,79.56 47.48,79.56 47.4,79.64 47.4,79.76 47.48,79.84 47.83,79.84 47.91,79.92 47.91,80.14 47.82,80.22 47.55,80.22 47.47,80.3 47.47,80.47 47.55,80.55 47.82,80.55 47.91,80.63 47.91,80.79 47.82,80.87 47.55,80.87 47.47,80.95 47.47,81.12 47.55,81.2 47.82,81.2 47.91,81.28 47.91,81.44 47.82,81.52 47.55,81.52 47.47,81.6 47.47,81.77 47.55,81.85 47.82,81.85 47.91,81.93 47.91,82.09 47.82,82.17 47.55,82.17 47.47,82.26 47.47,82.42 47.55,82.5 47.82,82.5 47.91,82.58 47.91,82.74 47.82,82.82 47.55,82.82 47.47,82.91 47.47,83.07 47.55,83.15 47.82,83.15 47.91,83.23 47.91,83.39 47.82,83.47 47.55,83.47 47.47,83.56 47.47,83.72 47.55,83.8 47.82,83.8 47.91,83.88 47.91,84.04 47.82,84.12 47.55,84.12 47.47,84.21 47.47,84.37 47.55,84.45 47.82,84.45 47.91,84.53 47.91,84.81 47.84,84.88 47.54,84.88 47.5,84.92 47.5,85.4 47.4,85.5 47.4,85.73 47.46,85.8 49.08,85.8 49.34,86.07 49.34,90.66 48.12,91.88 48.12,92.68 47.9,92.9 47.44,92.9 47.17,93.16 47.17,93.59 47.24,93.66 v8(47.46,93.66)
  L3-GND w0.06: v8(47.91,78.39) 47.91,78.39 47.8,78.29 47.8,77.93 v3(47.82,77.91)
  L3-GND w0.076: v3(47.67,94.01) 47.46,93.81 v8(47.46,93.66)
  L5-SIG w0.076: v3(47.67,94.01) 48.22,94.56 48.36,94.56 48.58,94.35 48.97,94.35 49.13,94.19 49.88,94.19 v1(50.08,93.98)
  L6-GND w0.06: v3(47.82,77.91) 47.83,77.91 48.08,78.17 v6(48.09,78.17)
42_M1_CKE3: length 29.1
  L2-SIG w0.081: v8(45.93,79.29) 45.25,79.97 45.25,80.77 45.17,80.85 44.98,80.85 44.9,80.94 44.9,81.18 44.98,81.26 45.17,81.26 45.25,81.34 45.25,81.59 45.17,81.67 44.84,81.67 44.76,81.75 44.76,81.99 44.84,82.07 45.17,82.07 45.25,82.15 45.25,82.4 45.17,82.48 44.84,82.48 44.76,82.56 44.76,82.81 44.84,82.89 45.17,82.89 45.25,82.97 45.25,83.21 45.17,83.29 44.84,83.29 44.76,83.37 44.76,83.62 44.84,83.7 45.17,83.7 45.25,83.78 45.25,84.02 45.17,84.11 44.84,84.11 44.76,84.19 44.76,84.43 44.84,84.51 45.17,84.51 45.25,84.59 45.25,84.84 45.17,84.92 44.84,84.92 44.76,85 44.76,85.24 44.84,85.32 45.17,85.32 45.25,85.41 45.25,85.65 45.17,85.73 44.84,85.73 44.76,85.81 44.76,86.06 44.84,86.14 45.16,86.14 46.13,87.11 47.02,87.11 47.18,87.28 47.18,88.99 47.29,89.1 47.82,89.1 47.91,89.18 47.91,89.34 47.82,89.43 47.37,89.43 47.29,89.51 47.29,89.67 47.37,89.75 47.82,89.75 47.91,89.83 47.91,89.99 47.82,90.08 47.73,90.08 46.39,91.42 46.39,95.08 v8(46.73,95.42)
  L3-GND w0.06: v8(45.93,79.29) 46.19,79.29 v3(46.39,79.09)
  L3-GND w0.076: v8(46.73,95.42) 46.97,95.19 v3(46.97,95.16)
  L6-GND w0.06: v6(46.39,78.74) 46.39,79.09 v3(46.39,79.09)
  L6-GND w0.076: v3(46.97,95.16) 47.33,95.16 v4(47.35,95.13)
  L7-SIG w0.076: v1(48.49,96.47) 48.26,96.24 48,96.24 47.84,96.08 47.84,95.63 v4(47.35,95.13)
42_M1_CS0_N: length 32.8
  L2-SIG w0.081: v8(47.53,78.61) 47.53,78.28 47.09,77.83 46.79,77.83 46.69,77.94 46.69,78.72 46.99,79.03 47.22,79.03 47.29,79.1 47.29,79.46 46.89,79.86 46.89,80.03 46.97,80.11 47.13,80.11 47.22,80.19 47.22,80.44 47.13,80.52 46.97,80.52 46.89,80.6 46.89,80.84 46.97,80.93 47.13,80.93 47.22,81.01 47.22,81.25 47.13,81.33 46.97,81.33 46.89,81.41 46.89,81.66 46.97,81.74 47.13,81.74 47.22,81.82 47.22,82.06 47.13,82.15 46.97,82.15 46.89,82.23 46.89,82.47 46.97,82.55 47.13,82.55 47.22,82.63 47.22,82.88 47.13,82.96 46.97,82.96 46.89,83.04 46.89,83.28 46.97,83.36 47.13,83.36 47.22,83.45 47.22,83.69 47.13,83.77 46.97,83.77 46.89,83.85 46.89,84.1 46.97,84.18 47.13,84.18 47.22,84.26 47.22,84.5 47.13,84.58 46.97,84.58 46.89,84.66 46.89,84.91 46.97,84.99 47.13,84.99 47.23,85.08 47.23,85.3 47.13,85.4 46.97,85.4 46.85,85.52 46.85,85.86 47.02,86.04 48.98,86.04 49.11,86.16 49.11,90.53 47.85,91.79 47.85,92.03 47.8,92.07 47.57,92.07 47.48,92.16 47.48,92.26 v8(47.82,92.6)
  L3-GND w0.06: v3(47.23,78.38) 47.46,78.61 v8(47.53,78.61)
  L3-GND w0.076: v8(47.82,92.6) 47.88,92.66 v3(47.88,93.01)
  L6-GND w0.06: v3(47.23,78.38) 47.24,78.38 47.27,78.42 v6(47.73,78.42)
  L6-GND w0.076: v3(47.88,93.01) 47.82,93.07 v4(47.82,93.37)
  L7-SIG w0.076: v1(49.08,96.48) 48.93,96.48 48.68,96.22 48.48,96.22 48.34,96.08 48.34,95.89 47.95,95.5 47.95,94.68 47.75,94.49 47.75,93.43 v4(47.82,93.37) 47.82,93.06 47.91,92.96 48.03,92.96 48.1,93.03 48.1,93.17 48.14,93.22 48.41,93.22 48.48,93.15 48.48,92.82 48.55,92.74 49.68,92.74 49.72,92.78 50.19,92.78 50.32,92.91 50.32,93.12 50.29,93.16 50.29,93.16 50.08,93.37 v1(50.08,93.48)
