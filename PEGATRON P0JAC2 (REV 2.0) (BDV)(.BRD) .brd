# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART3_DEBUG_TXD: length 74.2
  L4-SIG w0.076: v3(45.84,66.28) 46.24,65.87 46.24,65.32
  L4-SIG w0.107: v3(54.31,62.58) 53.96,62.58 51.08,65.47 48.44,65.47 47.73,64.75 46.81,64.75 46.24,65.32
  L4-SIG w0.109: v3(87.1,87.87) 86.95,87.72 84.6,87.72 83.95,87.07 83.95,83.86 77.67,77.58 77.67,77.58 77.43,77.34 77.43,76.41 76.87,75.85 76.87,75.56 76.42,75.11 76.42,71 77.24,70.18 77.24,69.05 78.9,67.39 78.9,61.46 78.51,61.07 78.51,60.44 v3(78.61,60.34)
  L5-SIG w0.109: v3(78.61,60.34) 77.51,60.34 76.89,60.95 71.64,60.95 71.56,60.87 70.73,60.87 69.8,59.94 63.31,59.94 62.89,60.36 60.51,60.36 59.62,61.25 55.31,61.25 54.31,62.25 v3(54.31,62.58)
  L6-GND w0.06: v3(45.84,66.28) v6(46.08,66.52)
  L6-GND w0.102: v1(87.52,87.87) 87.39,88 87.23,88 v3(87.1,87.87)
  BOTTOM w0.31: CON3800.55 88.04,87.87 T3804.1
ULPMC_RST#: length 7.6
  BOTTOM w0.102: T3801.1 86.9,102.79 86.9,100.65 86.41,100.16 86.41,97.33 86.14,97.07 CON3800.10
USB2_DEBUG_DN: length 49.4
  L5-SIG w0.094: v6(60.78,63.66) 60.78,63.5 60.85,63.42 61.47,63.42 62.15,62.74 63.07,62.74 63.33,62.48 64.35,62.48 64.91,61.92 68.72,61.92 69.65,62.85 70.74,62.85 70.87,62.98 73.57,62.98 73.88,63.28 75.72,63.28 75.95,63.51 78.28,63.51 79.3,64.53 79.3,66.68 80.69,68.07 81.09,68.07 86.52,73.5 86.52,88.48 86.43,88.56 86.25,88.56 86.2,88.52 86.2,88.44 86.29,88.35 86.29,88.1 86.17,87.98 86,87.98 85.9,88.08 v3(85.9,88.2)
  L6-GND w0.102: v3(85.9,88.2) 85.83,88.27 v1(85.55,88.27)
USB2_DEBUG_DP: length 49.4
  L5-SIG w0.094: v6(60.5,63.31) 60.69,63.31 60.77,63.23 61.39,63.23 62.07,62.54 62.99,62.54 63.25,62.28 64.27,62.28 64.83,61.73 68.8,61.73 69.73,62.66 70.82,62.66 70.95,62.78 73.66,62.78 73.96,63.09 75.81,63.09 76.04,63.32 78.36,63.32 79.62,64.57 79.62,66.72 80.78,67.88 81.17,67.88 86.71,73.41 86.71,88.56 86.51,88.76 v3(85.9,88.76)
  L6-GND w0.102: v3(85.9,88.76) 85.81,88.67 v1(85.55,88.67)
USB2_DN: length 34.1
  L5-SIG w0.094: v6(60.22,63.66) 60.22,63.16 60.33,63.04 61.18,63.04 61.97,62.26 62.5,62.26 62.89,61.87 64.01,61.87 64.63,61.25 69.26,61.25 70.08,62.07 70.19,62.18 71.02,62.18 71.1,62.27 75.66,62.27 76.23,62.84 85.93,62.84 88.15,60.62 88.15,58.45 v3(87.68,57.98)
  L6-GND w0.102: v1(87.25,57.98) v3(87.68,57.98)
USB2_DOCK_DN: length 134.3
  L4-SIG w0.094: v3(28.1,7.83) 28.47,8.2 28.75,8.2 29.1,7.84 29.2,7.84 34.63,2.41 62.24,2.41 62.24,2.41 62.68,2.41 63.4,3.13 63.77,3.13 64.37,2.53 64.53,2.53 70.27,2.53 84.14,16.4 84.14,30.89 85.21,31.96 85.21,35.76 83.25,37.72 83.25,45.37 81.77,46.85 81.77,53.81 81.53,54.04 81.53,55.26 79.33,57.46 79.05,57.46 78.74,57.77 78.74,58.1 78.84,58.2 79.05,58.2 v3(79.2,58.05)
  L6-GND w0.102: v3(28.1,7.83) 28.34,8.07 v1(28.64,8.07) ; v3(79.2,58.05) 79.04,58.21 78.82,58.21 v4(78.68,58.06)
  L7-SIG w0.076: v6(60.78,64.23) 60.83,64.19 60.83,63.95 61.94,62.84 61.94,62.22 62.46,61.69 62.46,59.7 63.05,59.11 67.46,59.11 67.6,58.96 69.44,58.96 70.78,57.63 75.71,57.63 76.24,58.16 78.58,58.16 v4(78.68,58.06)
USB2_DOCK_DP: length 134.4
  L4-SIG w0.094: v3(79.18,58.61) 78.96,58.39 78.76,58.39 78.55,58.18 78.55,57.69 78.96,57.27 79.25,57.27 81.34,55.18 81.34,53.96 81.57,53.73 81.57,46.77 83.06,45.28 83.06,37.64 85.01,35.68 85.01,32.04 83.95,30.98 83.95,16.49 70.19,2.72 64.45,2.72 63.85,3.32 63.32,3.32 62.6,2.6 34.71,2.6 29.28,8.04 29.18,8.04 28.83,8.39 v3(28.12,8.39)
  L6-GND w0.102: v3(79.18,58.61) 78.98,58.41 78.76,58.41 v4(78.68,58.48) ; v3(28.12,8.39) 28.47,8.39 v1(28.64,8.57)
  L7-SIG w0.076: v6(60.5,64.51) 60.8,64.51 61.02,64.3 61.02,64.03 62.13,62.92 62.13,62.3 62.65,61.77 62.65,59.78 63.13,59.3 67.54,59.3 67.68,59.15 69.52,59.15 70.86,57.82 75.63,57.82 76.16,58.35 78.55,58.35 v4(78.68,58.48)
USB2_DP: length 34.1
  L5-SIG w0.094: v3(87.71,58.58) 87.96,58.82 87.96,60.54 85.85,62.64 76.31,62.64 75.74,62.07 71.18,62.07 71.1,61.99 70.27,61.99 70.21,61.93 69.34,61.06 64.55,61.06 64.44,61.17 63.93,61.68 62.81,61.68 62.42,62.07 61.89,62.07 61.1,62.85 60.25,62.85 60,63.11 60,63.76 60.2,63.96 v6(60.51,63.96)
  L6-GND w0.102: v1(87.3,58.58) v3(87.71,58.58)
USB3_REXT0: length 15.3
  L7-SIG w0.06: 58.69,64.1 58.69,64.86 58.3,65.24 58.09,65.24 v6(57.98,65.36)
  L7-SIG w0.102: 58.69,64.1 58.69,63.49 60.04,62.13 60.49,62.13 61.31,61.31 61.31,58.53 61.81,58.03 62.45,58.03 62.71,57.77 63.98,57.77 64.5,58.28 66.76,58.28 v1(67.29,58.81)
USB3_REXT1: length 14.3
  L7-SIG w0.06: 60.98,61.93 60.63,62.27 60.1,62.27 58.89,63.49 58.89,64.83 58.26,65.46 v6(58.26,65.54)
  L7-SIG w0.102: v1(66.62,58.81) 66.3,58.48 64.32,58.48 63.81,57.97 63.03,57.97 62.77,58.23 61.98,58.23 61.51,58.7 61.51,61.4 60.98,61.93
USB_DOCK_DM: length 22.4
  L7-SIG w0.076: v1(29.88,8.07) v1(29.88,8.57) 29.88,8.71 29.6,8.99 29.6,9.86 29.03,10.44 28.17,10.44 25.72,12.88 25.72,24.63 25.43,24.92 25.1,24.92 24,23.82 v1(24,22.5)
USB_DOCK_DP: length 23.4
  L7-SIG w0.076: v1(24,26.5) 24,26.09 24.98,25.11 25.51,25.11 25.91,24.71 25.91,12.96 28.25,10.63 29.11,10.63 29.79,9.94 29.79,9.18 v1(29.88,9.09) 30.15,8.82 30.15,7.83 v1(29.88,7.57)
  BOTTOM w0.178: v1(29.88,7.57) 29.88,6.66 v9(29.82,6.6)
USB_HSIC_RCOMP: length 9.7
  L7-SIG w0.127: v1(55.49,59.27) 55.44,59.32 55.44,62.49 55.4,62.54 55.4,63.96 55.97,64.53 55.97,65.98 56.75,66.76 v6(57.24,66.76)
  BOTTOM w0.127: R2622.1 56.02,59.24 55.52,59.24 v1(55.49,59.27)
USB_OC#: length 2.1
  BOTTOM w0.31: U5203.5 76.9,52.42 76.94,52.38 R5205.1 R5204.1
USB_PHY0_RST#: length 0.8
  L3-GND w0.06: v8(61.37,69.2) 61.27,69.2 v3(61.06,69)
  L6-GND w0.102: v6(60.78,68.76) 60.82,68.76 v3(61.06,69)
USB_RCOMP: length 10.4
  L4-SIG w0.127: v3(59.07,64.91) 59.49,65.34 63.27,65.34 64.95,63.66 64.95,62.43 65,62.38 v3(65,62.38)
  L6-GND w0.127: v3(59.07,64.91) 59.22,65.07 v6(59.38,65.07) ; v4(65.48,62.48) 65.11,62.48 v3(65,62.38)
  L7-SIG w0.127: v4(65.48,62.48) 66.14,62.48 v1(66.42,62.2)
  BOTTOM w0.127: U2400.H8 U2400.J7
VBCLK: length 3.6
  L7-SIG w0.084: v1(27.79,70.14) 27.42,70.5 27.42,71.16 v1(26.9,71.68)
  BOTTOM w0.229: U1001.30 27.35,69.55 27.36,69.56
  BOTTOM w0.31: 27.36,69.56 27.79,69.99 v1(27.79,70.14)
VOLUMEDOWN#: length 5.4
  BOTTOM w0.31: R2010.2 R2008.1 8.02,60.84 7.53,60.35 CON2002.1
VOLUMEUP#: length 5.4
  BOTTOM w0.31: R2011.2 R2009.1 8.02,61.5 7.37,60.85 CON2002.2
W_DISABLE#1: length 2.3
  BOTTOM w0.102: T5401.1 15.8,77.19 15.8,77.81 15.32,78.29 U5401.28
W_DISABLE#2: length 4.1
  BOTTOM w0.31: U5401.63 3.45,85.29 3.31,85.43 R5418.2 C5410.1 R5420.2 2.81,83.84 v9(2.83,83.84)
WL_DEV_EN: length 95.9
  L4-SIG w0.109: v3(40.41,55.18) 40.45,55.14 40.45,54.77 42.87,52.36 45.09,52.36 46.98,50.46 52.88,50.46 53.5,51.08 64,51.08 64.79,51.87 64.79,53.56 67.79,56.56 67.79,61.53 66.34,62.98 66.34,64.14 66.01,64.47 66.01,65.25 63.89,67.38 63.89,68.15 63.02,69.02 v3(61.86,69.02)
  L5-SIG w0.06: v3(61.86,69.02) 61.77,69.02 61.18,69.61 v6(61.11,69.61)
  L5-SIG w0.109: v3(6.53,73.44) 7.42,72.56 20.68,72.56 20.69,72.57 21.85,72.57 22.83,71.58 25.88,71.58 27.44,70.02 27.44,69 30.29,66.15 30.29,62.83 33.23,59.88 33.23,58.33 36.07,55.49 38.88,55.49 38.95,55.56 40.04,55.56 v3(40.41,55.18)
  L6-GND w0.102: v1(6.53,73.82) v3(6.53,73.44)
  BOTTOM w0.31: T5407.1 v1(6.53,73.82)
WL_DEV_WAKE: length 2.7
  BOTTOM w0.31: R5425.2 16.51,79.77 16.18,80.1 16.18,81.01 15.9,81.29 U5401.22
WLAN_DEV_WAKE: length 158.4
  L5-SIG w0.06: 59.33,66.48 58.85,66.96 58.85,67.29 v6(58.8,67.34)
  L5-SIG w0.109: v3(83.63,72.53) 82.13,72.53 80.77,71.17 80.77,69.63 80.54,69.4 80.14,69.4 77.87,67.13 77.87,66.47 76.92,65.51 76.74,65.51 73.13,65.51 72.68,65.07 69.92,65.07 69.17,64.32 66.59,64.32 66.35,64.56 61.72,64.56 59.8,66.48 59.33,66.48
  L6-GND w0.102: v3(83.63,72.53) 83.63,72.88 v4(83.65,72.91)
  L7-SIG w0.084: v4(83.65,72.91) 83.84,73.1 83.84,83.04 84.63,83.82 86.05,83.82 88.72,86.49 88.72,90.65 88.64,90.74 88.64,99.31 v1(84.96,102.99) 83.71,104.23 78.38,104.23 77.98,104.63 73.61,104.63 72.92,103.95 61.54,103.95 61.11,104.38 30.68,104.38 28.68,102.37 27.97,102.37 26.49,100.9 21.24,100.9 18.62,98.28 18.62,88.86 15.24,85.48 15.24,81.09 16.67,79.67 16.81,79.52 v1(17.58,79.52)
  BOTTOM w0.31: v1(84.96,102.99) 84.96,103.91 T5406.1
WLAN_HOST_WAKE#: length 100.1
  L4-SIG w0.102: v3(62.75,67.29) 66.13,63.91 66.13,62.89 67.58,61.45 67.58,56.65 64.58,53.65 64.58,51.96 63.91,51.29 51.46,51.29 50.85,50.67 47.07,50.67 45.18,52.56 42.96,52.56 40.96,54.56 v3(40.96,55.06)
  L5-SIG w0.06: v6(58.86,69.04) 59.4,69.04 60.11,68.33 60.46,68.33 60.72,68.07 61.34,68.07 61.99,67.42 62.62,67.42 v3(62.75,67.29)
  L5-SIG w0.102: v3(40.96,55.06) 40.7,54.8 40.19,54.8 39.65,55.35 39.04,55.35 38.97,55.28 35.98,55.28 33.01,58.25 33.01,59.81 30.08,62.74 30.08,66.04 27.23,68.89 27.23,69.93 25.79,71.37 22.75,71.37 21.76,72.36 20.78,72.36 20.77,72.35 6.1,72.35 5.03,73.42 v3(5.03,73.44)
  L6-GND w0.102: v3(5.03,73.44) v1(5.03,73.82)
  BOTTOM w0.102: v1(5.03,73.82) 5.44,73.42 5.44,71.9 T5405.1
WLBT_1V8: length 19.4
  L7-SIG w0.203: v1(8.31,73.14) 8.51,73.34 8.51,74.13 8.77,74.39 v1(8.77,74.69) v1(8.03,74.69) 7.77,74.69 7.26,74.18 v1(7.26,73.82) 5.71,72.27 v1(5.03,72.27) 5,72.3 v1(4.22,72.3) 2.46,72.3 1.88,72.88 v1(1.88,75.09) v1(1.88,76.74) v1(1.88,78.32) v1(1.88,79.87)
  BOTTOM w0.203: R5427.2 7.89,73.09 7.8,73 7.8,71.96 v9(8.33,71.43)
WRST#: length 24
  L7-SIG w0.102: v1(78.4,68.13) 78.56,68.13 78.74,68.31 78.74,70.11 78.54,70.32 78.54,72.22 78.46,72.3 78.46,72.62 78.68,72.83 79.82,72.83 80.39,73.4 80.39,76.92 80.17,77.14 80.17,80.47 79.88,80.76 79.88,81.52 80.47,82.1 81.88,82.1 84.35,84.57 84.66,84.57 v1(84.99,84.9)
  BOTTOM w0.102: U3001.23 78.2,69.14 C3001.1 R3001.2
XDP_H_PRDY#: length 57.5
  L4-SIG w0.102: v2(86.34,95.49) 85.91,95.49 80.5,90.08 80.2,90.08 80.2,90.08 79.87,90.08 76.54,86.75 v3(75.16,86.75)
  L6-GND w0.102: v4(75.16,86.4) 75.16,86.4 v3(75.16,86.75)
  L7-SIG w0.06: v6(61.14,66.21) 61.19,66.25 62.2,66.25 62.37,66.09
  L7-SIG w0.102: v4(75.16,86.4) 75.46,86.09 75.46,84.31 75.82,83.96 75.82,81.09 76.89,80.02 77.11,80.02 77.51,79.62 77.51,77.61 77.67,77.44 78.46,77.44 78.72,77.18 78.72,75.95 79.28,75.39 79.28,73.99 77,71.71 76.77,71.71 76.53,71.47 76.53,69.46 76.07,69 75.32,68.25 75.32,68.09 75.32,67.78 74.17,66.63 73.58,66.63 73.11,67.1 70.91,67.1 70.46,67.1 69.98,66.62 69.98,66.26 68.97,65.26 66.93,65.26 66.68,65.01 66.16,65.01 66.02,64.86 65.69,64.86 65.21,64.38 64.58,64.38 64.13,64.83 63.63,64.83 62.37,66.09 ; v1(87.53,96.27) 87.11,96.27 v2(86.34,95.49)
  BOTTOM w0.102: v9(88.6,95.82) 88.39,95.82 87.94,96.27 CON3800.13
XDP_H_PREQ#: length 61.9
  L4-SIG w0.102: v3(87.91,96.58) 87.61,96.89 87.61,97.09 87.33,97.37 87.02,97.37 86.79,97.14 86.79,95.37 85.2,93.78 84.53,93.78 80.64,89.88 80.12,89.88 80.12,89.88 79.95,89.88 74.91,84.83 74.91,80.7 74.56,80.35 73.28,80.35 69.32,76.39 69.32,71.94 69.04,71.66 68.07,71.66 66.75,70.34 v3(66.75,69.86) 66.75,67.99 67.52,67.22 67.52,65.76 v3(68.09,65.2)
  L5-SIG w0.102: v3(62.71,65.74) 63.01,65.44 67.84,65.44 v3(68.09,65.2)
  L6-GND w0.102: v1(87.53,96.67) 87.82,96.67 v3(87.91,96.58) ; v5(62.66,66.15) 62.71,66.1 v3(62.71,65.74) ; v3(66.75,69.86) 66.57,69.68 v1(66.29,69.68)
  L7-SIG w0.06: v6(59.93,66.21) 60.22,66.21 60.42,66.41 62.4,66.41 v5(62.66,66.15)
  L7-SIG w0.102: v1(87.53,96.67) 85.66,98.54 85.01,98.54 v1(84.4,99.15)
  BOTTOM w0.102: v1(87.53,96.67) CON3800.11 88.01,96.67 88.42,96.25 88.87,96.25 89.4,95.72 v9(90.4,95.72)
XDP_H_TDI: length 58.8
  L4-SIG w0.102: v3(88.01,98.67) 88.49,98.18 88.49,96.18 84.63,92.32 84.63,91.92 84.24,91.53 83.72,91.53 82.56,90.36 82.56,90.06 80.44,87.95 80.44,87.76 76.12,83.43 76.12,78.08 75.18,77.14 72.37,77.14 72.03,77.14 70.68,75.79 70.14,75.25 70.14,73.2 70.95,72.39 70.95,72.14 71.93,71.16 71.93,68.93 71.4,68.4 71.4,66.61 v3(71.51,66.5)
  L6-GND w0.102: v3(71.51,66.5) v4(71.15,66.5) ; v3(88.01,98.67) v1(87.65,98.67)
  L7-SIG w0.06: 62.13,65.66 62.07,65.71 61.18,65.71 61.08,65.81 60.62,65.81 60.5,65.93 v6(60.22,65.93)
  L7-SIG w0.102: v4(71.15,66.5) 71.15,65.9 69.32,64.07 68.92,64.07 68.69,63.84 67.66,63.84 67.38,64.12 67.14,64.12 66.97,63.94 66.64,63.94 v1(66.42,63.73) 66.23,63.92 64.58,63.92 64.38,64.12 63.66,64.12 62.13,65.66
  BOTTOM w0.102: v1(87.65,98.67) 88.13,98.67 88.65,99.19 v9(88.65,99.33)
XDP_H_TDO: length 70
  L4-SIG w0.102: v3(72.07,66.51) 71.63,66.94 71.6,66.98 71.6,68.31 72.14,68.85 72.14,72.43 71.53,73.03 71.08,73.03 70.49,73.62 70.49,75.31 72.12,76.94 72.29,76.94 72.29,76.94 75.27,76.94 76.32,78 76.32,81.34 80.65,85.67 80.65,87.86 82.76,89.98 82.76,90.28 83.81,91.32 84.33,91.32 84.84,91.83 84.84,92.24 88.7,96.1 88.7,98.52 88.17,99.05 87.85,99.05 87.28,98.47 v3(87.28,98.27)
  L5-SIG w0.102: v3(60.82,62.49) 61.44,61.86 61.95,61.86 62.61,61.2 63.6,61.2 v3(63.69,61.11)
  L6-GND w0.102: v4(64,60.83) 63.97,60.83 v3(63.69,61.11) ; v1(87.65,98.27) v3(87.28,98.27) ; v4(72.06,66.15) 72.06,66.15 72.06,66.5 v3(72.07,66.51) ; v5(60.02,62.65) 60.21,62.83 60.47,62.83 v3(60.82,62.49)
  L7-SIG w0.06: v5(60.02,62.65) 59.89,62.65 59.08,63.46 v6(59.08,65.94)
  L7-SIG w0.102: v4(64,60.83) 64.07,60.76 66.37,60.76 v1(67.16,61.55) 67.67,61.55 67.97,61.86 69.16,61.86 70.44,63.14 70.44,64.53 v4(72.06,66.15)
  BOTTOM w0.102: v9(89.27,101.19) 89.37,101.09 89.37,98.84 89.16,98.62 88.61,98.62 88.25,98.27 v1(87.65,98.27)
XDP_H_TMS: length 77.8
  L2-SIG w0.102: v8(80.11,59.75) 80.11,62.6 81.98,64.46 81.98,67.9 81.64,68.24 81.64,71.89 82.42,72.68 83.62,72.68 87.02,76.08 87.02,80.91 89.56,83.45 89.56,94.95 88.38,96.13 v8(88.38,97.87)
  L3-GND w0.102: v3(88.01,97.87) v8(88.38,97.87) ; v8(80.11,59.75) 80.11,59.75 80.11,59.75 v3(79.56,59.75)
  L5-SIG w0.102: v3(60.99,59.33) 61.31,59.65 62.05,59.65 62.15,59.54 62.76,59.54 62.88,59.43 70.49,59.43 71.8,60.75 75.05,60.75 76.05,59.75 v3(79.56,59.75)
  L6-GND w0.102: v1(87.65,97.87) v3(88.01,97.87) ; v1(60.98,59.79) 60.99,59.77 v3(60.99,59.33)
  L7-SIG w0.06: 60.04,61.93 58.02,63.95 58.02,64.86 57.77,65.11 57.77,65.45 58.07,65.74 58.32,65.74 58.78,66.2 v6(58.78,66.23)
  L7-SIG w0.102: v1(60.98,59.79) 60.98,61.36 60.6,61.73 60.24,61.73 60.04,61.93
  BOTTOM w0.102: v1(87.65,97.87) 88.14,97.87 88.49,98.22 89.67,98.22 90.44,97.44 v9(91.4,97.44)
XDP_H_TRST#: length 56.2
  L4-SIG w0.102: v3(87.17,96.99) 87.17,95.46 85.28,93.57 84.63,93.57 80.73,89.67 80.03,89.67 75.11,84.75 75.11,80.62 74.64,80.15 73.47,80.15 69.52,76.2 69.52,71.51 v3(67.69,69.68) 67.21,69.2 67.21,67.82 67.72,67.31 67.72,66.11 v3(68.07,65.76)
  L5-SIG w0.06: 62.18,66.48 61.24,66.48 60.17,67.55 58.72,67.55 58.6,67.43 58.6,67.26 58.72,67.14 58.72,66.87 v6(59.36,66.22)
  L5-SIG w0.102: 62.18,66.48 62.54,66.13 63.37,66.13 63.85,65.65 67.96,65.65 v3(68.07,65.76)
  L6-GND w0.102: v1(87.53,97.47) 87.17,97.11 v3(87.17,96.99) ; v3(67.69,69.68) 67.58,69.79 v1(67.27,69.79)
  BOTTOM w0.102: CON3800.7 88.39,97.47 88.52,97.34 v9(89.52,97.34)
N43112359:
  vias: v9(73.57,37.74)
N43112585: length 8.7
  L7-SIG w0.102: v1(79.78,47.84) 79.78,45.76 78.64,44.61 74.98,44.61 v1(74.55,44.18) v1(73.86,44.18)
N45935989: length 1
  L3-GND w0.102: v8(75.74,44.99) 75.74,44.41 v3(75.72,44.38)
  L6-GND w0.102: v3(75.72,44.38) 75.67,44.34 v1(75.67,44.01)
N46908093: length 3.6
  BOTTOM w0.254: R1119.1 23.39,60.14 R1125.2 24.99,60.39 25.06,60.46 C1102.1 R1118.1
N50246848: length 0.9
  L7-SIG w0.102: v1(87.37,33.77) 86.94,33.77 86.92,33.79 v1(86.5,33.79)
N50248755: length 6.5
  L7-SIG w0.102: v1(87.8,27.9) 87.29,28.4 v1(87.29,29.32) v1(86.56,29.32) v1(85.82,29.32)
  BOTTOM w0.102: v9(85.34,26.17) 86.29,27.12 86.29,27.53 86.66,27.9 v1(87.8,27.9)
N54799847: length 58.2
  L2-SIG w0.381: v8(69.34,41.54) 69.34,27.7 69.22,27.57 v8(69.22,26.98)
  L3-GND w0.254: v8(69.22,26.98) 68.91,26.68 v3(68.91,26.3)
  L3-GND w0.381: v3(68.86,41.74) 69.14,41.74 v8(69.34,41.54)
  L4-SIG w0.381: v3(68.86,41.74) 66.59,44.02 58.97,44.02 v3(58.7,44.28) ; v3(68.91,26.3) 68.63,26.3 67.74,25.41 62.46,25.41 v3(60.27,23.23)
  L6-GND w0.06: 58.54,38.09 58.54,37.08 v6(58.68,36.94)
  L6-GND w0.102: 58.54,38.09 58.54,38.46 59.03,38.96 59.03,40.04 58.78,40.29
  L6-GND w0.152: 60.43,31.14 60.43,31.68 59.49,32.62 v6(59.49,32.94)
  L6-GND w0.254: v4(59.89,23.5) 60.2,23.2 60.25,23.2 v3(60.27,23.23)
  L6-GND w0.381: 58.78,40.29 58.78,40.95 58.79,40.97 58.79,42.03 58.7,42.12 v3(58.7,44.28) ; v1(69.62,41.45) 69.33,41.74 v3(68.86,41.74) ; 60.43,31.14 60.43,30.87 61.3,30 61.3,26.9 61.27,26.86 v4(61.27,25.82)
  L7-SIG w0.381: v4(61.27,25.82) 61.18,25.73 59.62,25.73 v1(59.56,25.67) 59.89,25.34 v4(59.89,23.5)
  vias: v9(69.97,42.38)
N54800277: length 24.4
  L4-SIG w0.102: v3(58.01,44.28) 57.81,44.49 51.21,44.49 46.71,39.99 v3(45.34,39.99)
  L6-GND w0.102: v6(58.34,37.33) 58.34,37.91 57.66,38.59 57.66,42.17 58.01,42.53 v3(58.01,44.28) ; v1(44.98,39.99) v3(45.34,39.99)
  BOTTOM w0.102: v1(44.98,39.99) 43.89,39.99 C8310.1 R8366.2
N54802100: length 25.7
  L6-GND w0.06: 61.71,31.23 61.64,31.3 61.64,31.5 60.32,32.81 60.32,32.92 v6(60.3,32.94)
  L6-GND w0.102: v4(62.92,25.77) 62.92,26.04 62.64,26.32 62.64,30.3 61.71,31.23
  L7-SIG w0.102: v1(71.32,27.29) 70.84,26.81 70.43,26.81 70.03,27.21 68.07,27.21 66.7,25.84 64.78,25.84 64.63,25.69 64.26,25.69 62.64,24.06 62.64,22.37 62.47,22.21 62.24,22.21 61.8,22.65 61.8,24.06 62.92,25.18 v4(62.92,25.77)
  BOTTOM w0.102: v1(71.32,27.29) R8365.2
N54837978: length 4.2
  L7-SIG w0.102: v1(37.19,41.63) 37.35,41.46 v1(37.87,41.46) 38.33,41.46 38.38,41.51 v1(38.59,41.51)
  BOTTOM w0.102: v9(40.36,43.61) 38.86,42.11 Q8402.3
N55037572: length 54.8
  L4-SIG w0.109: v3(80.17,60.93) 81.8,59.31 81.8,57.61 84.51,54.9 v3(84.51,53.68)
  L6-GND w0.06: 62.33,37.04 61.95,37.04 61.24,36.33 60.95,36.33 v6(60.75,36.54)
  L6-GND w0.102: v4(69.06,36.99) 69.01,37.04 62.33,37.04 ; v4(84.51,53.12) v3(84.51,53.68) ; v3(80.17,60.93) 80.16,60.93 80.16,60.94 79.93,61.17 v1(79.91,61.17)
  L7-SIG w0.102: v4(84.51,53.12) 84.51,49.72 84.8,49.42 84.8,39.25 80.05,34.49 77.49,34.49 77.01,34.96 74.58,34.96 74.42,34.81 73.45,34.81 73.05,35.21 70.26,35.21 69.83,35.65 69.83,36.23 v4(69.06,36.99)
  BOTTOM w0.102: T8507.1 78.16,61.48 78.77,60.86 79.6,60.86 v1(79.91,61.17)
N55037573: length 54.5
  L4-SIG w0.109: v3(80.55,61.39) 81.93,61.39 83.3,60.02 83.3,57.88 83.67,57.51 83.67,57.51 84.94,56.24 v3(84.94,53.3)
  L6-GND w0.06: 61.71,36.61 61.69,36.61 61.29,36.21 60.78,36.21 v6(60.72,36.15)
  L6-GND w0.084: 62.33,36.69 61.78,36.69 61.71,36.61
  L6-GND w0.102: v3(80.55,61.39) 80.55,61.55 v4(80.39,61.71) ; 62.33,36.69 68.48,36.69 68.8,36.36 68.82,36.36 v4(69.05,36.13) ; v4(84.94,52.82) v3(84.94,53.3)
  L7-SIG w0.102: v4(69.05,36.13) 70.17,35.01 72.72,35.01 73.63,34.1 80.24,34.1 85.14,39 85.14,49.79 84.94,50 v4(84.94,52.82) ; v1(79.91,61.91) 80.19,61.91 v4(80.39,61.71)
  BOTTOM w0.102: T8506.1 79.63,61.63 v1(79.91,61.91)
N55396009: length 12.9
  L5-SIG w0.102: v3(62.59,38.14) 63.75,36.97 71.53,36.97 v3(71.88,36.61)
  L6-GND w0.102: v3(62.59,38.14) 62.32,38.14 v6(61.52,37.34) ; v1(72.44,35.87) 72.44,36.05 v3(71.88,36.61)
  BOTTOM w0.102: v1(72.44,35.87) 72.44,35.82 R8450.2
N55582751: length 2.3
  L7-SIG w0.254: v1(22.42,65.8) 22.57,65.94 v1(24.7,65.94)
N55583031: length 1.5
  BOTTOM w0.178: U1001.18 24.24,65.54
  BOTTOM w0.254: 24.24,65.54 23.54,65.54 C1003.2
N55583175: length 1.6
  BOTTOM w0.178: U1001.20 24.22,66.34
  BOTTOM w0.254: 24.22,66.34 23.7,66.34 C1004.2
N55583183: length 2.7
  BOTTOM w0.178: U1001.21 24.17,66.74
  BOTTOM w0.254: C1004.1 22.93,67.27 23.6,67.27 24.12,66.74 24.17,66.74
N55584679: length 4.1
  BOTTOM w0.178: U1001.15 24.24,64.34
  BOTTOM w0.254: R1047.2 21.95,65.69 21.95,65.42 C1001.1 23.16,64.6 C1002.2 24.13,64.34 24.24,64.34
N55851405: length 6
  L7-SIG w0.102: v6(45.75,63.95) 45.37,63.95 44.95,63.53 42.22,63.53 42.17,63.48 42.07,63.38 41.95,63.38 41.22,62.65 40.72,62.65 v1(40.41,62.34)
N55851407: length 8.4
  L7-SIG w0.102: v1(39.09,62.44) 39.95,62.44 40.39,62.87 41.14,62.87 41.86,63.6 42,63.6 42.08,63.69 42.13,63.73 44.85,63.73 45.35,64.23 v6(46.08,64.23)
  BOTTOM w0.102: T2602.1 39.04,62.39 v1(39.09,62.44)
N55851409: length 7.9
  L7-SIG w0.102: v6(46.07,64.83) 45.82,64.59 41.73,64.59 41.3,64.16 41.3,63.75 41.14,63.59 40.91,63.59 40.8,63.69 40.26,63.69 v1(39.9,63.33)
  BOTTOM w0.102: v1(39.9,63.33) 39.9,63.41 T2600.1
N55956187: length 0.8
  L7-SIG w0.254: v1(84.71,92.69) 84.74,92.67 v1(85.55,92.67)
N56361708: length 6.5
  L7-SIG w0.102: v1(85.62,59.34) 85.62,60.39 85.19,60.82 85.19,62.35 v1(84.87,62.67)
  BOTTOM w0.102: R0706.2 84.53,64.86 84.4,64.73 84.4,63.8 R0704.2 v1(84.87,62.67)
N56361884: length 4.8
  BOTTOM w0.254: R0757.2 88.09,60.13 87.68,60.53 Q0703.1 86.58,61.13 86.23,61.48 86.06,61.48 C0722.2 R0755.2
N56362286: length 1
  BOTTOM w0.102: 87.22,59.52 86.82,59.52 86.64,59.34 Q0704.6
N56674697: length 1.1
  BOTTOM w0.102: 73.88,93.33 R3340.2
N56674876: length 2.9
  L7-SIG w0.102: v1(77.3,80.46) 77.69,80.07 78.04,80.07 v1(78.69,79.42)
  BOTTOM w0.102: R3343.2 76.84,80.71 76.84,80.83 R3351.1
N56674880: length 3.9
  BOTTOM w0.254: U3304.2 78.69,78.26 78.97,78.55 79.99,78.55 80.29,78.85 Q3301.3 80.29,79.74 80.16,79.87 R3352.2
N57330511: length 18.1
  L5-SIG w0.06: v6(58.29,36.14) 58.29,36.23 57.8,36.73 57.11,36.73 56.88,36.95 56.88,38.21 56.5,38.59
  L5-SIG w0.102: v3(47.19,46.44) 50.19,46.44 54.81,41.82 55.68,41.82 56.49,41.01 56.49,38.6 56.5,38.59
  L6-GND w0.102: v1(47.07,45.98) 47.07,46.31 v3(47.19,46.44)
N57534678: length 2.4
  BOTTOM w0.254: R1117.2 R1116.2 25.69,58.48 25.45,58.72 C1106.1
N57840224:
  vias: v9(77.57,22.49)
N57908913: length 18.7
  L2-SIG w0.508: v2(86.82,27.25) 86.82,29.65 90.02,32.85 v2(90.02,37.07)
  BOTTOM w0.102: R0902.2 88.64,42.6 v9(88.51,42.47)
  BOTTOM w0.432: v2(90.12,46.31) R0905.2 R0906.2 ; v2(90.02,37.07) 89.96,37.13 R0901.2 ; R0902.2 R0907.2 v2(90.07,43.27)
  BOTTOM w0.457: v2(90.12,49.21) 89.91,49.21 R0904.2
  BOTTOM w0.508: Q0901.3 v2(86.82,27.25) ; v2(90.09,39.56) R0900.2 R0903.2
N58054896:
  vias: v9(36.72,26.73)
N58054914: length 1.8
  BOTTOM w0.102: U8800.7 31.77,22.18 31.43,21.84 R8833.2
N58054916:
  vias: v9(32.88,26.82)
N58056974:
  vias: v9(45.61,4.31)
N58056982: length 19.8
  L2-SIG w0.254: v8(48.79,22.31) 48.79,18.6 48.98,18.42 48.98,6.52 48.28,5.83 v8(47.57,5.83)
  L3-GND w0.254: v3(48.34,22.31) v8(48.79,22.31) ; v8(47.57,5.83) v3(47.14,5.83)
  L6-GND w0.254: v1(47.52,22.31) 47.52,22.31 v3(48.34,22.31) ; v1(47.14,5.32) v3(47.14,5.83)
N58056996: length 1.5
  BOTTOM w0.254: SR9001.1 46.38,23.94 46.15,24.17 U9000.11
N58057009: length 6
  BOTTOM w0.102: U9000.4 42.71,25.17 42.47,25.41 42.47,26.45 C9008.1 42.52,26.83 42.13,27.22 42.13,27.78 42.23,27.88 42.23,28.4 41.97,28.65 41.97,29.11 v9(41.23,29.85)
N58057015: length 2.8
  BOTTOM w0.102: R9003.1 42.22,26.07 42.22,24.93 42.47,24.67 U9000.3
N58057035: length 1.5
  BOTTOM w0.254: U9000.10 46.61,24.67 SR9000.1
N58057050: length 2.4
  BOTTOM w0.102: U9000.2 42.69,24.17 42.01,24.84 42.01,25.54 C9007.1
N58057057: length 2.1
  BOTTOM w0.254: R9001.2 R9002.1 46.06,23.67 U9000.12
N58057069: length 11.5
  L2-SIG w1.016: 47.98,7.93 47.98,16.65 47.09,17.54 47.09,19.11
  vias: v2(46.81,20.53) v2(47.5,20.53) v2(48.24,7.58) v2(48.24,6.87)
N58057081:
  vias: v9(40.83,19.75)
N58057101: length 11.2
  L7-SIG w0.203: v1(41.61,22.26) 41.61,21.78 40.77,20.94 v1(40.77,15.95) ; v1(41.61,22.26) 42.66,22.26 v1(43.47,23.07) ; v1(41.61,22.26) v1(41.61,23) v1(41.61,23.73)
  BOTTOM w0.102: v9(42.47,22.4) 42.32,22.26 v1(41.61,22.26)
N58057127: length 3.6
  L7-SIG w0.102: v1(43.97,23.07) 43.97,22.31 v1(43.16,21.5) 42.77,21.11 42.01,21.11 v1(41.72,21.41)
N58057155: length 1.7
  BOTTOM w0.254: SR9002.1 46.07,25.17 U9000.9
N58057163: length 3.7
  BOTTOM w0.102: v9(42.75,28.77) 43.38,28.14 43.38,28.08 SR9003.1
  BOTTOM w0.254: SR9003.1 44.47,27 U9000.7
N58626283: length 1
  L3-GND w0.102: v3(58.22,17.09) 58.45,17.09 v8(58.57,17.22)
  L6-GND w0.102: v1(58.31,17.61) 58.31,17.19 v3(58.22,17.09)
N58759745: length 2.9
  L7-SIG w0.102: v1(30.46,36.18) v1(30.46,35.42) 30.46,35.08 31.46,34.08 v1(31.53,34.08)
  BOTTOM w0.102: v1(31.53,34.08) U8901.D3
N58759758: length 3.1
  L7-SIG w0.102: v1(30.45,34.68) v1(30.45,33.94) v1(30.45,33.21) 31.16,33.21 v1(31.53,33.58)
  BOTTOM w0.102: v1(31.53,33.58) U8901.E3
N58983506: length 2.2
  L7-SIG w0.102: v1(34.41,34.44) 33.99,34.44 33.91,34.36 33.33,34.36 33.05,34.08 v1(32.39,34.08)
N58989919: length 14.1
  L7-SIG w0.102: v1(35.25,38.19) 35.25,38.29 34.67,38.87 32.48,38.87 31.23,40.12 30.54,40.12 30.18,40.48 30.18,47.39 29.59,47.97 v1(29.59,48.24)
N59743838: length 2.8
  BOTTOM w0.102: U5203.4 72.25,52.42 72.71,52.89 R5201.2 C5215.1
N59790830: length 4.2
  BOTTOM w0.102: R5870.1 R5822.2 70.7,115.37 v9(70.36,115.71) 68.91,117.16 U5804.A2
N59826752: length 3.1
  BOTTOM w0.102: U5801.11 27.55,99.97 T5807.1
N59827709: length 3.7
  BOTTOM w0.432: Q7001.3 30.72,49.06 30.35,49.43 R7005.2 30.05,50.28 29.69,49.92 C7003.1 C7001.1
N59885010: length 2.1
  BOTTOM w0.229: U3001.5 71.36,73.57 71.35,73.59 71.35,74 C3007.1 70.92,74.23 70.8,74.11 L3003.1
N60244404: length 9.5
  L7-SIG w0.762: 84.81,55.25 84.63,55.08 81.66,55.08 80.88,54.3 78.48,51.89 77.02,51.89 76.81,51.68
  vias: v1(76.1,51.77) v1(76.1,51.12) v1(76.1,50.47) v1(85.44,55.97) v1(85.44,55.58) v1(85.41,55.1) v9(85.31,54.25)
N60285321: length 12.3
  L3-GND w0.102: v3(97.89,112.88) v8(98.14,113.13)
  L5-SIG w0.102: v3(89.66,107.4) 90.24,107.4 94.1,111.26 96.27,111.26 v3(97.89,112.88)
  L6-GND w0.102: v3(89.66,107.4) v1(89.31,107.4)
  BOTTOM w0.102: v1(89.31,107.4) 88.56,107.4 v9(88.35,107.19)
N60474543: length 1.1
  L7-SIG w0.102: v1(85.2,33.79) 84.96,33.55 v1(84.96,32.83)
N60485144: length 3.2
  BOTTOM w0.381: U2101.3 75.43,97.94 75.36,98 C2126.2 R2131.1 R2134.2
N60517541: length 1.1
  L7-SIG w0.102: v1(53.84,21.5) 54.72,21.5 v1(54.91,21.69)
N60556074: length 11.5
  BOTTOM w0.178: U1001.10 26.15,62.53 25.62,62
  BOTTOM w0.254: 25.62,62 25.18,62 C1040.1 24.85,61.05 24.69,60.89 22.92,60.89 22.66,61.16 22.66,61.5 22.44,61.72 20.77,61.72 20.57,61.93 C1053.2 20.08,62.88 20.08,64.93 20.23,65.09 R1046.2
N60826251: length 2.9
  BOTTOM w0.178: 25.33,62.87 U1001.12
  BOTTOM w0.254: C1008.1 23.38,62.87 v9(23.72,62.87) 25.33,62.87
N60826256: length 3.5
  BOTTOM w0.178: 25.53,62.36 25.75,62.58 U1001.11
  BOTTOM w0.254: C1007.1 23.48,62.4 23.52,62.36 25.53,62.36
N60946431:
  vias: v1(31.59,16.24) v1(31.77,16.82) v1(32.43,16.09) v1(32.99,16.93) v4(31.59,16.24) v4(31.77,16.82) v4(32.43,16.09) v4(32.99,16.93)
N60977672:
  vias: v1(23.54,49.63) v1(23.55,49.32) v1(23.54,49.02) v1(23.54,48.69) v1(23.64,50.29) v1(23.84,49.63) v1(23.85,49.32) v1(23.85,49.02) v1(23.84,48.69) v1(23.94,50.29) v1(24.2,50.02) v1(24.17,49.64) v1(24.17,49.31) v1(24.17,49) v1(24.17,48.67) v1(24.48,49.64) v1(24.47,49.31) v1(24.48,49) v1(24.47,48.67) v1(24.51,50.02) v1(24.79,49.64) v1(24.79,49.31) v1(24.79,49) v1(24.79,48.67) v1(29.24,47.23) v1(29.24,46.9) v1(29.54,47.23) v1(29.54,46.9)
N60977700: length 11.9
  L7-SIG w0.102: v1(32.2,38.13) 32.2,38.76 31.05,39.91 30.46,39.91 29.95,40.42 29.95,47.22 29.26,47.91 v1(28.7,47.91)
N61001811: length 3.4
  L7-SIG w0.102: v1(35.2,47.2) 35.2,47.61 34.82,47.99 v1(34.42,47.99) 34.44,48 v1(34.44,48.65) 33.79,49.3 v1(33.32,49.3)
N61001912: length 4.9
  L7-SIG w0.084: v1(37.28,48.75) 36.38,48.75 v1(35.85,49.28) ; v1(37.28,48.75) 37.97,48.07 v1(38.13,48.07) ; v1(37.28,48.75) 37.28,49.01 37.26,49.02 v1(37.26,49.41)
  BOTTOM w0.31: R7007.1 38.43,48.07 v1(38.13,48.07)
N61018294: length 10.6
  L3-GND w0.102: v8(91.83,118.06) v3(92.2,118.06)
  L6-GND w0.102: v3(92.2,118.06) 92.38,118.06 v4(92.53,117.9)
  L7-SIG w0.102: v1(87.83,110.47) v1(88.57,110.47) 92.3,114.21 92.3,117.67 v4(92.53,117.9)
N61045998: length 26.5
  L7-SIG w0.102: v1(87.07,15.4) 86.89,15.4 v1(85.23,13.74) 85.23,13.43 83.31,11.51 66.18,11.51 64.51,13.17 63.85,13.17 v1(63.29,13.73)
N61046001: length 5
  BOTTOM w0.102: R7132.1 84.05,14.08 84.05,15.07 84.36,15.39 Q7142.1 85.31,15.39 85.4,15.47 85.4,16.57 85.28,16.69 Q7142.3
N61046551: length 26.8
  L7-SIG w0.102: v1(64.74,15.43) v1(64.74,14.66) v1(64.74,13.9) 64.74,13.61 66.45,11.9 78.72,11.9 79.71,12.89 80.01,12.89 83.44,16.32 84.86,16.32 85.14,16.04 v1(87.07,16.04)
N61060018: length 1.1
  BOTTOM w0.102: v9(72.1,40.56) 71.65,41.01 R8113.2
N61060048: length 3.9
  BOTTOM w0.102: v9(68.76,43.63) 70.38,43.63 70.45,43.7 71.42,43.7 71.6,43.88 Q8100.2
N61183239: length 1
  L3-GND w0.102: v3(68.43,68.06) v8(68.43,68.44)
  L6-GND w0.102: v3(68.43,68.06) 68.71,68.34 v1(68.89,68.34)
N61655404: length 3.5
  BOTTOM w0.102: R3042.1 75.49,80.63 Q3004.5 75.49,79.49 75.72,79.26 76,79.26 76.14,79.4 Q3004.6
N61684746: length 3.4
  BOTTOM w0.102: R8117.2 R8123.1 34.39,42.17 32.52,42.17 32.36,42.34 U8101.B3
N61684748: length 10.7
  L7-SIG w0.102: v1(32.36,43.01) 32.36,42.62 32.65,42.33 35.16,42.33 35.21,42.28 35.71,42.28 v1(36.45,43.01)
  BOTTOM w0.102: R8132.1 36.12,42.61 R8133.1 36.94,43.43 38.85,43.43 39.58,44.15 v9(39.58,45.2)
N61766419: length 14.8
  L3-GND w0.254: v8(93.75,78.6) 93.98,78.6 93.98,78.6 v3(94.11,78.6)
  L6-GND w0.254: v4(94.11,78.24) 94.11,78.6 v3(94.11,78.6)
  L7-SIG w0.254: v4(94.11,78.24) 93.46,77.59 92.43,76.56 92.43,67.6 v1(92.08,67.24) v1(92.08,66.48) v1(91.38,66.48) v1(91.38,67.24)
N61766442: length 14.9
  L3-GND w0.102: v8(95.65,78.6) 95.65,78.6 v3(95.3,78.6)
  L6-GND w0.102: v3(95.3,78.6) 95.28,78.58 95.28,78.25 v4(95.27,78.24)
  L7-SIG w0.102: v4(95.27,78.24) 93.42,76.39 93.42,66.96 v1(92.94,66.48)
  BOTTOM w0.102: R5833.1 v1(92.94,66.48)
N61773390: length 4.1
  L7-SIG w0.102: v1(44.71,16.34) 43.96,16.34 v1(42.85,15.23) v1(42.85,14.46)
  BOTTOM w0.102: v9(41.99,15.6) 42.36,15.23 v1(42.85,15.23)
N61773392: length 1.1
  L7-SIG w0.102: v1(44.55,13.37) 44.55,13.8 44.71,13.96 v1(44.71,14.44)
N61773489: length 3.9
  L7-SIG w0.084: v1(46.96,12.63) v1(46.96,13.37) 46.96,13.79 v1(47.61,14.44) 47.62,14.43 v1(47.62,13.37) 47.63,13.37 v1(47.63,12.63)
N61801494: length 4.9
  L7-SIG w0.254: v1(98.4,95.59) 97.77,94.96 v1(96.27,94.96) v1(96.27,94.29) v1(96.27,93.53)
  BOTTOM w0.102: v1(96.27,94.96) 95.63,94.96 v9(95.31,95.28)
N61858088: length 6.9
  BOTTOM w0.102: Q8101.6 42.43,50.77 42.14,51.06 ; R8130.2 41.43,48.75 41.78,49.11 Q8101.5 41.78,50.71 42.14,51.06 ; 42.14,51.06 42.14,51.52 42.47,51.85 Q8102.2
N61858102: length 3.1
  BOTTOM w0.254: R8119.1 R8118.1 42.11,48.78 41.78,48.45 Q8101.2
N61932976: length 192
  L4-SIG w0.109: v3(71.49,74.04) 71.53,74 72.1,74 74.43,71.67 74.43,69.81 74.36,69.74 74.36,68.57 75.23,67.7 75.23,64.29 76.89,62.63 76.89,61.9 76.61,61.61 76.61,57.36 76.31,57.06 76.31,54.16 77.14,53.32 78.6,53.32 79.89,52.04 79.89,37.36 82.2,35.05 83.14,35.05 83.39,34.8 83.39,32.93 82.32,31.87 82.32,20.86 79.36,17.9 78.65,17.9 78.62,17.92 78.31,17.92 77.53,17.14 77.53,15.44 77.27,15.18 76.88,15.18 76.15,15.91 74.64,15.91 71.36,12.63 64.18,12.63 63.47,13.33 49.48,13.33 48.73,12.59 46.62,12.59 40.14,19.07 38.86,19.07 36.38,21.55 33.07,21.55 32.45,22.17 32.45,28.12 33.43,29.1 33.43,37.58 33.99,38.14 33.99,38.67 27.71,44.94 27.71,47.56 29.52,49.36 29.52,51.26 28.95,51.83 28.88,51.83 v3(28.52,51.47)
  L5-SIG w0.109: v3(71.49,74.04) 70.25,74.04 68.39,72.18 v3(68.15,72.18)
  L6-GND w0.102: v1(67.62,72.76) 67.62,72.63 68.07,72.18 v3(68.15,72.18) ; v3(28.52,51.47) v1(28.52,51.85)
  L7-SIG w0.102: v1(31.62,53.98) 32.13,54.49 32.13,56.17 32.49,56.52 32.49,57.29 33.25,58.05 33.25,58.94 v1(33.05,59.14)
  BOTTOM w0.102: v1(33.05,59.14) 33.05,61.04 33.89,61.88 34.47,61.88 34.85,62.27 36.08,62.27 37.48,63.66 37.48,65.41 37.33,65.56 37.33,68.29 36.48,69.15 36.48,72.04 36.58,72.15 36.94,72.15 37.29,71.79 37.29,71.14 37.38,71.05 37.74,71.05 38.13,70.67 R2692.2 37.83,69.97 Q2650.4 ; v1(67.62,72.76) 67.26,73.11 66.93,73.11 R2685.2 ; v1(28.52,51.85) 28.52,52.21 30.3,53.98 v1(31.62,53.98)
N61933366: length 14
  L5-SIG w0.06: v6(61.13,70.72) 60.93,70.72 60.55,70.34 59.56,70.34 58.42,69.21 58.16,69.21 58.05,69.09 58.05,68.84
  L5-SIG w0.084: 58.05,68.84 58.05,68.22 58.14,68.12 58.14,67.16 57.96,66.98 57.96,66.44 58.45,65.94 58.45,62.37 v5(58.32,62.24)
  L7-SIG w0.084: v1(58.32,59.65) 57.76,60.21 57.76,61.34 58.09,61.67 58.09,62.01 v5(58.32,62.24)
N61933368: length 13.7
  L5-SIG w0.06: v6(60.18,70.98) 59.73,70.52 59.57,70.52 58.53,69.48 58.28,69.48 58.28,69.46 58.15,69.33 58.11,69.33 57.89,69.1
  L5-SIG w0.084: v5(57.89,62.21) 57.89,62.34 58.16,62.61 58.16,65.96 57.71,66.41 57.71,67.05 57.94,67.28 57.94,68.08 57.89,68.14 57.89,69.1
  L7-SIG w0.084: v1(57.86,59.57) 57.48,59.95 57.42,59.95 57.16,60.21 57.16,61.38 57.89,62.1 v5(57.89,62.21)
N61961093: length 1.2
  BOTTOM w0.254: D2701.2 78.52,71.04 R2702.2
N62053578: length 1.9
  L7-SIG w0.102: v1(41.08,59.59) 42.21,59.59 v1(42.26,59.64) 42.29,59.67 v1(42.91,59.67)
N62053849: length 6
  L7-SIG w0.102: v1(65.71,61.4) 65.32,61.01 64.49,61.01 v1(64.14,61.36) 63.68,60.91 63.68,60.59 63.75,60.51 66.14,60.51 v1(66.62,60.03)
N62125634: length 4.4
  L7-SIG w0.102: v6(46.03,65.97) 44.88,65.97 44.64,65.72 43.3,65.72 43.1,65.92 42.57,65.92 42.42,66.08 v1(41.89,66.08)
N62127208: length 1.3
  L3-GND w0.102: v3(52.76,107.56) 52.76,107.55 53.29,107.02 v8(53.29,107.02)
  L6-GND w0.102: v3(52.76,107.56) 52.89,107.43 v1(53.29,107.43)
N62213582: length 4.7
  BOTTOM w0.102: v9(4.26,70.77) 3.81,70.77 3.79,70.75 R2031.1 ; R2031.1 3.35,68.58 3.58,68.35 CON2002.17 ; R2031.1 R2030.1
N62285848: length 15.7
  L7-SIG w0.254: v1(54.46,3.05) 54.46,4.99 54.16,5.29 v1(54.16,5.92) 54.16,7.52 52.99,8.68 v1(47.98,8.68) v1(47.22,8.68) 47.22,8.68 v1(46.45,8.68) v1(45.69,8.68)
  BOTTOM w0.102: v9(43.71,8.38) 45.38,8.38 v1(45.69,8.68) L7304.2
N62321407: length 15.3
  L3-GND w0.102: v8(99.79,110.79) v3(99.52,111.06)
  L5-SIG w0.102: v3(89.97,104.99) 89.97,106.84 94.18,111.06 v3(99.52,111.06)
  L6-GND w0.102: v3(89.97,104.99) 89.9,105.06 v1(89.35,105.06)
  BOTTOM w0.102: R1127.1 v9(89.31,103.89)
N62376398: length 14.3
  L7-SIG w0.102: v1(64.16,17.41) 64.16,17.33 63.9,17.07 61.41,17.07 61.15,17.33 59.9,17.33 59.88,17.31 57.45,17.31 57.25,17.5 57.25,17.69 57.07,17.87 57.07,18.21 v1(56.84,18.45) v1(57.56,18.45) v1(57.56,19.14) v1(56.84,19.14)
  BOTTOM w0.102: R8377.2 64.01,18.2 64.02,18.2 64.02,17.55 v1(64.16,17.41)
N62471773: length 1.5
  BOTTOM w0.102: U7321.C2 78.26,8.59 R7374.2
N62471816: length 5.4
  L7-SIG w0.102: v1(79.57,4.2) 79.12,4.65 79.12,5.62 80.25,6.75 v1(80.25,7.1) 80.25,7.13 79.81,7.58 79.81,8.49 v1(80.01,8.7)
N62471852: length 4.5
  L7-SIG w0.102: v1(80.75,8.67) 80.25,8.18 v1(80.25,7.6) 80.4,7.6 80.57,7.43 80.57,6.07 v1(79.54,5.04)
N62573604: length 2
  BOTTOM w0.102: U7321.D2 78.62,7.74 v9(77.84,7.74) 77.48,7.38 SP7302.1
N62573733: length 1.7
  BOTTOM w0.102: SP7304.2 78.58,7.1 U7321.D1
N62573833: length 2.5
  L7-SIG w0.102: v1(87.14,5.04) 87.14,5.23 86.41,5.95 86.41,6.68 v1(85.99,7.1)
N62573859: length 3
  L7-SIG w0.102: v1(82.67,8.98) 82.67,8.63 82.91,8.39 82.91,7.04 82.74,6.87 82.41,6.87 v1(82.13,7.15)
N62573915: length 4
  L7-SIG w0.102: v1(81.52,4.76) 81.53,4.77 81.53,6.99 82.13,7.59 v1(82.13,7.65)
  BOTTOM w0.102: v1(81.52,4.76) v9(82.4,4.76)
N62573966: length 1.6
  L7-SIG w0.102: v1(86.45,8.98) 86.45,8.63 85.99,8.17 v1(85.99,7.6)
N62708375: length 3.1
  BOTTOM w0.254: R3061.1 80.94,75.48 Q3006.3 79.52,75.48 79.3,75.7 79.3,76.01 79.43,76.13 Q3006.2
N62774305: length 1.5
  L7-SIG w0.102: v1(34.63,15.85) 34.63,16.36 v1(34.42,16.57)
  BOTTOM w0.102: R8821.2 34.21,16.57 v1(34.42,16.57)
N62839220: length 6.7
  L7-SIG w0.254: v1(30.84,50.3) 31.57,50.3 v1(31.84,50.57) 32.05,50.78 35.28,50.78 35.28,50.79 35.58,50.79 35.58,50.78 36.29,50.78 v1(36.57,51.06) v1(36.57,51.72)
N62839234: length 0.7
  L7-SIG w0.254: v1(36.57,52.59) 36.98,52.59 37.07,52.5 v1(37.21,52.5)
N62839244: length 1.9
  L7-SIG w0.254: v1(35.55,51.9) v1(35.55,51.22) 34.75,51.22 v1(34.44,51.52)
N62900780: length 8.4
  BOTTOM w0.102: Q7187.5 63.25,16.42 62.92,16.75 62.13,16.75 61.77,16.39 R7190.2 62.21,15.43 62.21,14.74 R7185.2 62.26,13.83 62.26,13.14 62.33,13.07 64.34,13.07 64.42,13.14 R7184.1
N62901123: length 17.9
  BOTTOM w0.102: R7182.2 64.24,24.98 64.19,24.93 R7181.2 62.66,24.52 62.59,24.44 62.59,23.17 62.87,22.9 63.3,22.9 63.58,22.62 63.58,21.55 63.48,21.45 62.1,21.45 61.77,21.12 61.77,19.24 62.69,18.32 63.6,18.32 63.81,18.11 63.81,17.18 64.24,16.76 64.24,15.55 63.3,14.61 62.79,14.61 62.6,14.42 Q7187.3
N62901166: length 3.9
  BOTTOM w0.254: Q7111.2 65.58,26.15 C7125.1 R7182.1 63.97,26.15 R7183.2
N62901168: length 4.7
  BOTTOM w0.102: C7125.2 65,24.9 65.05,24.85 R7181.1 65.33,24.52 65.43,24.62 68.2,24.62 68.34,24.76 Q7111.1
N62928799: length 4
  BOTTOM w0.102: Q2001.2 42.09,5.47 42.16,5.39 42.16,4.96 42.02,4.82 Q2001.3 40.57,4.82 R2098.1
N62933876: length 9.6
  L7-SIG w0.06: v6(46.63,64.8) 46.33,64.8 45.91,64.37 45.16,64.37 45.08,64.29 44.25,64.29
  L7-SIG w0.102: 44.25,64.29 41.88,64.29 41.61,64.02 41.61,63.71 41.28,63.38 40.36,63.38 v1(40.34,63.36)
  BOTTOM w0.102: T2686.1 40.74,64.88 40.74,64.42 40.34,64.01 v1(40.34,63.36)
N63021289: length 7.3
  L4-SIG w0.102: v3(72.95,58.78) 72.75,58.97 72.75,61.85 74.01,63.11 74.01,63.64 v3(73.26,64.39)
  L6-GND w0.102: v1(73.32,58.78) v3(72.95,58.78) ; v3(73.26,64.39) 73.26,64.39 73.26,64.38 73.17,64.38 v1(72.96,64.18)
N63039426: length 3
  BOTTOM w0.254: Q3008.5 75.29,60.49 75.18,60.39 75.18,59.95 75.3,59.84 Q3008.6 76.45,59.84 76.59,59.7 R3081.1
N63040609: length 3.1
  BOTTOM w0.254: R3083.1 68.35,59.95 68.45,60.06 Q3009.5 69.65,60.06 69.83,60.23 69.83,60.51 69.63,60.71 Q3009.6
N63106901: length 2.3
  BOTTOM w0.102: R8369.1 80.87,22.95 80.82,23 C8349.1 R8379.2 79.73,23.3 79.68,23.25 R8370.2

## Copper pours and planes (outline as drawn)
3VO on BOTTOM (solid shape): 36.3,45.58 36.3,45.12 36.15,44.98 36.15,44.09 36.17,44.07 36.17,43.22 36.09,43.14 35.74,43.14 35.66,43.22 35.66,43.8 35.51,43.95 34.49,43.95 33.86,43.32 33.12,43.32 33.07,43.37 33.07,44.38 33.3,44.61 33.3,44.76 33.4,44.87 35.33,44.87 35.43,44.97 35.43,45.5 35.64,45.7 36.17,45.7
3VO_EN on BOTTOM (solid shape): 41.33,48.22 41.33,47.17 40.93,46.78 39.94,46.78 39.78,46.94 39.78,47.33 40.08,47.62 40.08,48.24 40.12,48.28 41.27,48.28
3VO_LX1 on BOTTOM (solid shape): 31.6,46.49 31.6,44.56 32.11,44.05 32.11,43.42 32,43.32 31.93,43.32 31.73,43.52 31.73,43.57 30.84,44.46 30.38,44.46 30.28,44.56 30.28,46.54 30.35,46.62 31.47,46.62
3VO_LX2 on BOTTOM (solid shape): 33.07,46.52 33.07,44.64 32.92,44.49 32.92,43.39 32.84,43.32 32.72,43.32 32.64,43.39 32.64,43.8 31.83,44.61 31.83,46.47 31.98,46.62 32.97,46.62
3VO_VIN on BOTTOM (solid shape): 35.19,40.6 35.19,39.75 35.43,39.5 35.43,38.92 35.36,38.85 34.5,38.85 34.4,38.95 34.4,40.48 34.57,40.65 35.14,40.65
3VO_VIN on BOTTOM (solid shape): 31.85,43.19 31.95,43.19 32.06,43.09 32.06,42.96 32,42.91 31.83,42.91 31.52,42.61 30.46,42.61 30.35,42.5 30.35,41.67 30.46,41.56 30.84,41.56 30.99,41.41 30.99,39.1 30.86,38.97 29.29,38.97 29.08,39.18 29.08,42.2 29.64,42.76 29.64,44.18 29.74,44.28 30.76,44.28
3VO_VIN on L7-SIG (solid shape): 33.26,41.49 33.27,41.47 33.31,41.43 33.35,41.41 33.4,41.38 33.45,41.37 33.5,41.36 33.55,41.36 33.61,41.37 33.66,41.38 33.7,41.41 33.75,41.43 33.79,41.47 33.8,41.49 34.86,41.49 35.1,41.25 35.1,40.81 35.23,40.68 35.23,40.07 35.05,39.89 34.44,39.89 34.21,40.12 34.21,40.4 33.99,40.62 32.69,40.62 32.49,40.42 31.72,40.42 31.6,40.3 30.58,40.3 30.37,40.51 30.37,41.1 34.39,41.1 34.39,41.06 34.4,41.02 34.42,40.98 34.44,40.94 34.47,40.91 34.5,40.89 34.54,40.87 34.58,40.86 34.62,40.85 34.66,40.86 34.7,40.87 34.74,40.89 34.78,40.91 34.8,40.94 34.83,40.98 34.84,41.02 34.85,41.06 34.85,41.1 34.84,41.14 34.83,41.18 34.8,41.22 34.78,41.25 34.74,41.28 34.7,41.3 34.66,41.31 34.62,41.31 34.58,41.31 34.54,41.3 34.5,41.28 34.47,41.25 34.44,41.22 34.42,41.18 34.4,41.14 34.39,41.1 30.37,41.1 30.37,41.4 30.63,41.66 33.08,41.66
5V_USB_PAD on TOP (solid shape): 94.62,55.92 95.68,55.92 95.67,55.07 95.53,54.92 94.18,54.92 93.96,55.15 93.96,56.02 94.06,56.12 94.41,56.12
5V_USB_PAD on BOTTOM (solid shape): 88.04,56.42 88.04,56.09 88.24,55.89 90.32,55.89 90.65,56.22 94.64,56.22 94.9,55.97 94.9,53.93 94.54,53.58 91.09,53.58 89.82,52.31 85.92,52.31 85.74,52.13 85.15,52.13 85.02,52.27 85.02,52.81 85.2,52.99 85.79,52.99 86.01,53.21 86.01,55.84 86.77,56.6 87.86,56.6
+5VO on BOTTOM (solid shape): 79.02,48.45 79.02,47.66 79.2,47.48 81.18,47.48 81.46,47.2 81.46,44.43 80.87,43.85 79.17,43.85 79.1,43.93 79.1,44.28 78.77,44.61 77.72,44.61 77.67,44.66 77.67,45.42 77.17,45.93 77.17,46.52 76.81,46.87 74.91,46.87 74.83,46.95 74.83,47.25 75.08,47.51 75.08,49.64 77.83,49.64
+V1P0A on BOTTOM (solid shape): 56.36,63.15 56.4,63.12 56.4,63.04 56.93,62.51 56.93,59.37 56.96,59.34 56.96,59.13 56.73,59.13 56.73,59.2 56.3,59.2 56.16,59.34 56.16,61.94 56.07,62.03 56.07,63.05 56.09,63.07 56.16,63.11 56.2,63.17 56.22,63.2 56.31,63.2
+V1P0A on BOTTOM (solid shape): 77.07,28.95 77.06,28.94 77.06,28.33 77.32,28.08 77.9,28.08 78,28.18 78,28.58 78.16,28.74 78.66,28.74 78.69,28.71 78.69,25.21 78.49,25 76.35,25 76.12,25.23 76.12,27.19 75.74,27.57 74.68,27.57 74.04,28.2 74.04,28.84 74.14,28.94 75.31,28.94 75.54,29.17 76.85,29.17
+V1P0A on BOTTOM (solid shape): 57.9,68.16 57.9,66.9 57.84,66.84 57.57,66.84 57.56,66.88 57.53,66.94 57.48,67 57.48,67.01 57.49,67.05 57.5,67.06 57.57,67.45 57.24,67.67 57.17,67.69 57.15,67.75 57.15,67.8 57.14,67.86 57.15,67.91 57.15,68.02 57.18,68.05 57.21,68.05 57.37,68.07 57.54,68.17 57.63,68.26 57.8,68.26
+V1P0A on L2-SIG (solid shape): 49.88,35.26 49.88,32.93 49.53,32.59 48.22,32.59 47.3,33.51 47.3,35.65 47.49,35.84 49.29,35.84
+V1P0A on L2-SIG (solid shape): 47.08,55.6 47.08,50.89 46.9,50.71 45.83,50.71 45.42,51.12 45.42,52.2 44.56,53.06 44.56,55.57 44.73,55.74 46.93,55.74
+V1P0A on L2-SIG (solid shape): 75.85,29.47 78,29.47 78.46,29.02 78.46,26.96 78.13,26.63 75.01,26.63 74.27,27.37 74.27,29.35 74.42,29.5 75.82,29.5
+V1P0A on L4-SIG (solid shape): 79.5,28.53 79.5,27.95 78.72,27.17 77.08,27.17 76.78,27.47 76.78,28.56 77.23,29.01 79.03,29.01
+V1P0A on L6-GND (solid shape): 50.67,33.13 50.67,32.95 50.55,32.83 49.4,32.83 49.15,32.57 48.92,32.57 48.82,32.67 48.82,33.08 48.97,33.23 50.57,33.23
+V1P0A on L6-GND (solid shape): 54.56,33.44 54.99,33.44 55.12,33.31 55.22,33.31 55.32,33.21 55.32,33.14 55.22,33.04 54.76,33.04 54.34,33.11 54.2,32.7 53.72,32.7 53.49,32.93 53.49,33.36 53.83,33.36 54.08,33.61 54.38,33.61
+V1P0A on L7-SIG (solid shape): 47.22,56.5 47.22,55.36 46.99,55.13 44.9,55.13 44.68,55.34 44.68,55.73 45.35,56.4 45.97,56.4 46.17,56.6 47.12,56.6
+V1P0A on L7-SIG (solid shape): 56.54,60.36 56.54,60.08 56.83,59.79 56.83,59.34 56.97,59.2 56.97,58.63 57.43,58.18 57.43,57.95 57.18,57.7 57.18,57.25 55.92,55.99 55.65,55.99 55.5,56.14 55.5,57.52 56.34,58.35 56.34,59.73 56.21,59.85 56.21,60.4 56.3,60.49 56.41,60.49
+V1P0A_PMIC on BOTTOM (solid shape): 68.45,32.5 68.45,31.79 68.68,31.56 71.68,31.56 73.1,31.56 73.38,31.28 73.38,28.18 73.33,28.13 72.97,28.13 72.8,28.31 72.8,29.75 72.59,29.96 67.97,29.96 67.44,30.49 67.44,32.52 67.62,32.7 68.25,32.7
+V1P0S on BOTTOM (solid shape): 74.19,24.6 74.19,23.86 74.14,23.81 73.13,23.81 72.85,24.09 72.37,24.09 72.19,24.27 72.19,24.5 72.47,24.77 74.02,24.77
+V1P0S on BOTTOM (solid shape): 44.96,53.12 44.96,47.74 44.91,47.69 44.4,47.69 44.35,47.74 44.35,50.43 44.48,50.56 44.48,52.81 44.35,52.94 44.35,53.15 44.48,53.28 44.8,53.28
+V1P0S on BOTTOM (solid shape): 38.6,73.57 39.45,73.57 39.55,73.47 39.55,73.06 39.65,72.96 39.65,72.48 39.4,72.22 38.25,72.22 37.8,72.68 37.8,73.59 37.87,73.67 38.6,73.67
+V1P0S on BOTTOM (solid shape): 55.9,63 55.9,62.02 56.03,61.88 56.03,60.8 55.98,60.75 55.49,60.75 55.4,60.84 55.4,61.45 55.1,61.75 55.1,62.73 55.15,62.73 55.33,62.82 55.42,63.01 55.42,63.03 55.49,63.1 55.5,63.1 55.57,63.14 55.63,63.19 55.73,63.19
+V1P0S on BOTTOM (solid shape): 57.73,63.52 57.83,63.43 57.96,63.4 57.99,63.36 57.99,63.32 58.04,63.17 58.17,63.07 58.19,63.07 58.22,63.02 58.23,63 58.26,62.88 58.35,62.78 58.38,62.76 58.42,62.75 59.31,61.86 59.31,60.03 59.23,59.95 58.6,59.95 58.57,59.98 58.57,60.69 58.57,61.56 57.7,62.43 57.7,63.17 57.61,63.25 57.56,63.29 57.52,63.34 57.52,63.45 57.61,63.55 57.71,63.55
+V1P0S on BOTTOM (solid shape): 52.68,63.52 52.74,63.44 52.84,63.39 52.86,63.39 52.9,63.34 52.9,63.32 52.95,63.16 53.12,63.05 53.13,63.02 53.16,62.9 53.23,62.8 53.23,62.5 53.2,62.48 52.56,62.48 52.09,62.01 52.09,62.01 51.56,61.48 51.03,61.48 50.9,61.35 50.9,60.23 50.72,60.06 50.42,60.06 50.29,60.18 50.29,61.4 50.37,61.48 50.62,61.48 51.66,62.52 51.66,62.52 51.97,62.83 52.07,62.83 52.08,62.82 52.53,62.85 52.43,63.28 52.4,63.3 52.4,63.43 52.44,63.47 52.48,63.52 52.49,63.55 52.66,63.55
+V1P0S on L2-SIG (solid shape): 74.12,25 74.12,23.33 73.56,22.77 72.09,22.77 71.4,23.45 71.4,24.7 72.26,25.56 73.56,25.56
+V1P0S on L2-SIG (solid shape): 38.41,74.89 38.41,73.44 38.3,73.34 37.21,73.34 37.08,73.47 37.08,74.03 37.34,74.28 37.34,74.57 37.68,74.91 38.38,74.91
+V1P0S on L3-GND (solid shape): 39.68,74.86 39.68,74.2 39.5,74.03 37.75,74.03 37.52,74.25 37.52,74.91 37.69,75.09 39.45,75.09
+V1P0S on L6-GND (solid shape): 39.75,74.53 39.75,72.6 39.55,72.4 38.86,72.4 38.46,72.81 38.46,74.51 38.98,75.04 39.25,75.04
+V1P0S_PCIE_SATA on BOTTOM (solid shape): 50.38,63.54 50.42,63.47 50.48,63.41 50.48,63.32 50.45,63.31 50.3,63.15 50.29,62.92 50.3,62.9 50.28,62.86 50.23,62.81 50.2,62.76 49.4,61.96 48.9,61.96 48.36,61.43 47.89,61.43 47.89,59.88 46.58,59.88 46.46,60 46.46,60.49 46.53,60.56 47.13,60.56 47.18,60.61 47.18,61.98 47.32,62.11 47.81,62.11 48.31,62.62 48.31,62.71 48.36,62.76 48.37,62.76 48.5,62.81 48.58,62.92 48.59,62.95 48.64,62.95 48.65,63 48.65,63.04 48.82,63.13 48.88,63.31 48.9,63.37 48.96,63.4 49.04,63.44 49.1,63.49 49.18,63.53 49.26,63.49 49.29,63.46 49.35,63.46 49.39,63.43 49.42,63.34 49.36,63.27 49.31,62.81 49.73,63 49.73,63.01 49.76,63.04 49.94,63.12 50.01,63.31 50.15,63.37 50.23,63.5 50.26,63.57 50.37,63.57
+V1P0S_PMIC on BOTTOM (solid shape): 75.69,27.29 75.69,25.99 74.88,25.18 73.76,25.18 73.71,25.23 73.71,25.79 73.99,26.07 74.02,26.07 74.19,26.25 74.19,27.37 74.27,27.44 75.54,27.44
+V1P0SX on BOTTOM (solid shape): 81.71,27.42 81.71,25.89 81.53,25.71 80.8,25.71 80.49,26.02 80.49,27.42 80.65,27.57 81.56,27.57
+V1P0SX on BOTTOM (solid shape): 40.55,73.57 41.21,73.57 41.27,73.51 41.27,71.36 41.16,71.26 40.44,71.26 40.31,71.38 40.31,72.54 39.77,73.07 39.77,73.69 39.8,73.7 40.42,73.7
+V1P0SX on BOTTOM (solid shape): 45.32,70.71 45.4,70.7 45.44,70.69 45.51,70.53 45.68,70.47 45.73,70.47 45.79,70.32 45.92,70.24 45.95,70.23 45.95,70.12 45.92,70.11 45.86,70.08 45.81,70.04 45.76,70.02 45.71,70.03 45.42,70.21 45.14,70.02 45.12,69.99 44.22,69.99 43.85,69.63 43.28,69.63 43.24,69.68 43.24,70.14 43.28,70.18 43.8,70.18 43.81,70.18 44.36,70.73 45.27,70.73
+V1P0SX on BOTTOM (solid shape): 51.45,63.51 51.51,63.47 51.55,63.43 51.6,63.39 51.63,63.38 51.63,63.3 51.6,63.29 51.44,63.06 51.53,62.8 51.53,62.57 50.57,61.61 50.32,61.61 50.16,61.45 50.03,61.45 50,61.43 49.42,61.43 49.42,59.42 49.23,59.24 48.85,59.24 48.77,59.32 48.77,61.6 49,61.83 49.45,61.83 50.39,62.77 50.52,62.77 50.6,62.76 50.68,62.77 50.78,62.83 50.85,62.94 50.85,62.95 50.99,63.09 51,63.1 51.09,63.19 51.12,63.32 51.12,63.34 51.16,63.39 51.18,63.39 51.3,63.42 51.38,63.5
+V1P0SX on BOTTOM (solid shape): 61.13,66.93 61.42,66.74 61.71,66.93 61.73,66.96 62.08,66.96 62.81,66.23 62.81,65.01 63.04,64.78 63.6,64.78 63.6,62.69 63.48,62.57 62.64,62.57 62,63.21 62,64.6 61.55,65.05 61.42,65.05 61.4,65.13 61.31,65.28 61.15,65.35 61.13,65.35 61.08,65.38 61.08,65.4 61.02,65.5 60.93,65.57 60.9,65.58 60.9,65.71 60.93,65.72 60.97,65.74 61,65.77 61.08,65.8 61.16,65.75 61.64,65.7 61.62,66.18 61.52,66.25 61.4,66.26 61.31,66.42 61.14,66.48 61.08,66.5 61.04,66.56 61.01,66.63 60.96,66.7 60.92,66.77 60.96,66.85 60.99,66.89 61.02,66.93 61.03,66.96 61.12,66.96
+V1P0SX on L2-SIG (solid shape): 74.96,53.86 74.96,51.98 74.88,51.9 73.69,51.9 73.46,52.13 73.46,54.01 73.91,54.47 74.35,54.47
+V1P0SX on L2-SIG (solid shape): 81.74,29.65 81.74,26.88 81.2,26.34 79.64,26.34 79.07,26.91 79.07,30.13 79.45,30.52 80.87,30.52
+V1P0SX on L2-SIG (solid shape): 67.71,63.81 67.71,62.82 67.62,62.72 62.89,62.72 61.98,63.64 61.98,64.02 62.15,64.2 67.33,64.2
+V1P0SX on L4-SIG (solid shape): 81.93,27.89 81.93,26.83 81.36,26.26 80.68,26.26 80.31,26.63 80.31,27.68 80.66,28.03 81.79,28.03
+V1P0SX on L5-SIG (solid shape): 51.68,66.81 51.68,66.31 51.25,65.87 51.05,65.87 50.64,66.29 50.64,66.57 50.95,66.89 51.61,66.89
+V1P0SX on L7-SIG (solid shape): outline of 119 points within 50.85,66.37 52.11,68.2
+V1P0SX_PMIC on BOTTOM (solid shape): 79.5,26.37 80.15,26.37 80.21,26.31 80.21,25.23 80.11,25.13 79.62,25.13 79.34,24.85 79.07,24.85 78.99,24.93 78.99,26.38 79.02,26.4 79.48,26.4
+V1P0SX_S on BOTTOM (solid shape): 62.82,74.25 62.82,73.44 62.94,73.32 62.94,73.19 63.02,73.11 63.55,73.11 63.65,73.01 63.65,72.55 63.81,72.4 64.34,72.4 64.39,72.35 64.39,71.94 64.31,71.87 63.15,71.87 63.09,71.92 63.09,72.12 62.26,72.95 61.81,72.95 61.74,73.02 61.74,73.43 61.57,73.6 61.28,73.6 61.13,73.45 61.07,73.42 61,73.45 60.95,73.48 60.9,73.5 60.89,73.56 60.91,73.61 60.93,73.63 61,73.69 61.04,73.7 61.07,73.71 61.12,73.78 61.15,73.87 61.18,73.87 61.4,74.08 61.29,74.36 61.25,74.38 61.46,74.6 62.47,74.6
+V1P0SX_S on BOTTOM (solid shape): 41.59,75.03 41.59,74.87 41.75,74.87 41.76,74.86 45.06,74.86 45.34,74.59 45.6,74.44 45.6,74.38 45.5,74.3 45.46,74.25 45.42,74.06 45.53,73.91 45.59,73.88 45.65,73.86 45.67,73.86 45.7,73.82 45.71,73.81 45.74,73.76 45.91,73.58 45.91,73.51 45.89,73.5 45.85,73.47 45.81,73.43 45.74,73.43 45.61,73.6 45.02,73.6 44.6,74.03 42.42,74.03 42.2,73.8 42.1,73.8 41.84,73.89 41.58,73.8 41.53,73.8 41.42,73.7 40.6,73.7 40.58,73.72 40.58,73.82 39.67,73.82 39.55,73.82 39.42,73.7 38.72,73.7 38.72,73.82 37.9,73.82 37.82,73.9 37.82,74.76 37.95,74.89 39.98,74.89 40.33,75.25 41.37,75.25
+V1P2A on BOTTOM (solid shape): 57.47,63.15 57.51,63.12 57.53,63.1 57.53,62.42 58.45,61.5 58.45,60.82 58.4,60.77 57.86,60.77 57.79,60.84 57.79,61.38 57.08,62.08 57.08,62.89 57.1,62.94 57.11,63 57.11,63.02 57.15,63.07 57.17,63.07 57.25,63.12 57.32,63.19 57.43,63.19
+V1P2A_PMIC on L7-SIG (solid shape): 45.07,42.7 45.07,41.21 44.93,41.07 44.48,41.07 44.31,41.24 44.31,42.55 44.23,42.64 44.23,42.72 44.3,42.79 44.98,42.79
