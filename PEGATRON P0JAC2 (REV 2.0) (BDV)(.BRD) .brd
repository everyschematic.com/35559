# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BKLT_PWM_PMIC: length 76.9
  L4-SIG w0.109: v3(59.39,14.82) 59.16,15.05 58.08,15.05 56.06,17.06 45.85,17.06 42.17,20.75 39.5,20.75 38.26,21.99 38.26,33.18 37.88,33.56 37.88,36.5 38.21,36.83 38.21,37.53 37.26,38.48 36.79,38.48 36.28,38.99 36.28,39.57 v3(34.35,41.5)
  L5-SIG w0.06: v6(57.91,35.74) 57.91,35.88 57.72,36.06 57.72,36.25 57.61,36.37 56.96,36.37 56.51,36.82 56.51,37.51 55.8,38.21 55.8,38.59
  L5-SIG w0.109: 55.8,38.59 55.8,40.05 50.91,44.95 48.58,44.95 45.68,42.05 34.9,42.05 v3(34.35,41.5)
  L6-GND w0.102: v3(59.39,14.82) 59.72,14.82 v1(59.99,14.55)
BOARD_ID_0: length 16.8
  L5-SIG w0.06: v6(59.13,34.54) 59.01,34.41 59.01,34.37 58.92,34.28 58.92,34.09 58.8,33.97 58.6,33.97 58.52,33.89 58.52,33.16 58.65,33.03 58.65,31.23
  L5-SIG w0.102: 58.65,31.23 58.65,30.49 58.42,30.26 58.42,20.1 v3(58.9,19.62)
  L6-GND w0.102: v3(58.9,19.62) 59.05,19.47 v1(59.05,19.14)
  L7-SIG w0.102: v1(59.05,18.48) 59.05,19.13 v1(59.05,19.14)
BOARD_ID_1: length 18.2
  L5-SIG w0.06: v6(59.13,34.14) 59.13,34.05 58.92,33.84 58.92,33.24 59.11,33.06 59.11,31.23
  L5-SIG w0.102: 59.11,31.23 59.11,31.02 59.56,30.57 59.56,30.03 59.11,29.58 59.11,25.82 58.64,25.35 58.64,20.47 59.39,19.72 59.39,19.66 59.81,19.24 60.25,19.24 v3(60.61,19.59)
  L6-GND w0.102: v1(60.55,19.14) 60.55,19.38 60.61,19.44 v3(60.61,19.59)
  L7-SIG w0.102: v1(60.55,18.48) v1(60.55,19.14)
BOARD_ID_2: length 16.4
  L5-SIG w0.06: v6(59.13,33.74) 59.13,33.36 59.41,33.08 59.41,31.23
  L5-SIG w0.102: v3(59.97,19.62) 58.88,20.71 58.88,25.18 59.39,25.69 59.39,29.57 59.77,29.95 59.77,30.87 59.41,31.23
  L6-GND w0.102: v3(59.97,19.62) 59.82,19.47 v1(59.82,19.14)
  L7-SIG w0.102: v1(59.82,19.14) 59.79,19.11 v1(59.79,18.48)
BOARD_ID_3: length 28.6
  L4-SIG w0.102: v3(42.29,37.17) 42.29,39.07 42.14,39.23 42.14,42.97 42.36,43.19 42.5,43.19 42.75,43.44 42.75,44.49 43.12,44.87 v3(43.66,44.87)
  L5-SIG w0.06: v6(57.92,34.95) 57.73,35.14 57.45,35.14 57.32,35.27 57.32,35.42 57.21,35.54 56.9,35.54 55.97,36.47 55.53,36.47 55.51,36.48 55.09,36.48
  L5-SIG w0.102: 55.09,36.48 46.66,36.48 45.92,37.22 42.34,37.22 v3(42.29,37.17)
  L6-GND w0.102: v4(43.74,45.3) 43.74,44.94 v3(43.66,44.87)
  L7-SIG w0.102: v4(43.74,45.3) 44.39,45.95 44.39,46.25 44.78,46.63 v1(44.78,46.85) 45.31,46.85 v1(45.45,46.99)
BOARD_ID_4: length 21
  L5-SIG w0.06: v6(58.27,34.94) 58.08,34.74 57.75,34.74 57.72,34.71 56.82,34.71 56.64,34.88
  L5-SIG w0.102: 56.64,34.88 55.93,35.6 55.06,35.6 53.97,34.5 51.77,34.5 50.28,36 50.14,36 50.13,36.01 46.4,36.01 45.64,36.77 43.52,36.77 v3(42.19,35.44)
  L6-GND w0.102: v1(42.13,34.91) 42.13,35.39 v3(42.19,35.44)
  BOTTOM w0.102: v1(42.13,34.91) 41.74,34.91 41.55,34.72 v9(41.22,34.72) 41.22,35.12 41.4,35.3 R0512.2
BOARD_ID_5: length 26
  L2-SIG w0.102: v8(43.71,34.38) 43.71,41.36 45.16,42.81 v8(45.16,43.8)
  L3-GND w0.102: v3(45.16,44.15) v8(45.16,43.8) ; v3(43.71,34.02) v8(43.71,34.38)
  L5-SIG w0.102: v6(57.52,33.74) 57.26,33.48 44.26,33.48 v3(43.71,34.02)
  L6-GND w0.102: v1(45.54,44.16) 45.16,44.16 v3(45.16,44.15)
  BOTTOM w0.102: R0505.1 v1(45.54,44.16)
BPTHERM_0: length 111.4
  L2-SIG w0.102: v8(81.72,25.32) 81.72,15.38 71.32,4.99 55.25,4.99 v8(53.39,6.84)
  L3-GND w0.102: v3(53.39,7.2) v8(53.39,6.84) ; v3(81.46,25.56) 81.7,25.32 v8(81.72,25.32)
  L6-GND w0.06: 62.33,33.09 62.26,33.17 61.71,33.17 60.91,33.96 60.91,34.15 60.73,34.33 60.53,34.33 v6(60.32,34.54)
  L6-GND w0.102: v4(68.94,31.3) 68.5,31.3 67.44,32.37 67.42,32.37 67.42,32.37 63.64,32.37 63.39,32.61 62.81,32.61 62.33,33.09 ; v3(81.46,25.56) 81.55,25.65 v4(81.8,25.65) ; v3(53.39,7.2) 53.39,7.2 53.39,7.55 v4(53.39,7.55)
  L7-SIG w0.102: v4(53.39,7.55) 52.7,8.24 44.18,8.24 40.42,11.99 38.17,11.99 37.31,12.84 37.31,13.29 38.33,14.3 38.33,15.06 39.62,16.36 39.62,23 40.37,23.74 v1(40.37,27.79) ; v4(68.94,31.3) 69.03,31.21 71.59,31.21 72.96,29.83 74.13,29.83 75.67,31.38 v1(76.07,31.38) 76.38,31.38 76.95,30.81 78.59,30.81 81.8,27.59 v4(81.8,25.65)
  BOTTOM w0.102: v9(40.33,31.38) 40.66,31.05 40.66,29.37 41.18,28.86 41.18,28.4 40.57,27.79 v1(40.37,27.79)
BPTHERM_1: length 25.4
  L5-SIG w0.06: 62.33,31.3 61.92,31.3 60.41,32.8 60.41,34.05 59.97,34.5 v6(59.92,34.5)
  L5-SIG w0.102: 62.33,31.3 68.83,31.3 70.54,33 73.58,33 73.89,32.7 73.89,31.81 74.53,31.17 76.91,31.17 v3(77.15,31.41)
  L6-GND w0.102: v1(77.56,31.41) v3(77.15,31.41)
  BOTTOM w0.102: v9(76.94,29.61) 76.25,29.61 R8372.1 76.44,30.13 77.27,30.13 77.56,30.42 v1(77.56,31.41)
BRTC_EXTPAD: length 6.6
  L7-SIG w0.06: v6(64.86,63.08) 64.85,63.07 v6(64.85,62.19) ; 61.84,65.24 61.62,65.47 61.08,65.47 61.02,65.53 60.71,65.53 60.54,65.36 v6(60.22,65.36)
  L7-SIG w0.084: v6(64.86,63.08) 64.63,63.31 63.78,63.31 61.84,65.24
BT_DEV_EN: length 120.9
  L4-SIG w0.109: v3(60.28,58.06) 60.24,58.06 58.86,56.68 43.1,56.68 39.12,60.66 36.27,60.66 35.3,61.64 35.3,62.55 35.37,62.62 35.37,63.38 32.73,66.01 31.96,66.01 31.77,66.21 29.37,66.21 28.07,67.51 28.07,69.1 25.62,71.55 22.33,71.55 22.06,71.29 19.94,71.29 v3(19.51,71.72)
  L6-GND w0.102: v4(19.51,72.08) v3(19.51,71.72) ; v3(60.28,58.06) v4(60.28,57.71)
  L7-SIG w0.084: v4(60.28,57.71) 60.28,57.06 61.28,56.06 70.28,56.06 70.69,55.65 79.96,55.65 80.93,56.62 80.92,56.63 80.94,56.64 80.94,58.27 80.76,58.45 80.76,59.39 82.45,61.08 82.76,61.08 84.68,63 85.43,63 86.68,64.26 v1(88.34,64.26) v1(89.38,64.26) ; v1(2.77,84.69) 1.19,83.11 1.19,72.2 2.34,71.05 v1(13.11,71.05) 13.78,71.05 15.13,72.39 19.2,72.39 v4(19.51,72.08)
  BOTTOM w0.31: T5404.1 14.22,69.94 v1(13.11,71.05)
BT_DEV_EN_D: length 76.4
  L4-SIG w0.109: v3(34.98,62.78) 35.08,62.68 35.08,61.55 36.18,60.45 39.03,60.45 43.01,56.47 59.79,56.47 v3(61.39,58.08)
  L5-SIG w0.06: v6(47.45,66.76) 47.17,66.48 46.69,66.48 46.51,66.3 46.51,66.1 46.05,65.64 46.05,65.52
  L5-SIG w0.109: v3(34.98,62.78) 35.66,63.46 43.99,63.46 46.05,65.52
  L6-GND w0.102: v3(61.39,58.08) 61.23,57.92 v4(61.23,57.63)
  L7-SIG w0.084: v4(61.23,57.63) 61.23,56.75 61.53,56.45 70.41,56.45 70.84,56.02 79.8,56.02 80.57,56.8 80.57,58.12 80.39,58.29 80.39,59.55 82.3,61.45 82.61,61.45 84.53,63.37 85.07,63.37 v1(85.96,64.26)
BT_DEV_WAKE: length 10.5
  L3-GND w0.102: v3(20.7,77) v8(21.06,77)
  L6-GND w0.102: v4(20.7,77.35) v3(20.7,77)
  L7-SIG w0.102: v1(24.21,74.03) 24.21,74.38 21.24,77.35 v4(20.7,77.35) 20.34,77.35 18.82,78.88 v1(17.58,78.88)
  BOTTOM w0.102: v1(24.21,74.03) 24.21,73.78 24.21,73.78 Q2655.3
BT_DEV_WAKE_1: length 2.1
  BOTTOM w0.31: U5401.24 15.47,80.29 15.71,80.05 15.71,79.9 16.61,79 R5417.2
BT_DEV_WAKE_R: length 33
  L5-SIG w0.06: v6(47.73,67.06) 47.51,67.27 47.11,67.27 47,67.16 46.75,67.16 46.34,66.75 46.34,66.1 45.37,65.12
  L5-SIG w0.102: 45.37,65.12 43.93,63.69 35.85,63.69 27.36,72.18 27.36,72.18 26.77,72.77 25.2,72.77 v3(24.43,73.54)
  L6-GND w0.102: v3(24.43,73.54) v4(24.43,73.16)
  L7-SIG w0.102: v1(23.81,72.02) 24.43,72.64 v4(24.43,73.16)
  BOTTOM w0.102: v1(23.81,72.02) 23.81,72.54 v9(22.84,73.52)
BT_HOST_WAKE#: length 50
  L4-SIG w0.109: v3(66.93,66.96) 66.16,67.74 66.16,70.35 67.2,71.39 v3(67.2,71.73) ; v3(78.3,75.26) 78.58,75.26 78.99,74.84 83.9,74.84 v3(84.87,73.87)
  L5-SIG w0.06: v6(59.13,69.28) 59.33,69.28 60.12,68.49 60.5,68.49 60.8,68.19 61.39,68.19 62.02,67.56 62.34,67.56 62.41,67.62 62.85,67.62
  L5-SIG w0.107: 62.85,67.62 63.02,67.62 64.16,66.49 64.9,66.49
  L5-SIG w0.109: 64.9,66.49 66.17,66.49 66.65,66.96 v3(66.93,66.96) ; v3(67.2,71.73) 69.02,71.73 70.94,73.64 72.28,73.64 73.16,74.52 73.16,76.93 74.17,77.94 74.17,77.94 74.17,78.29 74.44,78.56 74.95,78.56 v3(75.11,78.41)
  L6-GND w0.102: v3(75.11,78.41) 75.12,78.41 v4(75.89,78.41) ; v3(78.3,75.26) 78.16,75.12 v4(77.93,75.12) ; v3(84.87,73.87) 84.87,73.53 84.86,73.52 v4(84.86,73.51) ; v3(67.2,71.73) 67.2,71.71 67.1,71.6 v1(67.1,71.16)
  L7-SIG w0.084: v1(85.96,65.56) 85.96,66.48 84.86,67.57 v4(84.86,73.51) ; v4(75.89,78.41) 75.89,78 75.87,77.98 75.87,77.7 77.39,76.18 v1(77.39,74.66) 77.85,75.12 v4(77.93,75.12)
BT_HOST_WAKE_1: length 119.6
  L4-SIG w0.109: v3(20.14,71.69) 20.33,71.5 21.97,71.5 22.24,71.76 25.7,71.76 28.3,69.17 28.3,67.58 29.45,66.42 31.88,66.42 32.08,66.22 32.85,66.22 35.58,63.49 35.58,62.54 35.51,62.47 35.51,61.72 36.2,61.03 39.08,61.03 42.84,57.28 59.12,57.28 59.85,58 59.85,58.18 60.12,58.45 60.44,58.45 60.78,58.11 v3(60.84,58.11)
  L6-GND w0.102: v3(60.84,58.11) 60.84,57.89 v4(60.66,57.72) ; v3(20.14,71.69) v4(20.14,72.04)
  L7-SIG w0.084: v4(60.66,57.72) 60.66,57.06 61.46,56.27 70.34,56.27 70.77,55.84 79.87,55.84 80.75,56.72 80.75,58.19 80.58,58.37 80.58,59.47 82.37,61.27 82.69,61.27 84.61,63.19 85.35,63.19 87.07,64.91 v1(88.34,64.91) ; v4(20.14,72.04) 19.61,72.58 15.06,72.58 13.81,71.33 v1(12.81,71.33) 12.71,71.23 2.41,71.23 1.37,72.27 1.37,82.2 2.14,82.97 v1(2.71,82.97)
  BOTTOM w0.31: v1(12.81,71.33) 12.17,71.33 T5402.1
BT_HOST_WAKE_2: length 3.5
  L7-SIG w0.084: v1(4,80.29) 3.75,80.29 3.52,80.52 3.52,81.66 3.07,82.1 v1(2.71,82.1) v1(1.87,82.1)
C0_VDDI: length 5.1
  L7-SIG w0.102: v1(33.22,87.73) 33.22,85.38 34.39,84.21 v1(34.39,83.15)
CAM_2M_PD: length 146.6
  L2-SIG w0.102: v2(82.17,104.81) 82.17,94.22 v2(81.74,93.79)
  L7-SIG w0.06: 62.85,72.16 62.37,72.16 61.87,72.66 60.32,72.66 60.3,72.67 59.72,72.67 v6(59.62,72.77)
  L7-SIG w0.102: v1(6.55,119.37) 6.55,113.24 11.53,108.26 14.73,108.26 v1(14.99,108.52) 15.37,108.52 18.56,105.32 25.79,105.32 27.36,106.9 64.64,106.9 64.75,107.01 65.7,107.96 78.54,107.96 81.69,104.81 v2(82.17,104.81) ; v2(81.74,93.79) 81.74,94.81 80.56,95.98 79.35,95.98 78.71,95.34 75.03,95.34 71.95,92.25 71.95,89.91 73.79,88.07 73.79,86.58 74.01,86.36 74.01,84.5 72.98,83.47 72.98,78.83 72.89,78.74 72.89,76.19 73.32,75.77 73.32,75.36 72.7,74.75 72.36,74.75 72.07,74.45 72.07,74.03 71.54,73.51 71.54,73.32 71,72.78 69.8,72.78 69.26,72.25 67.69,72.25 67.43,71.99 66.92,71.99 66.75,72.16 66.75,72.27 66.52,72.5 66.28,72.5 66.18,72.6 65.37,72.6 65.09,72.33 65.09,72.12 64.9,71.93 64.71,71.93 64.47,72.16 62.85,72.16
CAM_2M_RESET#: length 111.4
  L4-SIG w0.109: v3(75.63,95.32) 75.63,97.05 65.08,107.6 59.13,107.6 v3(58.78,107.96)
  L5-SIG w0.109: v3(75.63,95.32) 75.63,92.96 73.33,90.66 73.33,86.42 73.33,86.42 v3(73.33,81.09)
  L6-GND w0.102: v4(58.42,107.96) v3(58.78,107.96) ; v4(73.5,80.73) 73.33,80.9 v3(73.33,81.09)
  L7-SIG w0.06: v6(58.79,73) 58.86,72.93 59.13,72.93 59.51,72.55 60.25,72.55 60.27,72.54 61.76,72.54 62.33,71.97 62.85,71.97
  L7-SIG w0.084: v4(73.5,80.73) 73.34,80.57 73.33,80.57 73.17,80.41 73.17,78.75 73.09,78.66 73.09,76.38 73.56,75.9 73.56,75.27 72.78,74.5 72.51,74.5 72.26,74.25 72.26,73.95 71.74,73.43 71.74,73.24 71.07,72.58 69.87,72.58 69.33,72.04 67.76,72.04 67.51,71.8 66.45,71.8 65.84,72.4 65.45,72.4 65.29,72.25 65.29,72.04 64.98,71.74 64.49,71.74 64.26,71.97 62.85,71.97 ; v1(12.11,109.31) 12.28,109.13 13.25,109.13 13.58,108.8 15.47,108.8 18.75,105.52 25.7,105.52 27.28,107.09 57.12,107.09 57.99,107.96 v4(58.42,107.96)
CAM_2M_RESET#_R: length 15.3
  L5-SIG w0.109: v3(7.45,121.89) 7.16,121.6 7.16,119.77 7.6,119.34 7.6,114.12 10.38,111.34 v3(10.9,111.34)
  L6-GND w0.102: v1(11.35,111.34) v3(10.9,111.34) ; v1(7.45,122.25) v3(7.45,121.89)
  L7-SIG w0.084: v1(11.35,110.17) v1(11.35,111.34)
  BOTTOM w0.31: R2103.2 v1(11.35,110.17)
CAM_ON_SOC: length 14.9
  L7-SIG w0.06: v6(60.24,73.22) 60.33,73.31 60.97,73.31 61.15,73.12 62.01,73.12 62.05,73.16 64.06,73.16
  L7-SIG w0.102: 64.06,73.16 64.89,73.99 70.78,73.99 70.92,73.85 71.32,73.85 71.68,74.2 71.68,74.74 72.34,75.4 v1(72.57,75.4)
  BOTTOM w0.102: T2542.1 72.57,74.78 v1(72.57,75.4)
CAP_WAKE: length 85.3
  L2-SIG w0.102: v2(20.25,51.87) 20.25,7.07 v2(21.03,6.28)
  L7-SIG w0.06: v6(46.62,66.48) 46.38,66.48 46.15,66.25 45.85,66.25
  L7-SIG w0.102: 45.85,66.25 44.83,66.25 44.5,65.93 43.48,65.93 42.92,66.48 41.9,66.48 41.61,66.19 41.61,65.94 41.39,65.73 41.39,65.35 41.18,65.14 40.49,65.14 39.23,63.87 37.69,63.87 37.44,63.61 37.44,59.34 37.31,59.22 37.31,58.91 37.31,54.86 36.54,54.09 34.99,54.09 34.32,53.42 33.27,53.42 32.97,53.12 31.68,53.12 31.4,52.84 28.27,52.84 27.7,53.41 26.71,53.41 25.65,52.36 20.74,52.36 v2(20.25,51.87) ; v1(21.29,5.78) 21.29,6.03 v2(21.03,6.28)
CE#: length 4
  BOTTOM w0.31: U8800.9 31.72,23.18 31.05,22.51 30.6,22.51 30.43,22.34 R8809.1 R8808.2 R8835.2
CHG#_3V3: length 32.6
  L7-SIG w0.084: v1(52.96,5.92) 52.96,2.65 53.83,1.77 77.25,1.77 79.37,3.9 79.82,3.9 v1(80.68,4.76)
CHG_CE#: length 114.7
  L4-SIG w0.109: v3(43.1,52.95) 43.6,53.45 54.26,53.45 54.57,53.14 55.62,53.14 56.5,54.02 58.54,54.02 58.65,54.13 60.96,54.13 60.96,54.13 62.03,54.13 65.87,57.98 v3(65.87,58.27)
  L5-SIG w0.109: v3(29.46,23.3) 29.74,23.58 29.74,36.02 30.38,36.66 30.38,37.14 30.92,37.68 30.92,41.7 27.13,45.48 27.13,49.77 28.09,50.73 30.81,50.73 32.64,52.56 32.64,52.82 v3(32.84,53.02) 33.43,52.44 33.43,52.19 33.68,51.93 36.44,51.93 37.09,52.59 38.2,52.59 38.38,52.41 38.84,52.41 39.2,52.76 39.2,53 39.84,53.63 42.43,53.63 v3(43.1,52.95) ; v3(65.87,58.27) 66.16,58.55 68.69,58.55 69.09,58.15 74.04,58.15 74.47,58.58 v3(74.47,59.2)
  L6-GND w0.102: v1(29.15,23.07) 29.38,23.3 v3(29.46,23.3) ; v4(74.65,59.65) 74.65,59.38 v3(74.47,59.2) ; v3(32.84,53.02) v4(32.84,53.4)
  L7-SIG w0.084: v1(41.07,66.11) 40.48,65.51 40.34,65.51 39.07,64.25 37.54,64.25 37.28,63.99 37.06,63.77 37.06,60.74 36.87,60.55 36.87,59.23 37.12,58.98 37.12,58.83 37.12,55.57 36.58,55.03 36.58,54.74 36.14,54.3 34.92,54.3 34.32,53.7 33.14,53.7 v4(32.84,53.4) ; v1(77.31,69.94) 77.55,69.7 77.55,68.6 76.78,67.83 76.78,67.83 75.12,66.17 75.12,62.35 75.03,62.27 75.03,60.03 v4(74.65,59.65)
CHG_INT#: length 120.3
  L4-SIG w0.102: v3(75.64,58.97) 75.69,58.93 75.69,57.37 74.91,56.59 74.91,46.92 74.3,46.31 74.3,42.78 75.08,42 75.08,33.82 v3(75.59,33.31) 75.08,33.31 74.4,32.62 74.4,31.23 74.65,30.97 74.65,25.51 74.93,25.23 74.93,22.74 72.63,20.44 64.9,20.44 63.77,19.31 62.16,19.31 60.61,17.76 59.46,17.76 v3(59.43,17.74) ; v3(55.86,8.32) 55.27,8.9 43.44,8.9 41.13,11.21 35.74,11.21 34.2,12.75 32.15,12.75 30.66,14.25 30.66,16.44 29.24,17.87 v3(28.73,17.87)
  L5-SIG w0.102: v3(55.86,8.32) 55.86,15.88 57.71,17.74 v3(59.43,17.74)
  L6-GND w0.102: v3(75.59,33.31) 75.29,33.61 v1(75.29,33.72) ; v1(28.37,17.87) v3(28.73,17.87) ; v4(75.64,59.42) v3(75.64,58.97)
  L7-SIG w0.102: v4(75.64,59.42) 76.78,60.56 76.78,61.83 76.18,62.44 76.18,66.31 76.34,66.48 77.21,66.48 77.23,66.46 77.73,66.46 77.9,66.64 77.9,68.13 78.54,68.77 78.54,69.47 v1(78.4,69.61)
  BOTTOM w0.102: U3001.22 77.92,69.54 78.06,69.68 R3015.1 ; v1(28.37,17.87) 28.78,18.27 R8825.1 30.66,18.27 31.17,18.78 R8826.1 31.45,19.29 31.43,19.3 R8833.1
CHG_SCL: length 3.7
  L7-SIG w0.084: v1(33.22,21.58) 33.22,21.15 v1(32.89,20.81) 33.3,20.81 33.55,20.56 33.55,19.45 33,18.89 v1(33,18.78)
CHG_SDA: length 4.3
  L7-SIG w0.084: v1(32.72,21.58) 32.72,21.36 v1(32.18,20.81) 32.18,20.59 32.31,20.46 33.07,20.46 33.17,20.36 33.17,19.57 32.39,18.78 v1(32.3,18.78)
CLK_DEBUG: length 23.8
  L3-GND w0.102: v8(58.89,107.02) v3(58.89,106.66)
  L4-SIG w0.102: v3(58.89,106.66) 56.12,103.89 40.1,103.89 38.07,101.86 v3(38.07,101.61)
  L6-GND w0.102: v1(38.38,101.39) 38.16,101.61 v3(38.07,101.61)
CODEC_RESET#: length 96.5
  L4-SIG w0.109: v3(33.58,53.88) 34.25,53.88 35.26,52.87 35.26,42.04 39.56,37.75 39.56,26.33 44.38,21.5 51.16,21.5 52.25,22.59 53.63,22.59 54.72,21.5 55.22,21.5 55.71,21.01 57.87,21.01 59.15,22.29 61.72,22.29 64.04,24.61 68.88,24.61 71.94,27.67 v3(73.23,27.67)
  L5-SIG w0.109: v3(73.23,27.67) 72.16,27.67 69.19,30.64 61.92,30.64 60.15,32.41 60.15,33.86 v6(59.92,34.09)
  L6-GND w0.102: v1(73.7,27.67) v3(73.23,27.67) ; v3(33.58,53.88) 34.06,54.37 v4(34.06,54.49)
  L7-SIG w0.084: v4(34.06,54.49) 34.06,54.85 34.13,54.92 34.13,57.56 34.43,57.85 34.43,59.31 33.84,59.89 33.84,61.98 v1(34.21,62.34)
COMPASS_RSTN#: length 90.5
  L4-SIG w0.109: v3(67.97,113.65) 68.71,114.39 70.81,114.39 74.75,110.45 80.76,110.45 88.22,102.99 88.22,99.32 88.9,98.63 88.9,94.1 86.97,92.17 85.76,92.17 84.5,90.91 83.98,90.91 83.18,90.1 83.18,89.81 82.1,88.73 82.1,86.53 76.76,81.19 76.76,77.84 75.44,76.52 72.29,76.52 70.91,75.14 70.91,73.8 71.25,73.45 71.71,73.45 72.55,72.6 72.55,68.76 v3(72.72,68.6) ; v3(70.79,68.36) 70.46,68.69 70.46,69.67 70.9,70.11 70.9,70.43 70.67,70.65 70.27,70.65 69.93,70.99 69.93,71.94 v3(70.08,72.09)
  L5-SIG w0.06: v10(59.37,72.62) 59.52,72.78 62.24,72.78 62.85,72.16
  L5-SIG w0.107: 62.85,72.16 63.67,71.34 64.82,71.34
  L5-SIG w0.109: v3(70.79,68.36) 71.03,68.6 v3(72.72,68.6) ; v3(70.08,72.09) 69.82,72.09 69.24,71.51 67.56,71.51 67.55,71.51 67.52,71.5 67.36,71.34 64.82,71.34 64.82,71.34
  L6-GND w0.102: v10(59.37,72.62) 59.38,72.63 v6(59.38,73) ; v1(67.97,114) v3(67.97,113.65)
CORE_PWROK: length 115.7
  L4-SIG w0.109: v3(79.75,63.63) 79.53,63.41 79.53,60.67 80.95,59.25 80.95,57.64 82.99,55.6 v3(82.99,54.57)
  L5-SIG w0.109: v3(81.94,64.22) 80.34,64.22 v3(79.75,63.63)
  L6-GND w0.06: v6(59.52,36.54) 59.73,36.74 59.73,37.02 59.9,37.19 59.9,37.57 60.71,38.38 60.71,38.59
  L6-GND w0.102: v4(61.77,45.17) 61.77,43.06 61.35,42.64 61.35,39.38 60.71,38.73 60.71,38.62 60.71,38.62 60.71,38.59 ; v3(82.99,54.57) 82.99,54.22 v4(82.96,54.18) ; v3(81.94,64.22) 81.98,64.26 v4(82.34,64.26) ; v4(70.16,63.26) 70.55,63.26 v3(70.57,63.23) 70.95,63.23 v4(70.95,63.23)
  L7-SIG w0.06: v6(59.64,65.27) 59.97,65.27 60.33,64.91 60.6,64.91 60.7,65 60.82,65 61.05,65.23 61.22,65.23 61.92,64.53 61.92,63.74 63.23,62.43 64.2,62.43 64.36,62.26 64.36,61.96 64.52,61.81
  L7-SIG w0.084: 64.52,61.81 64.65,61.67 66.66,61.67 66.85,61.86 67.7,61.86 67.89,62.05 68.96,62.05 v4(70.16,63.26) v1(70.16,63.64) ; v4(70.95,63.23) 71,63.23 71.65,62.58 71.88,62.58 72.06,62.76 72.06,63.28 72.21,63.43 73.93,63.43 74.1,63.26 74.1,60.67 73.52,60.1 73.09,60.1 72.93,59.94 72.93,59.67 73.04,59.56 74.26,59.56 74.7,59.12 75.9,59.12 77.6,60.82 79.94,60.82 80.66,61.54 80.66,63.79 81.13,64.26 v4(82.34,64.26) 82.18,64.42 82.18,66.13 83.85,67.8 83.85,70.53 v1(83.74,70.64) 83,71.38 83,82.61 84.57,84.17 84.77,84.17 84.93,84.17 85.46,84.7 85.46,85.09 84.83,85.72 84.83,88.35 85.42,88.94 86.92,88.94 87.19,88.67 v1(87.65,88.67) ; v4(61.77,45.17) 61.85,45.25 66.92,45.25 67.47,45.8 71.82,45.8 73.01,46.99 75.76,46.99 v4(82.96,54.18)
  BOTTOM w0.31: T2625.1 84.91,70.64 v1(83.74,70.64)
CPS_I2C_SCL: length 7.1
  L7-SIG w0.084: v1(68.22,117.56) 68.16,117.62 68.16,117.7 67.96,117.89 67.68,117.89 67.16,117.37 67.16,113.98 v1(66.09,112.91) v1(65.35,112.91)
CPS_I2C_SDA: length 6.6
  L7-SIG w0.084: v1(67.82,117.56) 67.5,117.23 67.5,113.54 67.59,113.45 v1(67.59,112.91) v1(66.85,112.91)
  BOTTOM w0.31: v1(67.59,112.91) 68.46,112.91 v9(68.61,113.07)
CPU_VREF: length 4.3
  L7-SIG w0.06: v6(53.42,78.38) 53.42,78.72 53.19,78.96 53.19,80.59 v6(52.86,80.92)
  BOTTOM w0.254: R2401.2 C2401.1 R2400.1
CPVEE: length 3.5
  BOTTOM w0.178: 25.73,69.37 26.15,68.94 U1001.27
  BOTTOM w0.254: C1006.1 v9(24.76,70.32) 24.78,70.32 25.73,69.37
CPVPP: length 2.3
  BOTTOM w0.178: U1001.24 24.4,67.94 24.26,68.08
  BOTTOM w0.254: C1005.1 24.07,69.08 24.07,68.27 24.26,68.08
DACDAT2: length 3.1
  BOTTOM w0.102: U1001.33 28.55,68.84 29.45,69.74 30.46,69.74 R1051.1
DBG_RESETBTN#: length 167.7
  L4-SIG w0.109: v3(13.83,73.22) 14.46,73.22 14.46,73.21 14.87,73.21 15.16,73.5 15.16,76.06 14.69,76.52 14.69,79.6 15.23,80.14 15.23,92.5 16.17,93.44 16.17,99.64 19.01,102.48 24.25,102.48 26.47,100.26 32.05,100.26 v3(32.3,100.51) ; v3(35.77,100.1) 35.77,101.85 35.94,102.02 39.76,105.84 47.69,105.84 49.84,107.99 58.12,107.99 58.48,108.34 58.94,108.34 59.45,107.83 65.38,107.83 73.85,99.36 v3(75.78,99.36)
  L5-SIG w0.109: v3(13.83,73.22) 14.27,72.78 21.93,72.78 22.92,71.79 26.2,71.79 30.1,67.89 30.1,67.05 30.94,66.2 31.96,66.2 32.74,65.42 32.74,63.28 35.08,60.94 36.32,60.94 36.42,60.84 38.3,60.84 40.36,58.79 41.9,58.79 43.31,57.38 46.14,57.38 47.17,58.41 v3(47.17,58.68) ; v3(85.17,89.57) 85.17,94.61 84.41,95.37 84.41,98.44 84.18,98.67 76.47,98.67 v3(75.78,99.36) ; v3(32.3,100.51) 32.78,100.03 35.7,100.03 v3(35.77,100.1)
  L6-GND w0.102: v3(47.17,58.68) 47.12,58.73 v4(47.12,59.04) ; v3(85.17,89.57) 85.44,89.57 v1(85.55,89.47)
  L7-SIG w0.06: 46.9,61.93 46.9,62.62 47.49,63.21 47.49,63.73 47.62,63.86 47.62,64.05 47.17,64.5 v6(47.17,64.8)
  L7-SIG w0.084: 46.9,61.93 46.9,61.61 45.76,60.47 45.76,60.13 45.95,59.93 46.11,59.78 46.99,59.78 47.12,59.65 v4(47.12,59.04)
DDI0_DDC_SCL: length 77.4
  L5-SIG w0.06: v6(60.47,71.28) 60.45,71.3 59.97,71.3 58.45,69.78
  L5-SIG w0.109: v3(88.14,34.6) 89.03,35.49 89.03,53.53 87.08,55.48 87.08,60.57 85.58,62.07 79.9,62.07 79.42,61.59 71.38,61.59 71.3,61.5 70.47,61.5 69.54,60.57 63.57,60.57 63.15,60.99 60.77,60.99 59.83,61.93 55.73,61.93 55.13,62.53 55.13,64.14 53.24,66.03 53.24,66.89 53.68,67.32 55.92,67.32 57.48,68.88 57.48,69.22 58.03,69.77 58.44,69.77 58.45,69.78
  L6-GND w0.102: v3(88.14,34.6) 88.14,34.53 v1(88.49,34.17)
  L7-SIG w0.084: v1(87.37,34.43) 87.62,34.17 v1(88.49,34.17)
DDI0_DDC_SDA: length 79.3
  L5-SIG w0.109: v3(87.98,32.14) 87.68,32.45 87.68,35.09 88.77,36.18 88.77,53.43 86.87,55.33 86.87,60.49 85.5,61.86 79.99,61.86 79.5,61.38 71.47,61.38 71.38,61.29 70.56,61.29 69.63,60.36 63.48,60.36 63.06,60.78 60.68,60.78 59.79,61.67 55.75,61.67 54.96,62.46 54.96,64.07 53.07,65.96 53.07,66.96 53.61,67.5 55.81,67.5 57.29,68.98 57.29,69.44 57.8,69.95 58.42,69.95 58.82,70.35 58.82,70.72 v6(59.37,71.26)
  L6-GND w0.102: v1(88.49,31.62) 88.49,31.91 88.29,32.12 88.01,32.12 v3(87.98,32.14)
  L7-SIG w0.084: v1(88.49,31.62) 88.49,31.23 v1(88.11,30.85)
DDI0_HPD#: length 62.8
  L4-SIG w0.076: v3(61.72,69.96) 59.65,69.96 v3(58.56,71.06)
  L4-SIG w0.109: v3(74.6,66.81) 74.81,66.6 74.81,64.12 75.46,63.47 75.46,60.32 76.03,59.75 76.03,57.42 75.13,56.52 75.13,48.98 79.36,44.75 79.36,37.3 82.1,34.55 82.63,34.55 v3(82.73,34.45)
  L5-SIG w0.06: 63.51,68.6 63.3,68.81 62.92,68.81 61.77,69.96 v3(61.72,69.96)
  L5-SIG w0.109: v3(74.6,66.81) 74.24,67.17 73.29,67.17 73.06,67.4 67.76,67.4 66.87,68.29 63.82,68.29 63.51,68.6
  L6-GND w0.102: v6(58.8,71.3) 58.56,71.06 v3(58.56,71.06) ; v3(82.73,34.45) 83.09,34.09 v4(83.09,34.09)
  L7-SIG w0.084: v4(83.09,34.09) 83.12,34.06 83.12,29.79 83.54,29.37 v1(85.08,29.37) 85.42,29.04 v1(85.42,28.55)
DDI0_RCOMP_DN: length 10.5
  L4-SIG w0.127: v3(41.02,64.25) 41.34,64.56 44.29,64.56 44.56,64.28 49.89,64.28 v3(50.31,64.7)
  L6-GND w0.06: v6(50.31,65.08) v3(50.31,64.7)
  L6-GND w0.127: v1(41.02,63.87) v3(41.02,64.25)
DDI0_RCOMP_DP: length 10.7
  L4-SIG w0.127: v3(41.61,64.17) 42.32,64.17 42.43,64.06 50.22,64.06 50.78,64.61 v3(50.78,65.01)
  L6-GND w0.06: v6(50.6,65.36) 50.6,65.2 v3(50.78,65.01)
  L6-GND w0.127: v1(41.89,63.9) 41.88,63.9 v3(41.61,64.17)
DDI0_TX0_DN: length 55.1
  L5-SIG w0.094: v3(85.01,44.71) 84.84,44.54 84.68,44.54 84.53,44.69 84.53,45.07 85.78,46.31 85.78,48.42 85.14,49.06 85.14,51.87 83.24,53.77 81.97,53.77 80.09,55.66 52.43,55.66 49.59,58.49 49.59,61.67 50.11,62.18 50.11,64.3 49.89,64.52 49.89,64.83 49.46,65.25 v6(49.46,65.36)
  L6-GND w0.102: v3(85.01,44.71) 85.19,44.54 85.48,44.54 85.59,44.65 v1(85.59,44.84)
DDI0_TX0_DN_R: length 1.1
  L7-SIG w0.076: v1(87.35,44.79) 87.12,44.56 86.73,44.56 v1(86.46,44.84)
DDI0_TX0_DP: length 55.2
  L5-SIG w0.094: v6(49.18,65.08) 49.36,65.08 49.69,64.75 49.69,64.44 49.91,64.22 49.91,62.26 49.4,61.75 49.4,58.41 52.23,55.58 52.23,55.58 52.35,55.46 80.01,55.46 81.89,53.58 83.16,53.58 84.95,51.79 84.95,48.98 85.58,48.34 85.58,46.39 84.34,45.15 84.34,44.6 84.6,44.34 84.83,44.34 84.84,44.34 84.85,44.34 v3(85.04,44.15)
  L6-GND w0.102: v1(85.59,44.08) 85.34,44.33 85.22,44.33 v3(85.04,44.15)
DDI0_TX0_DP_R: length 1.1
  L7-SIG w0.076: v1(86.46,44.08) 86.75,44.37 87.11,44.37 v1(87.35,44.14)
DDI0_TX1_DN: length 49.8
  L5-SIG w0.094: v3(84.96,47.79) 84.78,47.6 84.59,47.6 84.02,48.17 84.02,52.03 83.01,53.04 81.59,53.04 80.43,54.2 77.28,54.2 76.94,54.54 69.61,54.54 69.16,54.99 51.96,54.99 48.92,58.03 48.92,62.34 49.7,63.12 49.7,63.94 v6(49.69,63.95)
  L6-GND w0.102: v3(84.96,47.79) 85.17,47.58 85.29,47.58 v1(85.59,47.89)
DDI0_TX1_DN_R: length 1.1
  L7-SIG w0.076: v1(87.35,47.83) 87.13,47.61 86.73,47.61 v1(86.46,47.89)
DDI0_TX1_DP: length 49.8
  L5-SIG w0.094: v6(49.46,63.64) 49.5,63.61 49.5,63.2 48.73,62.42 48.73,57.95 51.77,54.91 51.88,54.79 69.08,54.79 69.53,54.34 69.69,54.34 76.86,54.34 77.09,54.12 77.2,54 80.35,54 81.5,52.85 82.92,52.85 83.83,51.95 83.83,48.09 84.51,47.41 84.78,47.41 v3(84.95,47.23)
  L6-GND w0.102: v3(84.95,47.23) 85.11,47.38 85.34,47.38 v1(85.59,47.13)
DDI0_TX1_DP_R: length 1.1
  L7-SIG w0.076: v1(86.46,47.13) 86.75,47.42 87.11,47.42 v1(87.35,47.18)
DDI0_TX2_DN: length 57.1
  L5-SIG w0.094: v6(49.46,64.23) 49.46,63.96 48.25,62.75 48.25,57.62 51.56,54.32 51.69,54.32 51.69,54.32 52.08,54.32 52.08,54.32 68.88,54.32 69.35,53.85 76.59,53.85 76.7,53.74 77.01,53.43 80.18,53.43 81.25,52.35 82.66,52.35 83.26,51.75 83.26,42.1 84,41.36 84.79,41.36 v3(84.96,41.54)
  L6-GND w0.102: v3(84.96,41.54) 85.14,41.36 85.29,41.36 v1(85.59,41.67)
DDI0_TX2_DN_R: length 1.1
  L7-SIG w0.076: v1(87.35,41.64) 87.13,41.42 86.7,41.42 v1(86.46,41.67)
DDI0_TX2_DP: length 57.1
  L5-SIG w0.094: v3(84.99,40.98) 84.8,41.17 83.92,41.17 83.07,42.02 83.07,51.67 82.58,52.16 81.17,52.16 80.1,53.23 76.93,53.23 76.51,53.65 69.27,53.65 68.8,54.12 52.16,54.12 51.48,54.12 48.06,57.54 48.06,62.83 49.12,63.89 v6(49.12,63.95)
  L6-GND w0.102: v3(84.99,40.98) 85.17,41.16 85.34,41.16 v1(85.59,40.9)
DDI0_TX2_DP_R: length 1.1
  L7-SIG w0.076: v1(87.35,40.99) 87.11,41.22 86.78,41.22 v1(86.46,40.9)
DDI0_TX3_DN: length 59.3
  L5-SIG w0.094: v3(86.03,38.54) 86.21,38.36 86.29,38.36 86.49,38.57 86.49,52.31 83.58,55.22 81.33,55.22 80.42,56.13 53.05,56.13 52.93,56.25 51.41,57.77 51.41,58.06 51.41,58.06 51.41,58.62 51.41,59.62 50.87,60.17 50.87,63.68 50.6,63.95 v6(50.36,63.95)
  L6-GND w0.102: v1(85.59,38.62) 85.59,38.33 85.66,38.26 85.75,38.26 86.03,38.54 v3(86.03,38.54)
DDI0_TX3_DN_R: length 1.1
  L7-SIG w0.076: v1(87.35,38.54) 87.11,38.31 86.77,38.31 v1(86.46,38.62)
DDI0_TX3_DP: length 59.4
  L5-SIG w0.094: v6(50.6,64.23) 51.06,63.76 51.06,60.25 51.61,59.7 51.61,58.54 51.61,57.85 53.13,56.33 80.5,56.33 81.41,55.41 83.66,55.41 86.69,52.39 86.69,38.49 86.36,38.16 86.21,38.16 v3(86.03,37.98)
  L6-GND w0.102: v1(85.59,37.86) 85.72,37.98 v3(86.03,37.98)
DDI0_TX3_DP_R: length 1.1
  L7-SIG w0.076: v1(87.35,37.89) 87.12,38.11 86.72,38.11 v1(86.46,37.86)
DDI1_AUX_DN: length 96.3
  L5-SIG w0.094: v6(50.88,65.65) 50.95,65.65 52.6,63.99 52.6,61.04 52.95,60.69 52.95,58.7 53.98,57.67 54.9,57.67 56.09,58.86 57.53,58.86 57.99,58.4 57.99,58.05 58.37,57.67 81.25,57.67 82.12,56.81 84.21,56.81 84.23,56.78 88.05,52.96 88.05,37.92 83.72,33.59 83.72,23.56 82.47,22.31 68.43,22.31 67.31,23.43 67.31,24.21 v3(67.31,24.21)
  L6-GND w0.102: v3(67.31,24.21) 67.22,24.12 v1(67.22,23.84)
DDI1_AUX_DN_R: length 5.4
  L7-SIG w0.076: v1(65.75,22.65) 66.02,22.92 66.2,22.92 v1(66.47,22.65) 66.47,22.96 66.51,23.01 66.75,23.01 67.11,23.36 67.45,23.36 67.54,23.28 67.54,23.02 67.5,22.98 v1(67.22,22.98)
  BOTTOM w0.178: U7107.1 66.97,21.43 67.07,21.54 67.07,21.96 67.45,22.34 67.45,22.75 v1(67.22,22.98)
DDI1_AUX_DP: length 96.3
  L5-SIG w0.094: v3(67.87,24.22) 67.87,23.87 67.83,23.82 67.57,23.82 67.51,23.76 67.51,23.51 68.51,22.51 82.39,22.51 83.52,23.64 83.52,33.67 87.86,38.01 87.86,52.88 84.12,56.61 82.04,56.61 81.17,57.47 58.29,57.47 58.17,57.59 57.79,57.97 57.79,58.32 57.45,58.67 56.17,58.67 54.98,57.47 53.9,57.47 52.76,58.62 52.76,60.61 52.41,60.96 52.41,63.91 50.93,65.39 50.8,65.39 50.6,65.6 v6(50.6,65.93)
  L6-GND w0.102: v3(67.87,24.22) 67.95,24.15 v1(67.95,23.84)
DDI1_AUX_DP_R: length 5.5
  L7-SIG w0.076: v1(65.75,23.39) 66.03,23.11 66.19,23.11 v1(66.47,23.39) 66.47,23.26 66.52,23.2 66.68,23.2 67.03,23.56 67.53,23.56 67.73,23.36 67.73,23.06 67.81,22.98 v1(67.95,22.98)
  BOTTOM w0.178: U7107.2 67.47,21.42 67.35,21.54 67.35,21.84 67.73,22.22 67.73,22.76 v1(67.95,22.98)
DDI1_BKLT_EN: length 95.4
  L4-SIG w0.109: v3(64.97,14.39) 64.97,15.39 64.79,15.57 64.79,15.89 65.25,16.35 66.38,16.35 67.08,15.65 73.18,15.65 75.66,18.13 78.71,18.13 78.73,18.11 79.27,18.11 82.11,20.94 82.11,31.96 83.17,33.02 83.17,34.71 83.05,34.84 82.12,34.84 79.63,37.32 79.63,51.65 v3(79.49,51.79) ; v3(70.57,51.68) 70.57,51.63 69.85,52.35 69.85,61.73 67.75,63.83 67.75,64.69 66.74,65.71 66.74,65.96 66.3,66.41 66.3,67.29 65.91,67.67 65.91,70.88 64.65,72.14 63.75,72.14 v3(63.58,72.31)
  L5-SIG w0.06: 62.89,72.37 62.36,72.9 59.32,72.9 v6(58.84,72.41)
  L5-SIG w0.107: 62.89,72.37 62.95,72.31 v3(63.58,72.31)
  L5-SIG w0.109: v3(79.49,51.79) 79.47,51.81 78.84,51.81 78.7,51.68 76.55,51.68 75.77,52.46 71.35,52.46 v3(70.57,51.68)
  L6-GND w0.102: v3(63.58,72.31) 64,72.73 v6(64.11,72.73) ; v1(65.6,14.66) 65.25,14.66 v3(64.97,14.39)
DDI1_BKLTCTL: length 111.4
  L4-SIG w0.109: v3(78.05,74) 78.05,73.75 79.61,72.19 79.61,71.92 78.56,70.87 78.56,70.75 78.56,69.89 78.56,69.89 78.56,69.22 78.69,69.1 78.69,69.1 80.13,67.65 80.43,67.65 81,67.08 81,66.12 84.14,62.97 84.14,59.43 v3(84.45,59.13)
  L5-SIG w0.06: v6(59.17,72.15) 59.29,72.28 59.7,72.28 59.95,72.54 60.5,72.54 61.65,71.39 61.65,71.38 62.1,70.93 62.56,70.93 62.57,70.94 62.88,70.94 62.89,70.93
  L5-SIG w0.107: 64.95,70.44 63.38,70.44 62.89,70.93
  L5-SIG w0.109: 64.95,70.44 66.78,70.44 67.11,70.11 68.99,70.11 69.17,69.93 69.61,69.93 v3(70.03,69.5) ; v3(66.85,14.77) 67.12,14.51 78.44,14.51 87.28,23.35 87.28,34.98 88.54,36.24 88.54,53.26 84.45,57.35 v3(84.45,59.13)
  L6-GND w0.102: v1(66.37,14.86) 66.46,14.77 v3(66.85,14.77) ; v4(70.36,69.66) 70.21,69.5 v3(70.03,69.5) ; v4(77.82,73.69) 77.82,73.77 v3(78.05,74)
  L7-SIG w0.084: v4(70.36,69.66) 70.36,69.71 71.06,70.41 71.55,70.41 72.14,71 72.34,71 73.26,71.93 74.6,71.93 76.37,73.69 v4(77.82,73.69) ; v1(59.99,15.29) 60,15.29 v1(60.73,16.02) 61.79,16.02 62.46,16.69 64.65,16.69 65.15,16.19 65.15,16.17 65.56,15.76 65.58,15.76 65.96,15.38 65.96,15.19 66.3,14.86 v1(66.37,14.86)
DDI1_DDC_SCL: length 21.8
  L5-SIG w0.06: v3(62.38,71.79) 62.43,71.79 62.85,71.37
  L5-SIG w0.102: 62.85,71.37 63.58,70.65 66.87,70.65 67.2,70.32 68.6,70.32 68.98,70.69 70.39,70.69 70.79,71.09 70.79,71.51 70.97,71.69 71.5,71.69 73.98,74.18 73.98,76.48 74.76,77.26 74.76,77.26 v3(75.03,77.53)
  L6-GND w0.102: v4(74.47,77.33) 74.83,77.33 v3(75.03,77.53) ; v3(62.38,71.79) 62,71.79 v5(61.95,71.74)
  L7-SIG w0.06: v6(60.76,72.08) 60.85,71.99 61.7,71.99 v5(61.95,71.74)
  L7-SIG w0.102: v1(73.56,77.33) v4(74.47,77.33)
  BOTTOM w0.102: R2522.2 73.56,77.4 v1(73.56,77.33)
DDI1_DDC_SDA: length 20.8
  L5-SIG w0.109: v3(74.6,78.18) 74.6,78.07 73.37,76.84 73.37,74.44 73.25,74.31 71.56,72.63 v3(71.27,72.63)
  L6-GND w0.102: v4(70.94,72.3) v3(71.27,72.63) ; v4(74.14,78.18) v3(74.6,78.18)
  L7-SIG w0.06: 63.19,71.73 62.32,71.73 61.63,72.42 60.02,72.42 59.95,72.35 v6(59.92,72.35)
  L7-SIG w0.084: v4(70.94,72.3) 69.85,72.3 69.41,71.86 67.84,71.86 67.59,71.61 66.32,71.61 66.13,71.81 65.32,71.81 65.07,71.55 64.47,71.55 64.3,71.73 63.19,71.73 ; v4(74.14,78.18) 73.72,78.18 v1(73.36,78.55)
DDI1_HPD: length 16.3
  L7-SIG w0.084: v1(57.08,16.8) 57.24,16.64 58.43,16.64 58.67,16.88 v1(59.97,16.88) 60.23,17.14 61.03,17.14 61.3,16.87 64.01,16.87 64.82,17.69 64.82,18.05 65.52,18.75 65.52,18.89 66.5,19.87 69.88,19.87 v1(70.97,20.96)
DDI1_HPD_N: length 117.5
  L4-SIG w0.109: v2(82.73,9.81) 82.73,10.34 85.43,13.05 85.43,30.85 86.35,31.77 86.35,35.55 86.35,35.9 84.16,38.09 84.16,51.09 85.74,52.67 85.74,56.33 83.93,58.14 83.93,62.77 81.19,65.52 80.99,65.52 v3(80.56,65.95)
  L5-SIG w0.06: v6(60.22,72.21) 60.96,71.47 60.96,71.31 62.09,70.18 62.09,69.88 62.92,69.05 63.09,69.05
  L5-SIG w0.109: 63.09,69.05 63.35,69.05 63.9,68.5 66.96,68.5 67.8,67.65 71.38,67.65 71.91,68.18 74.73,68.18 v3(76.36,66.55)
  L6-GND w0.102: v1(80.29,65.64) 80.56,65.91 v3(80.56,65.95) ; v3(76.36,66.55) 76.46,66.45 v4(76.46,66.2)
  L7-SIG w0.084: v2(82.73,9.81) 82.22,10.33 79.38,10.33 78.22,9.17 77.18,9.17 76.97,8.96 74.78,8.96 74.4,9.34 70.38,9.34 70,8.96 69.48,8.96 68.22,10.22 65.59,10.22 65.28,10.53 63.1,10.53 62.1,11.52 59.7,11.52 v1(58.21,13.01) 58.21,13.82 v1(58.03,14) ; v1(80.29,65.64) 80.29,64.81 79.05,63.57 79.05,63.53 78.64,63.12 77.84,63.12 76.46,64.51 v4(76.46,66.2)
DDI1_TX0_DN: length 89.1
  L5-SIG w0.094: v3(69.35,23.4) 69.35,23.86 69.49,24 69.71,24 69.79,23.91 69.79,23.28 69.9,23.18 82.11,23.18 82.77,23.84 82.77,33.89 87.18,38.29 87.18,52.61 83.85,55.94 81.7,55.94 80.84,56.8 53.62,56.8 53.51,56.92 52.08,58.34 52.08,59.94 51.64,60.38 51.64,63.01 51.81,63.18 51.81,63.58 v6(51.73,63.66)
  L6-GND w0.102: v3(69.35,23.4) 69.35,23.76 v1(69.43,23.84)
DDI1_TX0_DN_R: length 2.3
  BOTTOM w0.178: U7107.5 68.97,21.37 68.86,21.47 68.86,22.06 69.19,22.39 69.19,22.44 69.19,22.74 C7146.1
DDI1_TX0_DP: length 89.2
  L5-SIG w0.094: v3(68.79,23.39) 69.21,22.98 82.2,22.98 82.97,23.76 82.97,33.8 87.38,38.21 87.38,52.69 83.93,56.14 81.78,56.14 80.92,57 53.7,57 52.28,58.42 52.28,60.02 51.84,60.46 51.84,62.92 52.01,63.09 v6(52.01,63.95)
  L6-GND w0.102: v1(68.69,23.84) 68.69,23.49 v3(68.79,23.39)
DDI1_TX0_DP_R: length 2.3
  BOTTOM w0.178: C7149.1 68.91,22.76 68.91,22.51 68.58,22.18 68.58,21.5 68.47,21.38 U7107.4
DDI1_VDDEN: length 127.3
  L4-SIG w0.109: v3(73.79,68.82) 73.79,68.8 75.02,67.57 75.02,64.2 75.67,63.56 75.67,60.67 v3(75.85,60.49) ; v2(82.04,9.81) 82.04,10.16 85.22,13.34 85.22,30.94 86.14,31.86 86.14,35.64 86.14,35.81 83.95,38 83.95,51.17 85.53,52.76 85.53,56.24 83.85,57.93 83.72,58.05 83.72,61.08 v3(83.49,61.32)
  L5-SIG w0.06: v6(58.8,71.84) 59.18,71.84 59.44,72.09 59.74,72.09 60.06,72.42 60.31,72.42 61.15,71.57 61.15,71.29 62.28,70.16 62.28,69.86 62.88,69.26 63.47,69.26
  L5-SIG w0.109: v3(73.79,68.82) 73.62,68.98 71.84,68.98 71.77,68.91 70.79,68.91 70.43,68.55 68.32,68.55 68.2,68.67 68.16,68.71 64.02,68.71 63.47,69.26 ; v3(83.49,61.32) 83.31,61.14 81.84,61.14 81,60.3 79.57,60.3 79.22,59.95 77.59,59.95 77.06,60.49 v3(75.85,60.49)
  L7-SIG w0.084: v1(61.77,15) 61.14,15.63 60.78,15.63 60.12,14.97 59.59,14.97 59.11,15.45 57.58,15.45 v1(57.23,15.1) ; v1(56.08,14.41) 56.71,13.78 v1(56.71,13.01) 59.42,10.3 65.25,10.3 65.52,10.03 68.14,10.03 69.4,8.77 70.08,8.77 70.46,9.15 74.32,9.15 74.7,8.77 77.05,8.77 77.25,8.98 78.9,8.98 80.04,10.12 81.74,10.12 v2(82.04,9.81)
  BOTTOM w0.31: v1(56.08,14.41) 56.54,14.41 v1(57.23,15.1)
DDR3L_PWROK: length 158.9
  L4-SIG w0.102: v3(87.83,102.24) 87.83,99.38 86.84,98.39 86.84,97.48 86.59,97.23 86.59,96.47 80.41,90.28 80.29,90.28 79.78,90.28 78.58,89.09 75.43,89.09 74.27,87.93 74.27,87.14 73.71,86.58 v3(73.71,86.57)
  L5-SIG w0.06: 63.02,73.45 58.31,73.45 57.13,74.63 56.76,74.63 56.67,74.72 56.67,74.94 56.48,75.13 56.05,75.13 55.79,74.87 53.62,74.87 53.41,75.09 53.41,75.92 53.42,75.93 v6(53.42,76.11)
  L5-SIG w0.102: v3(73.71,86.57) 73.71,80.63 72.91,79.83 72.91,77.87 68.12,73.07 64.28,73.07 63.9,73.45 63.02,73.45 ; v3(91.63,51.94) 92.07,51.94 93.45,53.32 93.45,62.77 96.11,65.44 96.11,96.17 90.04,102.24 v3(87.83,102.24)
  L6-GND w0.06: v6(59.52,36.94) 59.61,37.02 59.61,37.07 59.78,37.24 59.78,37.62 60.5,38.34 60.5,38.59
  L6-GND w0.102: v3(73.71,86.57) 74.06,86.92 v1(74.28,86.92) ; v4(61.39,45.17) 61.39,42.99 61.15,42.74 61.15,39.46 60.5,38.82 60.5,38.69 60.5,38.69 60.5,38.59 ; v4(91.49,51.6) 91.63,51.74 v3(91.63,51.94)
  L7-SIG w0.102: v4(91.49,51.6) 88.88,51.6 86.01,54.47 82.84,54.47 78.73,50.36 78.73,50.29 75.63,47.18 72.93,47.18 71.74,45.99 67.39,45.99 66.85,45.45 61.66,45.45 61.39,45.19 v4(61.39,45.17)
DDR3L_VCCA_PWROK: length 163.1
  L4-SIG w0.102: v3(87.83,102.83) 87.43,102.43 87.43,99.27 86.64,98.48 86.64,97.57 86.39,97.31 86.39,96.55 80.32,90.49 79.7,90.49 78.65,89.44 75,89.44 74.07,88.51 74.07,87.58 v3(73.75,87.27)
  L5-SIG w0.06: v6(59.12,36.14) 59.12,36.18 59.16,36.22 59.12,36.25 59.38,36.51 59.45,36.51 60.61,37.67 60.67,37.67 61.46,38.46 61.46,38.59 ; v6(53.42,77.81) 53.42,77.07 53.22,76.86 53.22,76.63 53.27,76.59 53.27,76.26 53.22,76.22 53.22,75.99 53.29,75.92 53.29,75.04 53.6,74.72 55.76,74.72 55.99,74.49 57.1,74.49 58.3,73.29 58.54,73.29
  L5-SIG w0.102: 58.54,73.29 63.58,73.29 64,72.87 68.2,72.87 73.11,77.78 73.11,79.74 74.1,80.72 74.1,86.93 v3(73.75,87.27) ; v3(87.83,102.83) 89.74,102.83 96.32,96.25 96.32,65.36 93.65,62.69 93.65,53.16 91.86,51.37 v3(91.86,51.33) ; v3(82.17,47.36) 81.92,47.36 80.62,46.06 66.33,46.06 61.46,41.19 61.46,38.59
  L6-GND w0.102: v1(73.51,86.98) 73.75,87.23 v3(73.75,87.27) ; v3(82.17,47.36) v4(82.53,47.36) ; v4(91.49,51.24) 91.73,51.24 91.82,51.33 v3(91.86,51.33)
  L7-SIG w0.102: v4(91.49,51.24) 91.42,51.32 88.88,51.32 86.73,53.47 84.36,53.47 84.15,53.26 84.15,49.51 82.93,48.3 82.93,47.75 82.54,47.36 v4(82.53,47.36)
DEBUG_I2C_CLK: length 11.3
  L3-GND w0.102: v3(70.77,37.7) v8(70.77,37.17)
  L5-SIG w0.102: v3(63.2,38.92) 64.42,37.7 v3(70.77,37.7)
  L6-GND w0.102: v3(63.2,38.92) 63.2,38.87 62.87,38.54 62.33,38.54 v6(61.52,37.74) ; v3(70.77,37.7) 71.01,37.46 v1(71.17,37.46)
DEBUG_I2C_DATA: length 11.7
  L3-GND w0.102: v8(70.41,38.62) 70.71,38.31 v3(70.71,38.29)
  L5-SIG w0.102: v3(70.71,38.29) 66.24,38.29 65.23,39.3 62.97,39.3 v3(62.61,38.95)
  L6-GND w0.06: v6(61.12,37.74) 61.32,37.93 61.43,37.93 62.09,38.59
  L6-GND w0.102: v1(71.17,37.98) 71.15,37.98 70.84,38.29 v3(70.71,38.29) ; 62.09,38.59 62.44,38.95 v3(62.61,38.95)
DEBUG_SVID_ALERT_B: length 20.5
  L5-SIG w0.109: v3(54.26,39.13) 54.26,39.47 54.26,39.48 54.26,39.8 54.03,40.02 53.31,40.02 53.03,40.31 52.87,40.31 49.19,43.98 v3(48.67,43.98)
  L6-GND w0.102: v3(54.26,39.13) 54.82,39.13 55.36,38.59 55.36,38.35 v6(55.7,38.01) ; v3(48.67,43.98) v4(48.18,43.98)
  L7-SIG w0.084: v4(48.18,43.98) 49.02,44.82 49.02,46.82 48.37,47.48 47.68,47.48 46.48,48.67 v1(45.56,48.67)
  BOTTOM w0.06: U8201.A2 55.92,37.34 55.63,37.63 55.63,37.93 v6(55.7,38.01)
  BOTTOM w0.31: T8503.1 46.41,48.17 45.9,48.68 R8530.2
DEBUG_SVID_CLK: length 20.1
  L5-SIG w0.109: v3(54.41,38.52) 54.64,38.75 54.64,39.93 54.18,40.39 53.46,40.39 53.18,40.67 53.03,40.67 49.14,44.56 v3(48.74,44.56)
  L6-GND w0.06: v6(55.92,37.74) 55.52,37.74 55.09,38.16 55.09,38.35
  L6-GND w0.102: 55.09,38.35 54.93,38.52 v3(54.41,38.52) ; v3(48.74,44.56) v4(48.26,44.56)
  L7-SIG w0.084: v4(48.26,44.56) 48.59,44.89 48.59,46.73 48.19,47.13 47.53,47.13 46.46,48.2 45.6,48.2 45.56,48.16 v1(45.56,48.04)
  BOTTOM w0.31: R8526.2 45.47,47.58 45.29,47.41 44.15,47.41 T8505.1
DEBUG_SVID_DATA: length 20.5
  L5-SIG w0.109: v3(53.87,39.64) 53.4,39.64 52.94,40.09 52.77,40.09 49.52,43.34 v3(48.67,43.34)
  L6-GND w0.102: v3(53.87,39.64) 54.63,39.64 55.56,38.71 55.56,38.5 v6(56.32,37.74) ; v3(48.67,43.34) v4(48.21,43.34)
  L7-SIG w0.084: v1(45.56,49.29) 46.14,49.29 47.71,47.71 48.51,47.71 49.21,47.01 49.21,43.72 48.83,43.34 v4(48.21,43.34)
  BOTTOM w0.31: R8527.2 46.29,49.41 T8504.1
DET1#: length 44.6
  L7-SIG w0.102: v1(35.66,8.07) 35.27,8.07 34.82,7.63 32.21,7.63 v1(31.14,6.56) 30.89,6.31 28.83,6.31 28.22,6.92 25.43,6.92 25.07,7.27 v1(24.71,7.27) 24.71,7.92 v1(24.96,8.17) 24.08,9.06 24.08,10.63 v1(24.66,11.21) 22.91,12.96 22.91,29.41 v1(24,30.5)
  BOTTOM w0.102: D5104.1 30.31,2.03 30.51,2.22 30.51,3.72 31.32,4.53 31.32,6.39 v1(31.14,6.56)
DET1#_SOC: length 87
  L5-SIG w0.102: v6(47.49,66.21) 47.49,64.67 46.1,63.29 46.1,61.31 45,60.21 43.87,60.21 v3(42.93,59.27)
  L6-GND w0.102: v3(42.93,59.27) 42.93,58.97 v4(42.87,58.91)
  L7-SIG w0.102: v1(33.28,8.07) 32.78,8.07 v1(32.21,8.65) 32.61,9.05 33.02,9.05 33.22,9.26 33.22,9.49 31.14,11.57 29.9,11.57 28.17,13.29 28.17,14.5 26.49,16.18 26.49,36.43 23.01,39.91 23.01,50.67 23.34,51 25.36,51 26,50.35 30,50.35 30.63,50.98 30.63,51.44 30.4,51.67 30.4,52.15 30.69,52.44 31.54,52.44 31.82,52.71 32.89,52.71 33.27,52.33 34.27,52.33 35.23,53.3 37.2,53.3 37.83,52.66 38.06,52.66 38.35,52.95 38.35,53.35 39.01,54.01 39.01,55.15 40.16,56.3 41.1,56.3 42.11,57.31 42.11,58.23 42.62,58.74 42.7,58.74 v4(42.87,58.91)
  BOTTOM w0.102: v9(31.81,7.77) 32.21,8.16 v1(32.21,8.65)
DET2#: length 23.2
  L7-SIG w0.102: v1(24,18.5) 24.44,18.07 24.44,12.81 25.43,11.82 v1(25.43,11.21) 25.43,11.01 25.1,10.68 25.1,9.61 v1(24.96,9.47) 25.91,9.47 26.12,9.69 v1(27.86,9.69) 28.07,9.69 v1(28.69,9.07) 28.8,8.95 28.8,8.94 28.92,8.82 28.92,7.8 28.82,7.7 28.82,7.25 29.47,6.6 30.68,6.6 31.22,7.13 31.22,9.57 31.43,9.79 32.53,9.79 v1(32.94,9.37)
DET2#_SOC: length 88.6
  L5-SIG w0.06: 47.95,65.68 47.95,66 47.83,66.12 47.83,66.56 v6(48.03,66.76)
  L5-SIG w0.107: 47.95,65.68 47.95,64.32 46.63,63 46.63,60.37 44.97,58.7 v3(44.41,58.7)
  L6-GND w0.102: v3(44.41,58.7) 44.31,58.8 v4(44.06,58.8)
  L7-SIG w0.102: v1(35.66,9.37) 36.49,9.37 v1(36.63,9.51) 36.58,9.51 36.07,10.02 35.15,10.02 33.78,11.39 31.74,11.39 31.24,11.88 29.87,11.88 28.37,13.38 28.37,14.59 26.7,16.27 26.7,36.53 23.22,40.01 23.22,50.5 23.49,50.78 25.28,50.78 25.91,50.15 30.09,50.15 30.84,50.9 30.84,51.53 30.61,51.76 30.61,52.07 30.77,52.23 31.63,52.23 31.9,52.51 32.81,52.51 33.19,52.13 34.47,52.13 35.44,53.1 37.06,53.1 37.69,52.46 38.15,52.46 38.56,52.87 38.56,53.26 39.22,53.92 39.22,55.07 40.19,56.04 41.13,56.04 42.34,57.24 42.34,58.17 42.71,58.54 43.46,58.54 43.72,58.8 v4(44.06,58.8)
DMIC1_DAT: length 138
  L2-SIG w0.254: v8(82.86,51.19) 82.94,51.19 90.96,59.21 90.96,74.51 90.53,74.94 90.53,79.89 96.01,85.38 96.01,96.07 92.06,100.03 92.06,106.77 95.07,109.79 97.14,109.79 v7(98.14,110.79)
  L3-GND w0.254: v3(82.5,51.14) 82.8,51.14 v8(82.86,51.19)
  L5-SIG w0.254: v3(82.5,51.14) 81.38,51.14 80.87,50.62 76.08,50.62 75.29,51.42 71.7,51.42 70.84,50.56 59.5,50.56 57.64,52.42 57.59,52.42 54.98,52.42 48.94,52.42 46.97,54.39 43.92,54.39 41.78,56.52 37.9,56.52 37.49,56.12 36.06,56.12 v3(35.66,56.52)
  L6-GND w0.254: v3(35.66,56.52) 35.54,56.52 v4(35.28,56.77)
  L7-SIG w0.254: v4(35.28,56.77) 35.06,56.77 34.85,56.98 34.85,57.31 35.21,57.67 35.21,59.13 34.65,59.69 34.65,60.7 34.72,60.77 34.72,63.31 34.44,63.59 33.86,63.59 32.33,65.12 29.85,65.12 28.15,63.42 v1(28.15,62.89)
DMIC1_SCL: length 133.7
  L2-SIG w0.254: v7(96.49,110.79) 96,110.3 94.85,110.3 91.55,106.99 91.55,99.82 95.5,95.86 95.5,85.59 90.02,80.1 90.02,74.73 90.45,74.3 90.45,59.42 v8(82.73,51.7)
  L3-GND w0.254: v3(82.37,51.7) v8(82.73,51.7)
  L5-SIG w0.254: v3(82.37,51.7) 81.22,51.7 80.66,51.13 76.39,51.13 75.59,51.93 71.49,51.93 70.63,51.06 59.71,51.06 57.85,52.93 57.8,52.93 55.19,52.93 49.15,52.93 47.18,54.9 44.13,54.9 41.99,57.03 41.57,57.03 37.69,57.03 37.28,56.63 v3(36.53,56.63)
  L6-GND w0.254: v4(35.92,56.96) 36.25,56.63 v3(36.53,56.63)
  L7-SIG w0.254: v1(30.4,66.34) 30.4,66.32 34.1,66.32 35.22,65.19 35.22,60.56 35.15,60.49 35.15,59.9 35.94,59.12 35.94,58.56 35.76,58.38 35.76,57.11 v4(35.92,56.96)
DOCK_PWR_EN: length 141.2
  L4-SIG w0.109: v3(71.89,74.44) 72.05,74.28 72.12,74.28 74.64,71.76 74.64,70.28 75.95,68.97 76.23,68.97 78.06,67.13 78.06,61.45 77.9,61.3 77.9,59.7 77.9,59.7 77.9,57.59 79.21,56.28 79.43,56.28 80.86,54.85 80.86,53.41 81.09,53.17 81.09,46.57 82.57,45.08 82.57,37.22 84.53,35.27 84.53,32.31 83.47,31.25 83.47,16.69 70.01,3.23 64.65,3.23 63.98,3.89 63.17,3.89 62.58,4.48 62.08,4.48 60.96,3.36 56.95,3.36 56.03,4.28 56.03,4.91 54.36,6.59 53.43,6.59 v3(52.73,7.29)
  L6-GND w0.102: v4(52.73,7.64) v3(52.73,7.29) ; v4(71.12,74.33) 71.23,74.44 v3(71.89,74.44)
  L7-SIG w0.06: 63.81,73.57 63.68,73.44 63.09,73.44 62.88,73.65 60.2,73.65 59.99,73.44 59.82,73.44 59.69,73.57 v6(58.8,73.57)
  L7-SIG w0.084: v1(33.98,13.47) 34.45,13.01 35.5,13.01 39.99,8.52 43.16,8.52 43.64,8.04 52.34,8.04 v4(52.73,7.64) ; v4(71.12,74.33) 71.1,74.33 70.97,74.46 64.69,74.46 63.81,73.57
  BOTTOM w0.31: v9(35.62,13.91) 35.01,14.52 34.39,14.52 33.98,14.11 v1(33.98,13.47)
DOCKIING_DET#: length 3.7
  L7-SIG w0.102: v1(26.9,8.82) 26.9,8.26 v1(27.86,7.3) 28.28,7.3 v1(28.54,7.56)
  BOTTOM w0.102: v9(28.07,6.36) 27.86,6.56 v1(27.86,7.3)
DRAM_RCOMP_0: length 15.8
  L2-SIG w0.381: v8(56.02,75.55) 56.64,75.55 57.41,74.78 64.38,74.78 66.68,72.48 v8(66.68,72.43)
  L3-GND w0.254: v8(56.02,75.55) 55.89,75.42 v3(55.6,75.42)
  L3-GND w0.381: v3(66.68,71.92) v8(66.68,72.43)
  L6-GND w0.254: v3(55.6,75.42) 55.53,75.42 55.45,75.5 v5(55.21,75.5)
  L6-GND w0.381: v3(66.68,71.92) 66.43,72.16 v1(66.43,72.2)
  L7-SIG w0.203: v5(55.21,75.5) 55.1,75.6 54.18,75.6 54,75.78 54,76.11 v6(53.71,76.4)
DRAM_RCOMP_1: length 15.1
  L2-SIG w0.381: v8(53.37,74.84) 54.03,74.18 55.53,74.18 56.08,73.62 62.94,73.62 v8(64.08,72.48)
  L3-GND w0.254: v8(53.37,74.84) 53.37,75.02 53.54,75.19 v3(53.76,75.19) ; v8(64.08,72.48) 64.14,72.53 v3(64.69,72.53)
  L5-SIG w0.06: v6(53.42,76.72) 53.45,76.7 53.47,76.67 53.47,76.41 53.63,76.25 53.63,75.97 53.53,75.87 53.53,75.42 v3(53.76,75.19)
  L6-GND w0.254: v1(64.95,72.85) 64.69,72.59 v3(64.69,72.53)
DRAM_RCOMP_2: length 14.5
  L2-SIG w0.381: v8(65.76,72.5) 63.96,74.3 57,74.3 56.46,74.84 55.04,74.84 54.86,75.02 v8(54.86,75.32)
  L3-GND w0.254: v3(54.33,75.27) 54.36,75.24 54.79,75.24 v8(54.86,75.32)
  L3-GND w0.381: v8(65.76,72.5) 65.91,72.35 v3(65.91,72.11)
  L6-GND w0.254: v6(53.72,75.82) 53.87,75.67 53.93,75.67 v3(54.33,75.27)
  L6-GND w0.381: v1(65.56,72.13) 65.58,72.11 v3(65.91,72.11)
EC_CH_GA_SCL: length 161.4
  L4-SIG w0.109: v3(42.24,8.49) 42.35,8.38 53.91,8.38 56.39,5.9 57.68,5.9 58.6,4.97 58.6,4.46 59.02,4.05 60.52,4.05 61.66,5.19 62.69,5.19 63.41,4.47 63.86,4.47 64.17,4.77 70.37,4.77 82.68,17.08 82.68,31.72 83.75,32.78 83.75,34.48 83.75,34.48 83.75,34.95 83.29,35.41 82.38,35.41 80.25,37.54 80.25,52.19 78.71,53.73 77.34,53.73 76.67,54.4 76.67,56.69 77.01,57.03 77.01,61.51 77.25,61.75 77.25,62.78 75.59,64.44 75.59,67.88 74.78,68.7 v3(74.78,68.99)
  L6-GND w0.102: v3(74.78,68.99) 74.56,68.99 v4(74.43,68.86) ; v4(42.04,8.84) 42.24,8.64 v3(42.24,8.49)
  L7-SIG w0.084: v1(66.37,66.79) 66.38,66.8 66.67,66.8 66.76,66.88 67.3,66.88 67.44,66.74 v1(68.4,66.74) 68.97,66.74 68.99,66.76 69.1,66.76 70.16,67.82 71.34,67.82 71.9,68.39 72.84,68.39 73.05,68.18 74.44,68.18 74.6,68.34 74.6,68.69 v4(74.43,68.86) ; v1(31.41,38.13) 31.14,37.86 29.36,37.86 29.35,37.85 28.94,37.85 27.78,36.69 27.78,19.39 29.27,17.9 31.41,17.9 31.55,18.04 32.76,18.04 v1(32.89,17.92) 33.56,17.24 35.25,17.24 35.85,16.64 v1(35.85,15.19) 35.85,13.56 40.26,9.15 41.98,9.15 42.04,9.09 v4(42.04,8.84)
  BOTTOM w0.31: v1(35.85,15.19) 37.11,13.93 v9(37.41,13.93)
EC_CH_GA_SDA: length 163.9
  L4-SIG w0.109: v3(41.68,8.49) 41.68,8.49 42.15,8.02 53.76,8.02 56.24,5.54 57.52,5.54 58.24,4.82 58.24,4.31 58.87,3.68 60.67,3.68 61.79,4.8 62.56,4.8 63.26,4.1 64.02,4.1 64.33,4.41 70.56,4.41 83.05,16.89 83.05,31.51 84.11,32.57 84.11,34.32 84.11,35.1 82.98,36.23 82.22,36.23 80.62,37.83 80.62,52.34 78.86,54.09 78.56,54.09 78.56,54.09 77.49,54.09 77.04,54.55 77.04,56.52 77.39,56.88 77.39,61.37 77.62,61.6 77.62,62.93 75.96,64.59 75.96,68.03 75.18,68.8 75.18,69.15 74.79,69.54 v3(74.74,69.54)
  L6-GND w0.102: v4(41.39,8.79) 41.68,8.5 v3(41.68,8.49) ; v3(74.74,69.54) 74.74,69.54 74.64,69.54 v4(74.43,69.32)
  L7-SIG w0.084: v1(29.21,38.19) 28.8,38.19 27.44,36.83 27.44,19.53 27.44,19.25 29.13,17.56 31.55,17.56 31.69,17.7 32.2,17.7 v1(32.46,17.44) 32.87,17.44 33.41,16.9 35.1,16.9 35.51,16.49 35.51,13.36 40.08,8.79 v4(41.39,8.79) ; v4(74.43,69.32) 74.26,69.32 73.66,68.72 71.76,68.72 71.2,68.16 70.02,68.16 69.38,67.52 69,67.14 v1(68.4,67.14) ; v1(67.96,64.74) 68.9,64.74 70.26,66.1 70.26,66.63 70.45,66.82 v1(70.59,66.82)
  BOTTOM w0.229: v1(68.4,67.14) 70.27,67.14
  BOTTOM w0.31: R3037.1 67.85,64.63 v1(67.96,64.74) ; R8876.1 32.18,17.73 v1(32.46,17.44) ; 70.27,67.14 v1(70.59,66.82)
EC_PWRBTN_R: length 6.4
  BOTTOM w0.102: Q3006.5 77.45,76.13 76.38,75.07 75.82,75.07 R3062.1 75.41,74.2 75.01,73.8 73.59,73.8 73.36,73.58 U3001.10
EC_VIBRATOR_PWM: length 77.9
  L4-SIG w0.102: v3(74.88,74.25) 75.16,73.97 75.16,70.05 76.04,69.17 76.31,69.17 78.64,66.85 78.64,61.74 78.13,61.23 78.13,60 78.94,59.19 79.88,59.19 v3(80.34,58.73)
  L6-GND w0.102: v3(80.34,58.73) 80.65,59.04 v4(81.05,59.04) ; v4(74.5,74.25) v3(74.88,74.25)
  L7-SIG w0.102: v1(57,53.68) 58.07,52.61 62.08,52.61 62.31,52.84 62.79,52.84 63.86,51.77 69.32,51.77 69.88,52.33 69.88,55.13 70.21,55.46 80.04,55.46 81.13,56.56 81.13,58.35 81.05,58.43 v4(81.05,59.04) ; v4(74.5,74.25) 74.5,73.62 73.97,73.09 v1(72.96,73.09)
  BOTTOM w0.102: v1(57,53.68) 56.69,53.98 55.3,53.98 55.07,53.76 44.7,53.76 44.17,53.22 44.17,52.87 44.3,52.74 44.3,50.96 43.71,50.38 43.71,47.63 43.63,47.55 43.17,47.55 42.6,46.97 41.4,46.97 40.84,46.42 R7007.2
EDP_CSCL: length 150
  L4-SIG w0.109: v3(57.66,7.68) 58.07,7.27 59.31,7.27 61.47,9.43 70.07,9.43 75.11,14.47 75.72,14.47 76.3,13.88 78.35,13.88 80.15,15.69 80.15,16.84 79.76,17.22 v3(79.76,17.54)
  L5-SIG w0.109: v3(79.76,17.54) 78.7,16.47 72.57,16.47 v3(72.47,16.36) ; v3(18.52,8.67) 19,8.19 19,6.63 19,6.63 19,5.99 19,5.99 19,5.9 22.94,1.96 33.75,1.96 38.66,6.87 38.66,8.59 39.81,9.75 52.6,9.75 55.09,7.25 57.23,7.25 v3(57.66,7.68)
  L6-GND w0.102: v1(79.76,18.04) v3(79.76,17.54) ; v1(73.07,16.36) v3(72.47,16.36) ; v4(18.37,9.03) 18.37,8.82 v3(18.52,8.67)
  L7-SIG w0.084: v1(10.98,60.88) 11.56,60.29 16.7,60.29 18.37,58.62 v4(18.37,9.03) ; v1(79.17,19.14) 79.17,18.64 v1(79.76,18.04)
  BOTTOM w0.31: v9(79.4,21.7) 80.05,21.05 80.05,19.11 79.76,18.82 v1(79.76,18.04)
EDP_CSDA: length 148.2
  L4-SIG w0.109: v3(78.69,15.3) 78.69,15.05 77.89,14.25 76.45,14.25 75.87,14.83 74.96,14.83 69.92,9.79 61.32,9.79 59.18,7.66 v3(58.24,7.66)
  L5-SIG w0.109: v3(72.49,17.03) 72.01,16.55 72.01,16.19 72.34,15.86 72.8,15.86 73,16.06 77.94,16.06 v3(78.69,15.3) ; v3(58.24,7.66) 57.46,6.87 54.86,6.87 52.35,9.38 40.03,9.38 39.6,8.95 39.6,7.2 34,1.6 22.79,1.6 18.64,5.75 18.64,5.84 18.64,5.84 18.64,6.78 18.64,6.78 18.64,7.76 v3(18.57,7.83)
  L6-GND w0.102: v3(78.69,15.3) 78.69,15.43 v1(78.46,15.66) ; v3(72.49,17.03) 72.66,16.86 v1(73.07,16.86) ; v4(18.34,8.14) 18.57,7.91 v3(18.57,7.83)
  L7-SIG w0.084: v4(18.34,8.14) 18.03,8.44 18.03,58.48 16.56,59.95 11.04,59.95 v1(10.99,59.9) ; v1(79.32,20.28) 78.79,19.75 78.79,15.98 v1(78.46,15.66)
  BOTTOM w0.31: v9(77.59,20.67) 77.72,20.8 78.8,20.8 v1(79.32,20.28)
EDP_GPIO: length 147
  L4-SIG w0.102: v3(57.05,7.66) 57.79,6.91 59.48,6.91 61.63,9.07 70.21,9.07 75.26,14.11 75.57,14.11 76.15,13.52 78.49,13.52 80.65,15.68 80.65,17 v3(80.39,17.26)
  L5-SIG w0.102: v3(19.05,10.04) 19.36,9.73 19.36,6.48 19.36,6.48 19.36,6.14 19.36,6.14 19.36,6.1 23.14,2.32 33.45,2.32 38.28,7.15 38.28,8.77 39.62,10.12 52.81,10.12 55.27,7.66 v3(57.05,7.66)
  L6-GND w0.102: v3(19.05,10.04) v4(18.72,10.37) ; v1(80.06,17.1) 80.21,17.26 v3(80.39,17.26)
  L7-SIG w0.102: v1(12.88,60.82) 13.06,60.64 16.85,60.64 18.72,58.76 v4(18.72,10.37)
  BOTTOM w0.102: U7107.17 73.72,18.36 74.12,18.75 76.28,18.75 76.45,18.93 76.45,19.36 76.68,19.59 77.57,19.59 77.78,19.39 77.78,17.59 78.26,17.1 v1(80.06,17.1) ; U7112.7 11.91,62.29 12.88,61.32 v1(12.88,60.82)
