# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+V3P3A: length 440.6
  L2-SIG w0.203: v2(81.71,95.56) 81.71,105 82.18,105.47 v2(82.2,105.47)
  L2-SIG w0.381: v2(83.8,89.85) 81.19,92.45 81.19,94.2 81.71,94.72 v2(81.71,95.56)
  L2-SIG w1.016: 1.78,72.06 1.78,62.34 4.14,59.98 16.48,59.98 18.65,57.81 18.65,5.66 19.62,4.69 21.63,4.69 22.55,5.6 ; 1.78,73.24 1.78,87.58
  L3-GND w0.203: v3(2.03,71.61) 1.81,71.84 v8(1.81,72.09)
  L4-SIG w0.203: v3(80.24,70.77) 80.32,70.7 86.16,70.7 v3(86.54,71.08)
  L4-SIG w0.254: v3(24.31,6.77) 23.93,6.39 v2(22.71,6.39)
  L4-SIG w0.508: v3(42.98,38.19) 46.58,34.58 46.58,28.86 51.35,24.09 54.66,24.09 55.25,23.5 ; v3(58.6,39.76) 58.47,39.63 57.46,39.63 55.78,37.96 55.4,37.96 v3(54.81,37.37)
  L5-SIG w0.203: v3(24.31,6.77) 27.48,9.94 29.02,9.94 30.96,11.89 30.96,16.7 30.61,17.05 30.61,17.79 29.59,18.81 29.59,22.36 29.03,22.92 29.03,23.99 29.15,24.11 v3(29.15,24.19) ; v3(58.6,39.76) 59.06,39.3 59.06,38.46 58.62,38.03 58.62,37.21 v6(58.35,36.94) ; v2(82.2,105.47) 81.29,106.37 74.69,106.37 v3(74.09,106.97)
  L5-SIG w0.381: v2(83.8,89.85) 82.31,88.35 82.31,73.19 80.24,71.13 v3(80.24,70.77)
  L5-SIG w0.508: v3(42.98,38.19) 46.28,38.19 47.09,37.37 v3(54.81,37.37)
  L5-SIG w1.016: 22.53,5.51 22.53,4.45 23.75,3.24 33.25,3.24 37.59,7.58 37.59,9.51 39.14,11.06 41.07,11.06 47.66,17.65 53.68,17.65 55.32,19.29 55.32,22.39 55.3,22.41
  L6-GND w0.152: v3(54.81,37.37) 54.81,37.3 55.61,36.5 55.95,36.5 56.24,36.21 56.63,36.21 56.71,36.14 v6(56.72,36.14)
  L6-GND w0.203: v1(2.59,71.61) v3(2.03,71.61) ; v3(24.31,6.77) 24.49,6.59 v1(24.64,6.59) ; v3(80.24,70.77) 80.24,70.6 v1(80.01,70.37) ; v3(74.09,106.97) 74.05,106.93 v4(73.71,106.93) ; v4(86.54,70.7) v3(86.54,71.08) ; v3(29.15,24.19) v1(29.15,23.83)
  L7-SIG w0.203: v1(1.47,89.01) 1.85,89.39 2.07,89.39 2.26,89.59 2.26,89.76 14.98,102.47 v1(23.42,102.47) 24.74,102.47 25.72,103.45 25.72,104.53 27.83,106.64 73.43,106.64 v4(73.71,106.93) ; v1(90.65,66.59) 90.91,66.85 90.91,68.92 89.13,70.7 v4(86.54,70.7) ; v1(31.19,51.17) 31.19,51.53 30.89,51.84 v1(30.89,51.95) 31.78,51.95 32.06,52.23 v1(32.26,52.23) 32.67,52.23 33.02,51.88 34.75,51.88 35.1,52.23 36.53,52.23 36.9,51.86 36.9,50.4 37.72,49.58 37.72,49.55 38.18,49.08 42.65,49.08 44.08,47.66 44.66,47.66 44.99,47.33 45.59,47.33 45.87,47.05 45.87,46.87 45.54,46.54 v1(45.54,46.11) v1(45.54,45.02) 45.13,45.43 44.51,45.43 43.64,44.55 43.64,42.01 v1(43.19,41.56) v1(42.46,41.56) 42.04,41.56 41.46,40.99 v1(41.46,40.56)
  L7-SIG w0.381: v1(84.58,89.16) 84.46,89.16 83.8,89.83 v2(83.8,89.85) ; v1(74.78,95.72) 77.62,95.72 78.22,96.32 80.95,96.32 v2(81.71,95.56)
  BOTTOM w0.203: R7004.1 34.08,46.84 32.32,46.84 31.78,47.38 31.78,49.06 32.87,50.15 32.87,50.94 32.64,51.17 v1(31.19,51.17) ; v1(41.46,40.56) 41.46,39.67 41.07,39.28 41.07,37.93 41.4,37.6 ; R2722.2 80.14,70.24 v1(80.01,70.37) ; CON3800.50 85.12,89.07 85.12,89.06 C3801.1 84.58,89.14 v1(84.58,89.16) ; T8312.1 27.05,78.69 26.98,78.62 T8314.1 26.19,83.74 22.76,87.17 22.76,95.67 24.07,96.98 24.07,99.98 23.42,100.63 v1(23.42,102.47) ; R2683.2 89.8,65.53 89.8,65.74 v1(90.65,66.59)
  BOTTOM w0.381: v1(74.78,95.72) 75.22,95.72 75.54,96.04 U2101.1
  vias: v1(1.42,87.49) v1(1.42,87.16) v1(1.75,87.49) v1(1.75,87.16) v1(41.58,37.86) v1(42.11,37.86) v1(55.7,22.19) v1(55.7,21.91) v1(56.01,22.19) v1(56.01,21.91) v1(56.31,22.2) v1(56.31,21.92) v2(22.02,6.39) v3(1.47,87.92) v3(2.01,87.92) v3(55.14,22.97) v3(55.73,23) v3(56.29,23) v4(1.42,87.49) v4(1.42,87.16) v4(1.75,87.49) v4(1.75,87.16) v4(41.58,37.86) v4(42.11,37.86) v4(55.7,22.19) v4(55.7,21.91) v4(56.01,22.19) v4(56.01,21.91) v4(56.31,22.2) v4(56.31,21.92) v8(1.52,88.66) v8(1.52,88.33) v8(1.85,88.66) v8(1.85,88.33)
+V3P3A_FB: length 13.2
  L6-GND w0.06: 57.28,31.23 57.71,31.66 57.71,33.13 v6(57.92,33.34)
  L6-GND w0.102: v4(56.31,26.27) 56.31,27.04 57,27.72 57,28.61 57.48,29.09 57.48,30.77 57.28,30.97 57.28,31.23
  L7-SIG w0.102: v1(57.04,21.28) 56.59,21.73 56.59,25.99 v4(56.31,26.27)
+V3P3A_G3: length 47.1
  L4-SIG w0.203: v3(65.15,66.89) 66.27,65.77 66.27,64.58 66.6,64.25 66.6,63.32 67.52,62.39 v3(67.59,62.39)
  L5-SIG w0.203: v6(58.29,68.47) 58.41,68.36 58.41,67.18 58.52,67.06 58.52,66.63 61.26,63.89 61.67,63.89 62.54,63.02 62.89,63.02 63.12,63.25 64.23,63.25 64.68,62.81 65.96,62.81 65.96,62.81 67.18,62.81 v3(67.59,62.39)
  L6-GND w0.203: v3(65.15,66.89) 64.85,66.89 v6(64.78,66.82)
  L7-SIG w0.254: v6(64.78,66.82) 65.18,66.82 65.57,67.22 66.47,67.22 66.55,67.3 67.8,67.3 68.02,67.52 68.7,67.52 69,67.52 69.91,68.43 71.09,68.43 72.64,69.99 74.14,69.99 75.43,71.27 75.43,71.84 75.86,72.27 76.9,72.27 78.22,73.59 78.22,74.88 v1(78.4,75.06)
  BOTTOM w0.254: v1(78.4,75.06) 80.3,75.06 80.58,74.77 80.89,74.77 81.2,74.46 81.2,68.74 80.71,68.25 R2722.1
+V3P3A_LX1: length 1.8
  BOTTOM w0.178: U8201.H14 U8201.G15 58.32,31.94
  BOTTOM w0.254: 58.32,31.94 58.32,30.95
+V3P3A_PMIC: length 0.6
  BOTTOM w0.178: U8201.F15 U8201.G14
+V3P3S: length 408.5
  L2-SIG w0.254: v8(33.48,58.4) 33.27,58.2 33.27,54.45 34.01,53.71 34.01,48.68 ; v8(51.49,7.45) 51.49,18.32 51.92,18.75 51.92,19.85
  L2-SIG w0.762: 90.02,108.82 89.59,108.39 89.59,96.53 90.32,95.79 90.32,82.81 88.09,80.58 88.09,63.14 87.59,62.64 ; 37.75,42.58 37.75,30.81 41.28,27.27 43.36,27.27 44.3,28.2 47.66,28.2 51.64,24.22 51.64,20.71 ; v8(40.75,101.83) 40.45,101.54 40.45,100.54 35.36,95.44 35.36,88.83 31.47,84.95 31.47,78.25 34.39,75.33 34.39,65.21 34.29,65.1 34.29,61.68 32.51,59.9 32.51,53.86 33.3,53.07 33.3,48.81 ; v11(74.46,10.05) 71.68,12.84 59.95,12.84 52.6,20.18 52.16,20.18
  L3-GND w0.254: v8(51.49,7.45) v3(51.49,6.94) ; v8(33.48,58.4) 34.32,58.4 v3(34.46,58.27) ; v3(40.23,101.99) 40.6,101.99 v8(40.75,101.83)
  L4-SIG w0.254: v3(73.15,23.58) 71.17,21.6 v3(66.07,21.6) ; v3(30.83,7.3) 33.55,4.58 48.08,4.58 50.45,6.94 v3(51.49,6.94)
  L4-SIG w0.762: 88.04,62.16 89.62,60.58 89.62,54.16 88.42,52.96 88.42,35.47 88.85,35.04 88.85,32 87.55,30.71 87.55,25.34 86,23.78 86,18.16 86.74,17.41 86.74,16.8 86,16.05 86,13 v2(86.64,12.35) 85.57,11.29 v11(85.57,10.04) 85.57,7.43 v2(83.16,5.02)
  L5-SIG w0.254: v3(66.07,21.6) 65.84,21.83 64.07,21.83 62.76,20.52 62.76,17.84 v2(61.37,16.44) 61.24,16.32 61.24,12.33 v3(63.17,10.4) ; v3(30.83,7.3) 30.83,7.12 v2(29.34,5.62) 29.19,5.78 26.85,5.78 v3(26.11,6.51)
  L5-SIG w0.762: 49.04,105.49 43.73,105.49 v3(40.23,101.99) 40.16,101.91 40.16,101.36 40.01,101.21 v3(40.01,100.41) ; v11(74.46,10.05) 78.04,10.05 79.38,8.71 83.49,8.71 84.82,10.04 v11(85.57,10.04)
  L6-GND w0.254: v3(26.11,6.51) 26.04,6.59 v1(25.38,6.59) ; v3(37.95,42.88) 37.87,42.81 v1(37.87,42.33) ; v1(65.69,21.73) 65.94,21.73 v3(66.07,21.6) ; v3(30.83,7.3) 31.5,7.96 v1(31.5,8.7) ; v1(34.16,58.48) 34.37,58.26 34.46,58.26 v3(34.46,58.27) ; v1(64.24,8.93) 63.42,9.74 63.42,10.14 v3(63.17,10.4) ; v3(73.15,23.58) 73.03,23.71 v1(72.61,23.71)
  L7-SIG w0.254: v1(52.65,19.14) 54.58,19.14 56.67,17.04 56.67,16.71 57.16,16.21 59.46,16.21 59.48,16.23 59.48,16.24 59.69,16.44 60.58,16.44 60.6,16.42 61.34,16.42 v2(61.37,16.44) ; v2(29.34,5.62) 29.34,4.45 29.46,4.33 v1(29.52,4.33) ; v1(65.75,24.17) 65.38,23.79 65.38,22.55 v1(64.97,22.13) ; v2(86.64,12.35) 86.61,12.38 v1(86.61,13.63) v1(87.37,13.63) v1(88.13,13.63) ; v1(80.01,9.53) 80,9.53 79.13,8.67 77.5,8.67 77.33,8.5 69.29,8.5 68.03,9.76 67.11,9.76 65.96,8.62 64.54,8.62 v1(64.24,8.93) ; v1(80.75,9.56) 81.61,9.56 81.84,9.33 83.41,9.33 84.12,10.04 v11(85.57,10.04)
  BOTTOM w0.254: v1(65.69,21.73) 65.28,22.13 v1(64.97,22.13) 64.72,22.13 64.49,22.36 64.49,23.42 63.86,24.05 R7183.1 ; R2723.1 42.22,66.86 42.05,66.69 40.72,66.69 40.53,66.51 40.53,66.14 40.35,65.95 39.97,65.95 39.41,65.39 38.76,65.39 38.49,65.12 38.49,63.24 37.95,62.7 37.95,59.51 36.44,58 34.64,58 v1(34.16,58.48) 33.65,57.97 31.45,57.97 30.13,59.29 R1017.1
  BOTTOM w0.305: R0755.1 85.93,63.12 85.93,63.09 Q0703.2
  BOTTOM w0.457: U2301.5 84.45,3.75 83.95,4.25 C2301.2 83.16,4.68 v2(83.16,5.02)
  BOTTOM w0.508: 84.66,8.26 84.66,9.13 v11(85.57,10.04) 85.83,9.79 86.86,9.79 88.05,8.59
  vias: v1(33.32,47.4) v1(37.17,47.08) v1(37.36,46.81) v1(37.36,46.44) v1(40.44,99.45) v1(51.84,19.14) v1(52.15,19.14) v1(87.3,62.93) v1(87.61,62.93) v1(87.88,62.93) v1(88.16,62.93) v2(89.92,109.69) v2(90.53,109.69) v3(32.6,48.21) v3(33.32,47.79) v3(36.65,46.35) v3(37.07,45.96) v3(50.29,105.5) v3(51.41,105.5) v3(51.69,19.52) v3(52.2,19.52) v3(87.53,62.52) v3(88.04,62.54) v4(32.3,47.39) v4(32.32,47.75) v4(32.67,47.74) v4(32.62,47.38) v4(33,47.4) v4(33.32,47.4) v4(37.17,47.08) v4(37.36,46.81) v4(37.36,46.44) v4(40.44,99.45) v4(51.84,19.14) v4(52.15,19.14) v4(87.3,62.93) v4(87.61,62.93) v4(87.88,62.93) v4(88.16,62.93) v7(50.17,106.94) v7(50.17,106.61) v7(51.69,107.02) v7(51.69,106.64) v8(33.32,48.19) v8(33.67,48.18) v8(33.72,47.83) v8(34.01,48.18) v8(34.04,47.82) v8(34.35,47.82) v8(35.55,46.89) v8(35.55,46.56) v8(35.91,46.92) v8(35.94,46.57) v8(36.3,46.93) v8(36.35,46.57) v8(37.1,43.11) v8(37.15,42.76) v8(37.29,43.37) v8(37.64,43.37) v8(37.99,43.34) v8(50.7,105.85) v8(50.7,105.55) v8(51.03,105.85) v8(51.03,105.55) v8(51.51,20.41) v8(51.51,20.08) v8(51.89,20.41) v8(51.89,20.08) v8(87.4,61.88) v8(87.68,61.88) v8(87.99,61.88) v8(88.32,61.88)
+V3P3S_AUD: length 4.4
  BOTTOM w0.178: U1001.3 28.95,62.41
  BOTTOM w0.254: R1017.2 C1052.1 C1025.1 C1026.1 28.57,62.03 28.95,62.41
+V3P3S_EDP: length 7
  BOTTOM w0.254: R7160.1 70.45,24.42 R7161.1 70.09,24.77 70,24.77 69.79,24.98 69.79,25.24 69.62,25.41 69.08,25.41 68.92,25.56 68.92,26.36 Q7111.3 67.39,28.64 67.7,28.95 C7126.1
+V3P3S_EN#: length 43.2
  L4-SIG w0.102: v3(59.26,24.9) 59.64,24.52 59.64,23.5 59.42,23.28 58.93,23.28 57.66,24.55 51.47,24.55 47.02,29 47.02,34.78 42.52,39.28 v3(42.52,42.81)
  L6-GND w0.06: 59.56,31.23 59.56,31.59 58.87,32.28 58.87,33.18 U8201.H12 v6(58.72,33.36)
  L6-GND w0.102: v4(58.62,25.82) 58.62,25.54 v3(59.26,24.9) ; v3(42.52,42.81) 42.46,42.75 v1(42.46,42.43) ; v4(58.57,26.27) 59,26.71 59,29.55 59.56,30.11 59.56,31.23
  L7-SIG w0.102: v4(58.57,26.27) 58.57,25.87 v4(58.62,25.82) ; v1(41.46,42.46) 42.43,42.46 v1(42.46,42.43)
+V3P3S_SD: length 15.9
  L7-SIG w0.508: 85.35,67.86 85.35,75.66 85.67,75.98
  L7-SIG w0.762: 87.25,67.62 89.1,67.62 90.03,66.69 90.03,63.27 89.54,62.77 89.21,62.77
  vias: v1(86.21,75.96) v1(86.46,75.96) v1(86.49,67.37) v1(87.15,67.37) v1(88.9,62.42) v1(88.9,62.11) v1(89.21,62.42) v1(89.21,62.11) v9(85.62,67.29)
+V3P3S_SENSE: length 43.5
  L4-SIG w0.254: v3(58.04,22.67) 57.89,22.51 54.76,22.51 54.65,22.63 54.65,22.63 53.82,23.45 50.22,23.45 48.69,24.98 46.93,24.98 40.67,31.24 40.67,38.26 38.48,40.45 v3(38.48,40.55)
  L6-GND w0.152: v4(58.09,23.1) 58.09,22.72 v3(58.04,22.67) ; v4(57.66,26.27) 57.66,26.78 58.09,27.21 58.09,28.31 58.52,28.74 58.52,30.57 58.62,30.67 58.62,31.58 58.42,31.79 58.42,32.75 58.33,32.84 v6(58.33,32.94)
  L6-GND w0.254: v1(37.47,40.52) 38.46,40.52 v3(38.48,40.55)
  L7-SIG w0.152: v4(57.66,26.27) 57.51,26.12 57.51,23.53 57.94,23.1 v4(58.09,23.1)
+V3P3S_SENSOR: length 23.2
  L7-SIG w0.254: v1(72.1,115.37) 76.13,111.34 v1(87.83,111.34)
  BOTTOM w0.102: C5819.1 71.31,113.75 v9(71.27,113.71) ; C5819.1 70.59,114.63 68.62,116.61 U5804.A1 ; C5819.1 71.68,115 71.81,115 R5822.1
  vias: v2(91.82,116.14) v2(91.82,115.53)
+V3P3S_USBSW: length 15.6
  L5-SIG w0.254: v3(26.11,7.27) 26.69,7.27 27,6.97 v3(29.29,6.97) 29.54,7.22 29.54,8.29 v3(29.31,8.52)
  L6-GND w0.254: v3(29.31,8.52) 29.31,9.11 v1(29.29,9.14) ; v3(29.29,6.97) 29.4,7.08 v4(29.67,7.08) ; v1(25.58,7.27) v3(26.11,7.27)
  L7-SIG w0.254: v1(30.71,9.46) v1(30.71,8.7) 30.71,7.31 30.48,7.08 v4(29.67,7.08) ; v1(27.86,8.16) v1(27.86,8.82) 27.36,9.33 26.29,9.33 25.58,8.62 v1(25.58,7.27)
  BOTTOM w0.102: v1(25.58,7.27) 26.29,7.27 v9(26.44,7.12)
+V3P3S_VIB: length 41.4
  L7-SIG w0.254: v1(17.35,58.76) 16.81,59.29 7.66,59.29 v1(7.54,59.41)
  L7-SIG w0.457: v2(21.79,51.9) 25.83,51.9 26.37,51.37 29.77,51.37 30,51.14 v1(30.25,51.14)
  BOTTOM w0.254: CON2002.16 3.6,67.85 3.1,67.35 3.1,60.35 4.04,59.41 v1(7.54,59.41) ; v2(21.79,51.9) 21.76,51.9 20.78,52.88 20.78,56.11 20.13,56.76 18.94,56.76 18.25,57.46 18.25,57.86 v1(17.35,58.76)
+V3P3SX: length 104.9
  L2-SIG w0.508: 34.9,52.08 34.9,44.18 35.25,43.83 35.25,43.28 36.88,41.64 36.88,30.34 40.92,26.3 40.92,23.81 44.32,20.41 44.32,20.23 ; 33.88,56.83 33.88,54.52 34.77,53.63 34.77,52.66
  L5-SIG w0.508: v3(55.32,53.57) 53.07,53.57 49.64,53.57 47.06,56.14 43.78,56.14 42.26,57.67 41.31,57.67 37.42,57.67 37.1,57.35 35.04,57.35 v3(34.67,57.72)
  L6-GND w0.508: v3(55.32,53.57) v4(55.82,53.57)
  L7-SIG w0.254: v1(59.2,59.39) 59.27,59.32 59.27,58.67 58.79,58.19 58.79,54.9 58.03,54.14 56.39,54.14 v4(55.82,53.57)
  L7-SIG w0.508: 65.2,9.51 64.87,9.84 63.73,9.84 63.05,9.15 60.73,9.15 60.25,9.64 53.44,9.64 51.74,11.34 51.74,13.42 50.83,14.34 50.83,16.04 47.75,19.11 47.11,19.11 46.42,19.8 v4(45.91,19.8) v4(45.42,19.8)
  BOTTOM w0.254: T8417.1 62.15,8.26 62.15,10.04 62.33,10.22 64.8,10.22 65.22,9.8 65.75,9.8
  vias: v1(35.55,52.82) v1(35.76,52.66) v1(65.51,9.51) v1(65.86,9.51) v3(34.85,52.74) v3(45.03,19.82) v4(35.55,52.82) v4(35.76,52.66) v8(33.88,58) v8(33.88,57.62) v8(34.57,52.28) v8(34.85,52.28) v8(44.53,20.02) v8(44.53,19.67)
+V3P3SX_G3: length 1.8
  L7-SIG w0.254: v1(60.45,61.07) 60.41,61.03 60.41,59.57 60.54,59.43 v1(60.54,59.32)
+V3P3U_EN#: length 9.7
  L3-GND w0.102: v8(55.96,25.74) v3(56.24,25.46)
  L5-SIG w0.06: 56.92,31.23 57.93,32.24 v6(57.93,33.74)
  L5-SIG w0.102: 56.92,31.23 56.54,30.85 56.54,29.34 56.91,28.97 56.91,26.14 v3(56.24,25.46)
+V5P0S: length 68.9
  L4-SIG w0.762: v2(42.77,17.54) 40.59,19.72 39.12,19.72 36.7,22.14 36.7,29.17 34.32,31.55 34.32,36.93 35.18,37.79 35.18,38.69 30.48,43.39 30.48,51.77 30,52.26
  L7-SIG w0.254: v1(49.36,15.07) 48.2,15.07 48.12,15.15 44.4,15.15 v1(43.71,14.46) 43.71,13.58 45.21,12.07 45.21,9.26 45.37,9.1 46.02,9.1 v1(46.45,9.53)
  L7-SIG w0.762: 49.15,16.44 47.3,18.3 44.86,18.3 44.78,18.38 43.33,18.38 42.77,17.82 v2(42.77,17.54)
  L7-SIG w1.016: 31.37,54.91 31.37,56.48 31.78,56.89 31.78,57.62 32.54,58.38
  BOTTOM w0.127: T8205.1 41.54,13.91 43.15,13.91 v1(43.71,14.46)
  vias: v1(32,59.29) v1(32.32,59.3) v1(32.61,59.29) v1(49.25,16.27) v1(49.25,15.96) v1(49.56,16.27) v3(29.67,52.97) v3(30.2,52.94) v4(29.46,53.58) v4(29.82,53.58) v4(30.18,53.58) v4(49.25,16.27) v4(49.25,15.96) v4(49.56,16.27)
+V5P0S_AUD: length 9.6
  L7-SIG w0.254: v1(32.32,60.64) 32.99,61.31 32.99,63.14 32.14,63.98 v2(31.77,63.98)
  BOTTOM w0.178: 29.35,62.38 U1001.2
  BOTTOM w0.254: 29.35,62.38 29.35,61.83 30.08,61.1 30.41,61.1 30.74,61.43 C1029.1 31.15,61.06 31.17,61.04 C1030.1 v1(32.32,60.64)
+V5P0S_EN#: length 6
  L7-SIG w0.102: v1(51.46,22.15) 51.96,21.64 51.96,20.72 51.26,20.02 v1(50.46,20.02) v1(50.46,19.26) 50.46,18.71 50.93,18.24 v1(51.51,18.24)
+V5P0S_FB: length 12.8
  L6-GND w0.06: v6(60.27,33.34) 60.32,33.29 60.32,33.23 60.52,33.03 60.52,32.79 62,31.31 62,31.23
  L6-GND w0.102: 62,31.23 62.87,30.36 62.87,26.63 v4(63.63,25.87)
  L7-SIG w0.102: v1(62.36,22.49) 62.31,22.54 62.31,24.11 63.63,25.44 v4(63.63,25.87)
+V5P0S_LX:
  vias: v9(65.01,30.28)
+V5P0S_O: length 30.3
  L4-SIG w0.254: v3(63.91,20.74) 63.91,22.23 64.26,22.59 69.76,22.59 70.82,23.65 70.82,24.98 71.93,26.1 v3(73.48,26.1)
  L4-SIG w0.508: v2(49.58,18.55) 60.39,18.55 61.19,19.35 61.19,19.86 62.01,20.69 63.86,20.69 v3(63.91,20.74)
  L6-GND w0.254: v3(73.48,26.1) 73.36,25.97 v1(72.82,25.97) ; v4(63.35,20.66) 63.55,20.66 63.63,20.74 v3(63.91,20.74)
  vias: v1(59.15,22.26) v1(59.15,21.73) v1(59.29,21.98) v4(59.15,22.26) v4(59.15,21.73) v4(59.29,21.98)
+V5P0S_SUS: length 78.3
  L4-SIG w0.254: v2(21.58,54.55) 21.58,58.27 16.38,63.46 13.49,63.46 v2(13.28,63.66)
  L5-SIG w0.254: v2(72.55,49.64) 59.12,49.64 57.26,51.51 54.6,51.51 54.6,51.51 53.92,51.51 53.92,51.51 48.56,51.51 46.59,53.48 43.31,53.48 42.7,54.09 39.57,54.09 38.74,53.25 38.52,53.25 38.5,53.25 38.49,53.25 33.57,53.25 33.39,53.43 33.39,53.43 33.13,53.69 22.76,53.69 21.9,54.55 v2(21.58,54.55)
  BOTTOM w0.254: v2(13.28,63.66) 12.83,64.12 9.91,64.12 9.45,63.66 9.45,63.2 9.09,62.84 7.99,62.84 7.5,62.35 CON2002.5
  vias: v9(73.65,49.04)
+V5S: length 15.5
  L7-SIG w0.254: v1(49.98,13.55) 49.98,14.95 49.41,15.53 48.69,15.53 47.88,16.34 v1(47.61,16.34) ; v1(49.98,13.55) v1(49.22,13.55) 47.97,14.8 45.67,14.8 45.31,14.44 45.31,13.47 v1(45.41,13.37) 45.41,12.56 45.69,12.28 v1(45.69,9.53) ; v1(49.98,13.55) v1(50.74,13.55)
+VBATTBKUP: length 91.3
  L2-SIG w0.254: v8(81.7,65.69) 81.7,64.71 79.76,62.77 79.76,59.53 81.6,57.69 81.6,53.3 80.95,52.65 80.95,48.81 84.61,45.16 v8(84.61,40.37) ; v8(75.06,45.33) 70.18,50.21 v8(53.59,50.21)
  L3-GND w0.254: v3(75.29,45.06) 75.29,45.1 v8(75.06,45.33) ; v3(53.59,50.63) v8(53.59,50.21) ; v8(81.7,65.69) 81.53,65.85 v3(81.53,66.13) ; v8(84.61,40.37) v3(84.96,40.37)
  L5-SIG w0.203: v6(57.52,36.94) 57.52,37.21 57.16,37.57 57.16,39.13 56.75,39.54 56.75,41.66 56.74,41.66 56.74,46.23 v3(56.7,46.27)
  L5-SIG w0.254: v3(84.96,40.37) 80.97,40.37 79.85,41.49 75.85,41.49 75.14,42.19 75.14,44.91 v3(75.29,45.06)
  L6-GND w0.203: v4(56.21,46.41) 56.56,46.41 v3(56.7,46.27) ; v4(53.59,50.25) 53.58,50.25 53.58,50.62 v3(53.59,50.63)
  L6-GND w0.254: v4(81.18,66.14) 81.27,66.14 81.27,66.14 81.52,66.14 v3(81.53,66.13)
  L7-SIG w0.203: v4(56.21,46.41) 56.24,46.44 56.24,47.6 53.6,50.25 v4(53.59,50.25)
  L7-SIG w0.254: v4(81.18,66.14) 80.87,66.45 80.87,70.01 79.82,71.07 v1(79.82,71.3)
  BOTTOM w0.254: R2701.1 R2703.1 80.14,72.05 80.14,71.63 v1(79.82,71.3)
+VCC_COMP: length 9.4
  L5-SIG w0.102: v3(64.95,42.53) 64.95,41.39 63.32,39.76 v3(62.84,39.76)
  L6-GND w0.06: v6(60.35,36.94) 60.83,37.42 60.83,37.74 61.03,37.94 61.08,37.94 61.74,38.59
  L6-GND w0.102: 61.74,38.59 62.28,39.14 62.28,39.16 62.84,39.72 v3(62.84,39.76) ; v3(64.95,42.53) 65.02,42.6 v1(65.02,42.96)
  BOTTOM w0.102: v1(65.02,42.96) 65.02,43.47 65.31,43.75 v9(65.31,43.95)
+VCC_GASG: length 10.9
  L7-SIG w0.102: v1(34.44,35.38) 34.77,35.04 34.77,34.3 34.55,34.08 33.49,34.08 v1(33.4,33.99) 32.02,32.61 30.32,32.61 29.92,32.21 29.47,32.21 29.3,32.37 29.3,33.32 29.6,33.61 29.65,33.61 29.86,33.83 29.86,34.4 v1(29.58,34.68)
  BOTTOM w0.102: U8901.D1 33.32,34.08 v1(33.4,33.99)
+VCC_LX0: length 2.8
  BOTTOM w0.508: 59.94,39.13 59.94,41.96
+VCC_LX1: length 4.1
  BOTTOM w0.508: L8201.2 62.17,42.27 61.37,41.46 61.37,38.95 61.32,38.9
  vias: v9(64.18,42.63)
+VCC_LX2: length 3
  BOTTOM w0.508: v9(62.97,39.35) 63.87,39.35 65,40.49 L8203.2
+VCC_LX3: length 5.1
  BOTTOM w0.508: 62.48,36.53 62.76,36.81 62.76,37.4 63,37.63 65.46,37.63 65.92,38.09 L8204.2
  vias: v9(64.86,39.26)
+VCC_LX4: length 3.2
  BOTTOM w0.508: 63.3,35.37 63.31,35.36 65.36,35.36 65.82,35.82 L8205.2
+VDDIO: length 182.6
  L2-SIG w0.254: v2(76.71,12.58) 76.71,11.11 71.12,5.52 55.53,5.52 53.72,7.32 53.34,7.32 v8(52.71,6.69)
  L3-GND w0.254: v8(52.71,6.69) v3(52.27,6.69)
  L4-SIG w0.254: v3(52.27,6.69) 52.27,6.94 51.77,7.45 50.45,7.45 47.96,4.96 34.19,4.96 v3(32.49,6.66) ; v3(74.35,23.71) 74.35,23.61 71.88,21.14 v3(65.53,21.14)
  L4-SIG w0.508: v3(69.01,13.09) 71.23,13.09 74.45,16.32 76.63,16.32 77.12,15.83 v2(77.12,15.61)
  L5-SIG w0.254: v3(11.25,63.69) 11.48,63.69 13.64,61.53 16.1,61.53 19.18,58.46 19.18,44.13 24.64,38.67 24.64,31.63 22.43,29.42 22.43,11.87 23.5,10.8 23.5,6.28 25.73,4.05 29.46,4.05 32.08,6.66 v3(32.49,6.66)
  L6-GND w0.254: v1(10.84,63.56) 11.13,63.56 v3(11.25,63.69) ; v1(64.97,21.27) 65.41,21.27 v3(65.53,21.14) ; v4(74.88,23.71) v3(74.35,23.71)
  L7-SIG w0.254: 66.24,17.38 65.58,18.04 v1(65.2,18.04) ; v2(77.12,15.61) 77.12,17.14 v1(77.21,17.23) v1(77.21,18.12) 77.21,18.75 77.6,19.14 v1(78.3,19.14) 78.3,20.13 v1(78.45,20.28) 78.45,20.48 75.71,23.22 75.37,23.22 v4(74.88,23.71) 74.5,23.33 71.96,23.33 71.45,23.83 v1(70.14,23.83)
  L7-SIG w0.381: 68.15,13.27 68.15,14.57 66.98,15.74 66.98,16.95 66.55,17.38 66.24,17.38 65.91,17.05 65.91,16.5 v1(65.6,16.19)
  BOTTOM w0.254: R7106.2 69.91,24.02 69.91,24.15 69.78,24.28 69.72,24.28 R7161.2 ; v2(76.71,12.58) 76.45,12.58 75.99,13.05 R7116.1 R7115.1 76.68,14.06 v9(76.98,14.35) 77.12,14.49 v2(77.12,15.61)
  BOTTOM w0.279: U7107.42 66.04,17.36 65.76,17.08 65.76,16.35 v1(65.6,16.19) ; v1(67.86,13.14) v1(68.52,13.14) 68.97,13.58 U7107.32
+VDDIOX: length 5.9
  BOTTOM w0.279: U7107.11 71.97,21.41 71.75,21.63 ; 71.75,22.87 72.54,22.08 v9(72.54,21.95) 72.54,21.49 72.47,21.42 U7107.12
  BOTTOM w0.432: 71.75,21.63 C7106.1 R7103.2 71.75,24.34 R7160.2
+VDDQ: length 38.5
  L2-SIG w1.524: 43.31,32.17 43.31,31.96
  L2-SIG w2.159: 44.17,31.43 42.24,33.36 42.24,43.28 42.43,43.47 42.43,48.37 42.18,48.68 42.18,54.58 39.83,56.93
  L5-SIG w0.254: v6(57.12,33.74) 55.83,33.74 v6(55.45,34.12)
  BOTTOM w0.254: R2400.2 54.33,82.05 54.15,82.23 46.38,82.23 45.87,81.72
  vias: v1(48.79,33.72) v1(48.9,34.1) v1(49.15,33.72) v1(49.25,34.1) v1(49.45,33.72) v1(49.61,34.1) v2(44.35,31.66) v2(44.35,30.97) v2(45.01,31.66) v9(43.38,78.47) v11(34.73,81.28) v11(34.74,80.41) v11(35.59,81.28) v11(35.62,80.39)
+VDDQ_FB: length 20.7
  L6-GND w0.152: v6(57.12,33.34) 57.1,33.34 56.49,32.72 55.6,32.72 53.47,30.59 53.47,30.3 53.01,29.85 53.01,28.61 52.5,28.1 52.5,27.8 52.63,27.67 v4(52.86,27.67)
  L7-SIG w0.152: v1(46.53,29.85) 47.04,29.85 50.27,26.63 51.66,26.63 52.71,27.67 v4(52.86,27.67)
  BOTTOM w0.102: v9(42.72,30.81) 43.36,30.17 44.51,30.17 44.85,29.83 JP8205.1
+VDDQ_LPDDR3: length 23
  L2-SIG w0.254: v2(47.22,98.64) 47.14,98.56 47.14,95.06 46.8,94.71 v2(46.8,94.45)
  L5-SIG w0.254: v2(64.49,95.51) 64.49,97.27 v2(65.73,98.51)
  L6-GND w0.076: v1(68.36,97.05) 68.56,97.24 69.54,97.24 ; v1(50.58,96.98) 50.83,96.73 51.84,96.73 ; v1(44.35,89.56) 44.34,89.58 44.34,90.74 v1(44.58,90.98) ; v1(62.21,89.52) 62.1,89.62 62.1,90.35 62.09,90.36 62.09,90.71 v1(62.36,90.98)
  L6-GND w0.102: v2(69.83,97.24) 69.54,97.24 ; v2(52.22,96.72) 52.21,96.73 51.84,96.73
  BOTTOM w0.076: 51.89,94.7 51.89,95.11
  BOTTOM w0.229: U1601.T8 U1601.U7
  BOTTOM w0.254: R1701.1 41.76,101.68 41.76,101.64 C1710.1 41.91,100.52 42.22,100.52 43.59,99.15 44.25,99.15 ; R1703.2 55.35,99.27 ; 58.38,100.45 R1612.1
+VDDQ_LX: length 2.2
  BOTTOM w0.508: 53.67,32.22 53.52,32.06 52.23,32.06 L8215.1
+VDDQ_PMIC: length 1.2
  BOTTOM w0.102: C8256.1 46.63,28.31 v9(46.52,28.21)
+VDDQ_SOC: length 12.6
  L2-SIG w0.203: v8(50.78,75.55) 50.82,75.55 53.46,78.19 v8(53.46,80.26)
  L3-GND w0.203: v3(53.56,79.92) 53.56,80.15 v8(53.46,80.26) ; v3(50.42,75.35) 50.62,75.55 v8(50.78,75.55)
  L6-GND w0.203: v6(50.57,75.01) 50.57,75.2 v3(50.42,75.35) ; v3(53.56,79.92) 53.47,80.01 53.47,80.24 v6(53.46,80.24)
  L7-SIG w0.203: v6(55.31,75.09) 55.12,75.09 54.9,75.31 53.81,75.31 53.62,75.5 50.9,75.5 50.57,75.16 v6(50.57,75.01)
+VDDQ_VTT_FB: length 15.2
  L6-GND w0.06: 55.09,31.58 55.74,32.23 56.41,32.23 v6(56.72,32.54)
  L6-GND w0.102: 55.09,31.58 54,30.49 54,30.09 53.6,29.69 53.6,28.8 52.86,28.05 v4(52.86,28.03)
  L7-SIG w0.102: v4(52.86,28.03) 52.73,28.03 51.56,26.86 50.37,26.86 47.09,30.13 47.09,31.09 v1(46.98,31.2)
+VDDQ_VTT_MEM: length 261.9
  L2-SIG w0.254: v11(52.88,21.83) 52.88,21.68 60.91,13.65 76.71,13.65 v11(77.47,12.89) ; v11(91.29,76.21) 92.43,75.07 92.43,57.69 86.41,51.67 86.41,37.86 85.14,36.59 85.14,15.07 v11(83.62,13.55)
  L2-SIG w0.762: v2(41.05,99.02) 36.53,94.5 36.53,85.14 33.97,82.59 33.61,82.59 33.05,82.02 33.05,78.91 35.15,76.8 36.42,76.8 37.2,76.02 37.2,75.11 36.25,74.16 36.25,55.43 37.9,53.77 37.9,51.01 39.24,49.67 39.25,49.66 39.25,47.56 39.5,47.31 39.5,47.31 39.5,44.69 39.31,44.49 39.31,30.5 v11(41.68,28.13) ; v11(44.43,34.83) 47.93,31.33 52.96,31.33 53.39,30.9 53.39,27.64 53.08,27.33
  L4-SIG w0.762: v3(45.36,101.44) 44.86,101.93 41.75,101.93 41.05,101.23 v2(41.05,99.02)
  L5-SIG w0.254: v11(75.46,101.89) 78.35,99 84.39,99 84.95,98.45 84.95,98.21 90.35,92.81 90.35,77.15 v11(91.29,76.21) ; v11(77.47,12.89) 78.13,13.55 v11(83.62,13.55) ; v11(52.88,21.83) 52.88,22.11 52.59,22.4 52.59,26.1 v3(52.55,26.14)
  L6-GND w0.254: v3(45.36,101.44) 45.73,101.8 v1(45.73,102.04)
  L7-SIG w0.762: 52.05,24.94 52.03,24.92 52.03,23.91 51.24,23.12 48.66,23.12 46.42,25.36 46.42,27 45.84,27.58 44.88,27.58 44.32,27.01 42.62,27.01 42.11,27.52 42.11,27.7 v11(41.68,28.13)
  BOTTOM w0.254: v2(41.05,99.02) 40.84,99.02 C1724.1 C1625.1 C1623.1 C1723.1
  vias: v1(46.41,102.04) v1(47.17,102.05) v3(46.09,101.41) v3(46.83,101.43) v3(51.96,26.15) v4(46.41,102.04) v4(47.17,102.05) v4(51.93,25.66) v4(52.25,25.66) v4(52.57,25.66) v4(52.89,25.66) v8(52.29,26.98) v8(52.3,26.64) v8(52.64,26.98) v8(52.65,26.64) v9(44.87,35.46)
+VDDQ_VTT_PMIC: length 15.8
  L6-GND w0.203: v6(56.72,33.34) 56.36,32.98 55.45,32.98 53.19,30.72 53.19,30.42 52.71,29.94 52.71,28.74
  L6-GND w0.254: 52.71,28.74 51.99,28.03 v4(51.99,27.77)
  L7-SIG w0.254: v4(51.99,27.77) 51.92,27.85 50.32,27.85 48.34,29.83 48.34,31.72 v1(48.13,31.93)
  BOTTOM w0.102: R8301.2 45.55,32.33 v9(45.08,32.33)
AGND_2M: length 12.8
  L7-SIG w0.102: v1(9.55,119.37) 9.55,114.16 11,112.71 14.62,112.71 v1(14.98,112.35) 14.99,112.35 v1(14.99,111.69) v1(15.72,111.69)
AGND_AUD: length 16
  BOTTOM w0.178: U1001.25 25.35,68.75 25.17,68.93 24.92,68.93 24.92,68.94 24.66,68.94 24.4,69.19 v2(24.4,69.44) ; v1(26.55,62.36) U1001.9
  BOTTOM w0.203: 4.99,66.85 4.97,66.85
  BOTTOM w0.254: v2(21.54,69.89) 21.62,69.8 C1028.2 ; v2(20.83,69.86) 20.95,69.98 R1008.2 R1007.2 ; C1027.1 v2(23.39,68.84) ; C1005.2 C1006.2 22.53,70.32 v2(22.15,69.94)
  BOTTOM w0.305: CON2002.15 5.18,67.35 5.69,66.84 ; 5.16,66.66 4.97,66.85 CON2002.14
  BOTTOM w0.432: C1106.2 24.11,59.35 23.72,58.96 v2(22.63,58.96) ; C1002.1 23.52,64.09 23.8,63.82 v2(23.8,63.52) ; C1053.1 20.57,63.26 v2(20.57,63.87) ; v2(21.36,59.88) 21.27,59.97 R1101.2
  BOTTOM w0.457: v2(22.01,62.57) 21.84,62.4 C1007.2
  BOTTOM w0.508: C1040.2 23.95,61.66 v2(24.17,61.45) ; C1008.2 21.93,63.49 v2(22.07,63.64) ; v2(20.65,64.47) 21.05,64.47 21.18,64.6 C1001.2
  vias: v1(24.7,67.14) v1(25.52,61.32) v1(27.71,60.77) v1(27.71,60.03) v1(27.71,59.29) v1(29.23,58.53) v2(13.99,65.36) v2(15.87,65.34) v2(16.76,65.34) v2(17.81,65.34) v2(19.97,61.99) v2(20.09,61.33) v2(20.63,60.94) v2(21.27,67.27) v4(24.7,67.14) v4(25.52,61.32) v4(27.71,60.77) v4(27.71,60.03) v4(27.71,59.29) v4(29.23,58.53)
GND: length 1314.9
  TOP w0.508: 94.71,43.68 CON0901.20 ; CON0901.20 93.35,44.44 ; CON0901.20 94.71,45.2 ; CON0901.20 96.06,44.44 ; J3101.35 49.14,108.67 ; J3101.35 46.24,108.67 ; J3101.35 47.69,110.03 ; J3101.35 47.69,107.31 ; 93.35,36.04 CON0901.21 ; CON0901.21 96.06,36.04 ; CON0901.21 94.71,36.8 ; CON0901.21 94.71,35.28 ; 97.06,61.92 CON5201.7 ; CON5201.7 94.45,61.92 ; CON5201.7 95.76,62.68 ; 97.06,52.02 CON5201.6 ; CON5201.6 95.76,51.26 ; CON5201.6 94.45,52.02 ; 77.44,108.67 J3101.36 ; J3101.36 78.89,107.31 ; J3101.36 80.34,108.67 ; J3101.36 78.89,110.03 ; 98.22,36.04 CON0901.23 ; 98.22,44.44 CON0901.22 ; 98.29,52.02 CON5201.8 ; 98.32,61.92 CON5201.9
  L2-SIG w0.102: v8(72.55,74.27) 70.48,74.27 68.28,72.06 68.28,69.56 74.75,63.08 v8(74.75,62.52)
  L2-SIG w0.254: CON5201.8 98.29,51.26 ; 99.65,92.9 SW2004.5 100.5,92.26 ; 99.65,98.3 SW2004.4 100.5,98.93 ; CON5201.9 98.29,62.68 ; 94.91,40.24 CON0901.10
  L2-SIG w0.508: 98.32,52.02 CON5201.8 ; H7907.1 93.6,34.4 ; H7907.1 95.27,32.74 ; H7907.1 91.94,32.74 ; H7907.1 93.6,31.08 ; CON0901.20 96.04,44.44 ; CON0901.20 94.71,43.7 ; CON0901.20 93.37,44.44 ; CON0901.20 94.71,45.18 ; 98.32,61.92 CON5201.9 ; 98.22,36.04 CON0901.23 ; CON5201.7 94.47,61.92 ; CON5201.7 97.04,61.92 ; CON5201.7 95.76,62.65 ; 94.47,52.02 CON5201.6 ; CON5201.6 95.76,51.28 ; CON5201.6 97.04,52.02 ; CON0901.21 94.71,36.78 ; CON0901.21 94.71,35.3 ; CON0901.21 93.37,36.04 ; CON0901.21 96.04,36.04 ; 98.22,44.44 CON0901.22
  L3-GND w0.06: 59.26,77.53 59.21,77.58 58.9,77.58
  L3-GND w0.102: 55.93,75.09 56.16,75.24 ; 69.85,66.79 69.77,66.41 ; 68.78,68.28 68.89,67.75 ; 54,73.31 53.87,73.03 ; 4.27,73.87 4.04,73.64 ; 62.15,70.77 62.56,70.93 ; 60.22,40.14 60.55,39.84 ; 38.74,68.39 38.99,68.59 ; 58.14,75.67 57.52,75.86 ; 55.14,75.55 55.19,75.17 ; 67.95,71.08 68.12,70.75 ; 69.57,69.53 69.72,69.15 ; 43.94,100.03 43.71,99.73 ; 74.96,77.94 74.58,77.71 ; 94.31,90.94 94.69,90.99 ; 62.89,39.3 62.54,39.41 ; 74.93,87.11 75.29,87.16 ; 50.45,74.15 50.19,74.15 ; 91.49,84.62 91.87,84.62 ; 50.01,75.14 50.01,75.55 ; 58.7,71.51 58.95,71.26 ; 69.72,69.86 70.1,69.94 ; 65.46,67.19 65.61,66.86 ; 81.43,94.17 81.28,93.86 ; 57.25,31.02 57.43,30.79 ; 66.83,100.92 66.88,100.52 ; 74.09,73.59 74.35,73.36 ; 32.16,100.95 32.56,100.85 ; 74.32,69.68 74.32,69.35 ; 38.38,43.01 38.38,43.44 ; v8(74.75,62.52) 74.63,62.64 v3(74.4,62.64) ; 45.26,60.36 44.98,60.18 ; 68.3,64.83 68.53,65.11 ; 91.44,85.46 91.87,85.48 ; 57.15,76.69 57.43,76.51 ; 62.46,38.54 62.79,38.54 ; 84.74,38.87 85.01,38.85 ; 53.8,39.1 53.95,38.8 ; 66.98,97.34 67.31,97.44
  L3-GND w0.109: 58.9,77.61 59.26,77.53 ; 59.89,78.14 59.74,77.68
  L3-GND w0.127: 3.23,93.3 2.95,93.02 ; 18.34,8.24 18.75,8.26 ; 50.78,74.97 50.06,74.97 ; 28.45,17.46 28.93,17.46 ; 76.07,6.41 76.45,6.44 ; 63.17,7.17 63.53,7.32
  L3-GND w0.178: 60.88,21.35 60.78,20.81
  L3-GND w0.254: 100.5,92.26 SW2004.5 99.65,92.9 ; 100.5,98.93 SW2004.4 99.65,98.3 ; CON5201.8 98.29,51.26 ; CON5201.9 99.76,61.92 98.3,62.68 98.29,62.68
  L3-GND w0.508: CON5201.7 94.47,61.92 ; CON5201.7 97.04,61.92 ; CON5201.7 95.76,62.65 ; CON5201.6 95.76,51.28 ; CON5201.6 97.04,52.02 ; CON5201.6 94.47,52.02 ; 93.37,44.44 CON0901.20 ; CON0901.20 94.71,45.18 ; CON0901.20 94.71,43.7 ; CON0901.20 96.04,44.44 ; 98.32,61.92 CON5201.9 ; 93.6,31.1 H7907.1 ; H7907.1 91.96,32.74 ; H7907.1 93.6,34.38 ; H7907.1 95.24,32.74 ; 93.37,36.04 CON0901.21 ; CON0901.21 96.04,36.04 ; CON0901.21 94.71,36.78 ; CON0901.21 94.71,35.3 ; 98.32,52.02 CON5201.8 ; 94.93,40.24 CON0901.10 ; CON0901.4 93.91,42.01 ; CON0901.4 94.48,41.44 ; CON0901.4 93.33,41.44 ; 98.22,36.04 CON0901.23 ; 98.22,44.44 CON0901.22 ; CON0901.16 94.48,39.04 ; CON0901.16 93.33,39.04 ; CON0901.16 93.91,38.47
  L4-SIG w0.102: 39.33,61.66 36.93,61.66 v3(36.7,61.88) 36.7,62.15 36.84,62.28 36.84,63.29 36.84,63.46 33.46,66.84 32.59,66.84 31.04,68.39 30.76,68.39 26.09,73.07 23.6,73.07 18.16,78.51 17.84,78.51 17.62,78.29 17.62,77.79 17.71,77.7 v2(17.71,76.87) 18.28,76.87 22.5,72.66 25.92,72.66 30.59,67.98 30.87,67.98 32.42,66.43 32.95,66.43 35.85,63.52 35.85,61.92 v3(35.89,61.88) 36.04,61.73 36.04,61.71 36.51,61.24 39.16,61.24 40.46,59.95 43.66,59.95 44.48,59.12 47.39,59.12 48.64,57.87 v3(51,57.87) 54.57,57.87 54.81,58.12 54.81,58.44 54.59,58.66 54.38,58.66 54.34,58.7 v3(50.98,58.7) 50.83,58.56 48.56,58.56 47.58,59.54 45.5,59.54 45.5,59.53 44.66,59.53 43.64,60.55 40.5,60.55 39.4,61.65 39.37,61.65 39.36,61.65 39.34,61.65 39.33,61.66
  L4-SIG w0.254: 100.5,98.93 SW2004.4 99.65,98.3 ; 93.91,38.44 CON0901.16 ; CON0901.16 93.31,39.04 ; CON0901.16 94.5,39.04 ; CON0901.4 93.91,42.04 ; CON0901.4 93.31,41.44 ; CON0901.4 94.5,41.44 ; 94.91,40.24 CON0901.10 ; CON5201.9 98.29,62.68 ; 99.65,92.9 SW2004.5 100.5,92.26 ; CON5201.8 98.29,51.26
  L4-SIG w0.508: CON0901.21 96.04,36.04 ; CON0901.21 94.71,36.78 ; CON0901.21 94.71,35.3 ; CON0901.21 93.37,36.04 ; H7907.1 95.27,32.74 ; H7907.1 91.94,32.74 ; H7907.1 93.6,34.4 ; H7907.1 93.6,31.08 ; 29.7,9.1 29.07,9.1 28.94,8.98 27.88,8.98 27.47,8.57 25.33,8.57 23.06,10.84 23.06,12.59 19.12,16.53 v3(19.12,20.27) 19.12,45.97 v3(20.2,47.06) 22.98,49.83 22.98,53.45 26.75,57.21 29.85,57.21 30.2,57.56 30.2,61.15 29.57,61.78 U1001.57 29.57,64.26 29.71,64.4 30.56,65.24 32.24,65.24 32.92,64.57 32.92,63.66 33.83,62.75 v3(33.83,60.31) 33.83,56.12 31.37,53.65 28.65,53.65 27.22,52.23 27.22,48.68 v3(23.27,44.72) 22.96,44.41 v3(22.96,20.68) 22.96,17.85 25.26,15.54 27.65,15.54 28.24,14.96 28.24,13.45 ; 94.47,52.02 CON5201.6 ; CON5201.6 95.76,51.28 ; CON5201.6 97.04,52.02 ; 98.22,44.44 CON0901.22 ; v3(33.54,12.15) 33.94,12.15 37.34,8.75 37.34,7.78 36.83,7.27 32.03,7.27 30.65,8.65 ; 98.22,36.04 CON0901.23 ; 94.71,43.7 CON0901.20 ; CON0901.20 94.71,45.18 ; CON0901.20 96.04,44.44 ; CON0901.20 93.37,44.44 ; 97.04,61.92 CON5201.7 ; CON5201.7 95.76,62.65 ; CON5201.7 94.47,61.92 ; 98.32,52.02 CON5201.8 ; 98.32,61.92 CON5201.9
  L5-SIG w0.102: v3(28.42,80.85) 27.77,81.51 27.77,89.58 v3(28.16,89.97) 28.16,92.24 v3(33.35,97.43) 33.53,97.61 39.57,97.61 39.62,97.66 41.82,97.66 42.59,98.43 42.59,100.52 44.59,102.52 77.45,102.52 v3(77.6,102.37) 83.91,102.37 v3(85.66,100.61) 86.72,99.56 89.63,99.56 91.12,98.07 v3(91.12,97.37) v3(91.12,90.36) 90.97,90.22 90.97,88.78 91.2,88.55 ; 24.3,76.52 18.06,76.52 v2(17.71,76.87) 15.14,76.87 v2(15.1,76.83) 12.85,76.83 v2(12.85,76.83) 12.74,76.95 11.53,76.95 v2(11.35,76.77) 11.35,76.36 11.21,76.21 6.83,76.21 4.46,78.58 4.46,78.91 v3(4.32,79.05) 4.32,80.01 3.86,80.47 3.86,81.22 3.26,81.82 2.94,81.82 2.72,81.6 v3(2.72,80.93) 2.72,79.69 6.61,75.8 11.45,75.8 11.89,76.24 v2(12.19,76.24) 12.35,76.08 26.22,76.08 26.74,76.6 29.59,76.6 31.33,74.86 31.76,74.86 32.95,73.67 32.95,73.46 32.95,73.33 38.55,67.74 39.22,67.74 39.46,67.98 39.46,68.31 39.24,68.53 38.92,68.53 38.84,68.45 38.47,68.45 33.37,73.55 33.37,73.84 31.93,75.28 31.5,75.28 29.76,77.02 26.57,77.02 26.07,76.52 24.3,76.52 ; 24.3,76.52 24.3,77.4 24.45,77.55 24.58,77.55 24.98,77.96 24.98,89.25 v3(24.98,89.26) 24.98,92.04 32.39,99.45 32.55,99.45 v3(32.66,99.56) 32.84,99.38 38.83,99.38 39.05,99.61 40.13,99.61 40.79,100.27 40.79,101.2 40.79,101.2 40.79,101.37 43.77,104.35 62.6,104.35 v3(63.14,104.89) 63.65,105.4 65.63,105.4 66.43,104.6 v3(76.9,104.6) 77.59,104.6 77.81,104.38 85.21,104.38 v3(86.68,102.92) 86.68,102.5 87.72,101.46 90.24,101.46 93.37,98.32 v3(93.37,97.64) 93.37,94 94.9,92.48 v3(94.9,89.93) ; v3(94.9,89.93) 94.46,89.49 93.33,89.49 92.39,88.55 91.2,88.55 ; v3(94.9,89.93) 94.9,88.31 92.7,86.11 92.7,84.34 v3(92.35,83.99) 92.19,83.83 91.52,83.83 91.2,84.15 91.2,88.55
  L5-SIG w0.254: 100.5,92.26 SW2004.5 99.65,92.9 ; 100.5,98.93 SW2004.4 99.65,98.3 ; 98.29,51.26 CON5201.8 ; 93.41,41.44 CON0901.4 ; CON0901.4 93.91,41.94 ; CON0901.4 94.4,41.44 ; 93.91,38.54 CON0901.16 93.41,39.04
  L5-SIG w0.508: 96.96,61.92 CON5201.7 ; CON5201.7 95.76,62.58 ; CON5201.7 94.55,61.92 ; 98.03,36.04 CON0901.23 ; 94.71,35.38 CON0901.21 ; CON0901.21 94.71,36.7 ; CON0901.21 93.45,36.04 ; CON0901.21 95.96,36.04 ; 94.71,43.78 CON0901.20 ; CON0901.20 95.96,44.44 ; CON0901.20 94.71,45.1 ; CON0901.20 93.45,44.44 ; CON5201.6 96.96,52.02 ; CON5201.6 94.55,52.02 ; CON5201.6 95.76,51.36 ; 91.94,32.74 H7907.1 ; H7907.1 93.6,34.4 ; H7907.1 95.27,32.74 ; H7907.1 93.6,31.08 ; 98.1,44.43 98.1,44.44 CON0901.22 ; CON5201.8 98.08,52.02 ; CON5201.9 98.26,61.92
  L6-GND w0.06: v6(54.84,76.96) 54.84,76.71 55.09,76.46 55.09,76.27 55.14,76.23 ; 55.04,76.13 54.84,76.13 54.32,76.64 54.08,76.64 ; 58.9,72.07 58.96,72.12 58.96,72.24 59.04,72.33 59.09,72.37 59.41,72.37 v6(59.63,72.16) ; 58.05,75.11 58.06,75.1 ; 55.7,76.4 55.64,76.35 55.58,76.35 55.38,76.14 55.3,76.14 ; 55.7,76.4 55.97,76.13 56.07,76.13 ; 55.7,76.4 55.75,76.45 ; 54.69,71.99 54.69,71.99 ; 52.22,76.41 52.07,76.57 52.07,76.9 v6(52.01,76.96) ; 54.92,75.58 55.13,75.79 55.13,75.99 ; 51.54,76.59 51.69,76.41 51.69,76.22 v6(51.73,76.11) ; 50.07,75.65 50.07,75.65 50.07,76.18 v6(50.06,76.18) ; v6(58.52,68.75) v6(58.51,68.2) ; v6(57.52,34.54) 57.52,34.54 57.73,34.33 58.13,34.33 v6(58.32,34.14) ; 58.87,76.24 58.87,75.88 v6(58.81,75.82) ; 51.3,70.57 51.29,70.58 ; 47.53,77.51 47.53,77.51 ; 51.49,76.69 v6(51.44,76.96) ; 54.1,70.06 54.1,70.06 ; 53.16,76.06 53.37,75.83 ; v6(48.64,68.49) 48.64,68.49 ; 53.4,76.46 53.16,76.16
  L6-GND w0.076: 50.35,91.25 50.34,91.27 50.34,91.65 ; 50.35,91.25 50.26,91.25 50.18,91.18 49.84,91.18 49.8,91.14 ; 50.35,91.25 50.85,91.25 ; v6(47.2,73.82) 47.22,73.84 47.22,74.1 47.45,74.44 ; 59.06,71.91 58.9,72.07 58.69,72.07 58.61,72.15 ; 59.06,71.91 59.06,71.8 58.85,71.58 58.54,71.58 v6(58.5,71.54) ; 59.06,71.91 59.24,71.91 59.35,72.02 59.49,72.02 v6(59.63,72.16) ; 45.34,95.86 44.96,95.86 44.94,95.84 ; 45.34,95.86 45.34,96.33 ; 45.34,95.86 45.75,95.86 ; 65.61,96.83 65.61,97.21 ; 65.61,96.83 65.71,96.72 65.99,96.72 66.17,96.9 ; 65.61,96.83 65.45,96.68 65.3,96.68 ; 44.7,92.67 44.7,92.33 ; 51.37,91.75 50.81,91.75 ; 50.81,91.75 50.4,91.75 50.35,91.79 ; 50.81,91.75 50.83,91.72 50.83,91.59 50.83,91.39 50.83,91.39 50.83,91.27 50.85,91.25 ; 48.46,74.94 48.74,74.97 ; 62.11,95.76 61.64,95.76 ; 62.11,95.76 62.1,95.75 62.1,95.26 ; 62.11,95.76 62.11,96.27 ; 62.11,95.76 62.61,95.76 ; 65.61,91.29 65.61,91.64 65.72,91.75 ; 65.61,91.29 65.55,91.23 65.18,91.23 ; 65.61,91.29 65.61,91.29 65.83,91.07 ; 48.24,94.79 48.33,94.79 48.68,94.44 48.95,94.44 ; 65.74,97.24 66.07,97.24 ; 45.33,93.25 45.33,92.81 45.4,92.74 45.78,92.74 45.82,92.78 ; 50.98,90.73 50.85,90.86 50.85,91.25 ; 50.98,90.73 50.94,90.69 50.94,90.47 50.82,90.35 50.82,90.26 ; 50.98,90.73 51.41,90.73 51.41,90.72 ; 68.58,94.74 68.18,94.74 68.11,94.81 ; 52.4,72.63 52.4,72.58 52.02,72.2 ; 65.76,90.71 65.2,90.71 ; 47.32,68.18 47.52,68.18 47.75,68.41 ; 57.96,70.75 58.04,70.95 ; 50.06,75.52 49.99,75.24 ; 51.48,91.19 51.42,91.25 50.85,91.25 ; 68.11,94.81 68.11,94.81 67.98,94.67 67.98,94.36 68.11,94.23 68.11,93.77 ; 68.11,94.81 68.11,95.2 ; 50.32,94.85 50.32,95.22 ; 47.85,93.66 47.63,93.61 ; 66.62,92.27 66.62,91.37 ; 45.01,95.34 45.75,95.34 ; 45.82,96.34 45.25,96.34 ; 47.76,91.71 47.6,91.71 47.56,91.75 47.42,91.75 47.37,91.8 ; 67.15,91.74 67.08,91.33 ; 47.88,90.75 47.86,90.73 46.87,90.73 46.86,90.75 ; 67.11,90.65 66.65,90.65 ; 67.11,90.65 67.11,90.25 67.24,90.12 ; 67.11,90.65 67.11,91.07 ; v6(48.01,77.51) 48.08,77.23 48.29,77 ; 57.99,69.91 57.99,70.09 58.01,70.2 58.03,70.27 58.07,70.42 ; 49.43,69.81 49.66,69.81 49.99,69.48 ; 46.82,91.24 47.22,91.24 ; 47.22,91.24 47.63,91.24 47.74,91.34 ; 47.22,91.24 47.2,91.25 47.2,91.63 47.37,91.8 ; 44.93,92.21 45.19,92.29 ; 52.35,76.36 52.5,76.16 ; v6(48.33,70.45) 48.8,70.45 ; 64.92,91.27 64.59,91.27 ; 52.48,76.08 52.35,75.83 52.35,75.63 ; 46.77,91.12 46.86,91.04 46.86,90.75 ; 43.84,95.68 44.28,95.68 44.42,95.82 ; 62.41,92.24 62.41,92.24 61.54,92.24 ; 44.42,95.82 44.49,95.74 44.77,95.74 44.78,95.74 ; 44.42,95.82 44.34,95.9 44.34,96.25 ; 50.42,94.73 50.75,94.73 ; 47.51,74.74 47.8,74.74 48.03,74.91 ; 62.61,95.76 63.11,95.76 ; 62.61,95.76 62.61,95.31 ; 47.37,92.24 47.37,92.24 47.37,91.8 ; 48.26,73.8 v6(47.78,73.85) ; 67.16,91.83 67.11,91.88 67.11,92.21 67.06,92.26 ; 66.04,91.67 66.17,91.33 ; 63.22,96.28 63.56,96.28 ; v6(47.75,66.5) v6(48.33,66.52) ; 65.11,91.78 65.11,92.22 ; 44.63,92.26 44.29,92.26 ; v6(58.52,68.75) 58.07,68.72 ; 46.86,90.75 46.86,90.23 ; 47.96,75.52 47.78,75.3 47.51,75.3 v6(47.48,75.27) ; 53.06,76.79 53.16,76.69 53.29,76.54 53.37,76.46 53.65,76.46 ; 63.11,95.76 63.69,95.76 ; 63.11,95.76 63.11,96.2 ; 63.11,95.76 63.11,94.76 ; 47.4,94.85 47.63,95.01 ; 51.13,76.44 50.98,76.62 ; 44.2,92.34 44.2,92.72 ; 50.83,94.6 50.83,94.29
  L6-GND w0.102: 67.13,70.75 67.46,71.08 67.46,71.16 ; v6(47.77,69.32) 48.25,69.32 ; 21.97,51.52 21.74,51.44 ; 56.93,71.15 56.68,71.15 56.38,71.45 ; 56.93,71.15 56.93,71.28 57.12,71.46 ; 56.93,71.15 56.93,71.07 57.11,70.89 ; 55.41,72.02 55.06,72.02 ; 55.41,72.02 55.69,71.74 56.02,71.74 ; 55.41,72.02 55.42,72.02 55.65,72.25 ; v6(47.75,66.5) 47.34,66.5 47.23,66.4 ; 54.27,68.67 54.02,68.42 ; 54.27,68.67 54.06,68.89 54.06,69 ; 54.27,68.67 54.44,68.67 54.65,68.88 54.65,68.96 v6(54.86,69.17) ; 54.02,68.42 53.81,68.42 ; 54.02,68.42 54.03,68.42 54.15,68.3 54.15,68.3 54.27,68.19 54.27,68.12 ; 78.69,23.99 78.92,23.53 ; 53.55,71.96 53.67,72.09 53.67,72.25 ; v6(47.48,67.34) 47.54,67.4 47.78,67.4 47.98,67.5 48.25,67.5 48.34,67.41 v6(48.34,67.04) ; 79.43,18.09 79.43,17.89 ; 53.81,68.42 53.65,68.58 53.65,68.89 53.9,69.15 v6(53.9,69.23) ; 53.81,68.42 53.57,68.19 53.57,68.03 ; 61.6,78.75 61.57,78.72 61.15,78.72 ; 55.65,72.25 55.89,72.25 ; 55.65,72.25 55.53,72.37 55.53,72.53 ; 49.25,71.1 49.43,71.34 49.43,71.41 ; 47.08,66.46 46.71,66.46 46.66,66.41 ; v6(50.06,76.18) 50.13,76.11 v6(50.6,76.11) 50.85,76.11 51.11,75.85 51.11,75.57 ; 61.39,59.45 61.39,59.06 ; 56,76.89 55.95,76.83 55.95,76.65 55.75,76.45 ; 55.53,72.53 55.21,72.53 54.9,72.22 ; 55.53,72.53 55.53,72.6 55.6,72.78 55.7,72.88 ; 59.09,75.78 59.13,75.78 59.37,75.54 v6(59.37,75.27) ; 56.17,71.98 55.9,72.25 55.89,72.25 ; 53.36,72.57 53.02,72.23 53.02,72.18 ; 53.36,72.57 53.33,72.57 53.07,72.83 ; 53.36,72.57 53.55,72.57 ; 49.51,72.54 49.29,72.32 49.29,72.18 ; 49.83,69.21 49.43,69.21 ; 50.93,72.25 51.22,72.25 ; 50.93,72.25 50.66,71.98 ; 50.93,72.25 50.66,72.53 ; 75.18,58.99 75.24,58.73 ; 54.28,71.99 54.69,71.99 ; 54.28,71.99 54.02,71.73 53.72,71.73 ; 54.28,71.99 54.28,71.99 54.02,72.25 ; 63.5,7.32 63.2,7.17 ; 63.35,58.58 63.5,58.2 ; 49.43,71.41 49.43,71.49 49.35,71.64 ; 49.43,71.41 49.68,71.41 ; v6(59.37,74.7) 59.37,74.4 59.22,74.25 59.09,74.25 ; v6(60.41,69.62) 60.48,69.54 60.48,68.48 v6(60.49,68.47) ; 53.55,72.57 53.67,72.44 53.67,72.25 ; 53.55,72.57 53.75,72.77 54.02,72.77 54.18,72.61 ; 54.18,72.61 54.18,72.41 54.02,72.25 ; 54.18,72.61 54.41,72.61 54.73,72.29 ; 50.34,74.18 50.57,74.13 ; v6(59.08,73.85) 59.09,73.86 59.09,74.25 ; 50.83,77.33 51.18,77.03 51.18,77.02 50.95,76.69 ; 55.89,72.25 56.21,72.56 ; 59.82,58.07 59.89,57.87 ; 59.09,74.25 58.39,74.25 ; 57.12,71.46 57.37,71.46 57.58,71.68 ; 57.12,71.46 56.87,71.71 ; 53.73,70.06 54.1,70.06 ; 50.89,70.58 50.74,70.42 50.74,70.3 ; 50.89,70.58 50.89,70.71 50.67,70.93 ; 50.89,70.58 51.29,70.58 ; 58.05,75.59 58.05,75.11 ; 49.68,71.41 49.71,71.41 49.95,71.17 ; 49.68,71.41 50.01,71.75 ; v6(59.63,69.33) 59.71,69.4 59.71,69.77 ; 71.12,59.85 71.45,59.7 ; 49.78,71.99 49.47,71.99 ; 48.66,78.28 48.66,78.54 ; 79.76,16.88 80.09,16.75 ; 48.97,74.73 48.77,74.53 48.77,74.39 ; 25.96,6.89 26.37,6.89 ; 54.02,72.25 53.67,72.25 ; 48.39,69.31 48.83,69.31 ; 48.64,68.49 48.08,68.49 ; 62.23,70.82 62.54,70.9 ; 34.01,41.82 33.91,41.41 ; 78.79,18.09 78.79,17.89 ; 28.93,8.7 28.93,8.37 ; 30.81,38.87 30.96,38.64 ; 48.64,72.65 48.44,72.4 ; 21.82,54.9 22,54.67 ; v6(58.52,74.98) 58.01,74.98 57.99,74.97 ; 47.53,77.51 v6(48.01,77.51) ; 61.48,68.78 61.48,69.31 ; 65.05,13.98 65.33,14.13 ; 51.94,7.02 51.82,6.66
  L6-GND w0.127: 61.47,69.61 61.27,69.89 ; 58.19,72.37 58.04,72.63 ; 46.13,67.35 45.74,67.35 ; 59.97,78.24 59.74,77.96 ; 58.57,78.37 58.45,78.11
  L6-GND w0.254: CON0901.16 94.48,39.04 ; CON0901.16 93.91,38.47 ; CON0901.16 93.33,39.04 ; 93.91,42.01 CON0901.4 94.48,41.44 ; 99.65,92.9 SW2004.5 100.5,92.26 ; 100.5,98.93 SW2004.4 99.65,98.3
  L6-GND w0.508: H7907.1 93.6,34.4 ; H7907.1 95.27,32.74 ; H7907.1 93.6,31.08 ; H7907.1 91.94,32.74 ; CON0901.20 94.71,45.18 ; CON0901.20 96.04,44.44 ; CON0901.20 94.71,43.7 ; CON0901.20 93.37,44.44 ; 98.22,44.44 CON0901.22 ; 94.45,52.02 CON5201.6 ; CON5201.6 97.06,52.02 ; CON5201.6 95.76,51.26 ; CON0901.21 96.04,36.04 ; CON0901.21 94.71,35.3 ; CON0901.21 94.71,36.78 ; CON0901.21 93.37,36.04 ; 98.22,36.04 CON0901.23 ; 94.45,61.92 CON5201.7 ; CON5201.7 95.76,62.68 ; CON5201.7 97.06,61.92 ; 94.93,40.24 CON0901.10 ; 98.32,61.92 CON5201.9 ; 98.32,52.02 CON5201.8
  L7-SIG w0.06: 57.71,32.37 57.71,33.03 57.81,33.13 57.99,33.13 58,33.13 58.15,33.27 ; v6(58.32,34.14) 58.12,34.33 57.73,34.33 57.52,34.54 v6(57.52,34.54) ; 58.17,32.67 58.13,32.71 58.13,33.02 58.26,33.15 ; v6(57.38,64.81) 57.38,64.06 57.15,63.83 57.15,62.24 56.84,61.93 ; 56.13,61.93 56.13,61.98 56.8,62.65 v6(56.8,63.02) 56.8,63.82 57.05,64.07 57.05,65.29 57.42,65.65 57.42,65.98 v6(57.66,66.23) ; 58.32,32.42 58.55,32.65 58.67,32.65 58.87,32.85 58.87,33.06 58.78,33.16 58.52,33.16
  L7-SIG w0.102: 56.13,61.93 56.13,61.1 55.67,60.64 55.67,59.49 55.77,59.39 55.77,58.96 v1(55.66,58.85) 55.27,58.46 55,58.46 54.84,58.29 54.84,58.06 55,57.9 55.37,57.9 56.16,58.69 56.16,59.55 56.06,59.65 56.06,60.48 56.61,61.04 56.61,61.7 56.84,61.93 ; v1(92.66,82.56) 87.83,77.73 87.83,74.4 86.41,72.98 86.09,72.98 85.93,73.15 85.93,75.18 86.27,75.52 86.58,75.52 86.79,75.74 86.79,76.24 86.46,76.57 ; 94.79,85.03 94.79,91.48 93.27,93 92.8,93 90.38,90.58 v1(90.38,90.07) 90.66,89.79 91.22,89.79 91.55,90.12 91.55,90.72 91.92,91.09 92.2,91.09 92.37,90.93 92.37,90.03 91.74,89.4 90.85,89.4 90.59,89.14 90.59,87.96 90.86,87.7 ; 90.86,87.7 90.58,87.42 90.58,87 v1(90.43,86.85) v1(90.16,86.59) 89.51,85.93 89.51,84.11 87.68,82.28 86.18,82.28 85.02,81.12 85.02,77.55 86.01,76.57 86.46,76.57 ; 90.86,87.7 91.93,87.7 92.09,87.53 92.09,87.3 91.93,87.14 91.63,87.14 91.06,86.57 90.99,86.57 v1(90.45,86.04) v1(90.2,85.78) 89.89,85.48 89.89,83.95 87.8,81.85 86.36,81.85 85.41,80.89 85.41,77.77 85.85,77.33 86.36,77.33 86.51,77.48 v1(86.51,77.76) 86.79,77.48 86.79,76.9 86.46,76.57 ; 16.89,76.87 v2(17.71,76.87) 17.71,77.23 16.99,77.94 16.99,78.36 16.06,79.29 v1(15.2,79.29) 14.97,79.29 14.89,79.21 14.89,78.65 15.04,78.5 16.09,78.5 16.41,78.17 16.41,77.35 16.89,76.87
  L7-SIG w0.254: 94.5,39.04 CON0901.16 93.91,38.44 ; 100.5,98.93 SW2004.4 99.65,98.3 ; 99.65,92.9 SW2004.5 100.5,92.26 ; v6(47.2,73.28) 47.05,73.28 46.77,73 v6(46.35,73) ; 93.91,42.04 CON0901.4 94.5,41.44 ; CON5201.8 98.29,51.26 ; CON5201.9 98.29,62.68 ; 94.91,40.24 CON0901.10
  L7-SIG w0.508: CON5201.7 95.76,62.65 ; CON5201.7 97.04,61.92 ; CON5201.7 94.47,61.92 ; 93.6,31.08 H7907.1 ; H7907.1 91.94,32.74 ; H7907.1 95.27,32.74 ; H7907.1 93.6,34.4 ; CON0901.21 96.04,36.04 ; CON0901.21 94.71,36.78 ; CON0901.21 94.71,35.3 ; CON0901.21 93.37,36.04 ; 98.22,44.44 CON0901.22 ; 98.32,52.02 CON5201.8 ; 98.22,36.04 CON0901.23 ; CON0901.20 94.71,45.18 ; CON0901.20 93.37,44.44 ; CON0901.20 96.04,44.44 ; CON0901.20 94.71,43.7 ; CON5201.6 95.76,51.28 ; CON5201.6 94.47,52.02 ; CON5201.6 97.04,52.02 ; 98.32,61.92 CON5201.9
  BOTTOM w0.06: U2400.AH56 53.68,78.12 53.68,78.56 ; 50.34,78.39 50.64,78.1 U2400.AY56 50.88,78.42 51.12,78.66 U2400.AV58 51.77,78.66 52.01,78.42 v6(52.01,78.1) ; U2400.F6 59.98,64.49 v6(59.92,64.49) ; 52.32,75.27 52.07,75.02 ; 52.07,75.02 51.84,75.02 ; 52.07,75.02 52.35,74.74 ; v6(56.53,64.52) 56.55,64.52 56.57,64.51 U2400.V6 ; U2400.AN49 52.86,76.28 52.83,76.3 52.83,76.65 v6(52.86,76.68) ; v6(46.35,73) 46.02,73 45.74,72.72 U2400.BW37 ; U2400.BM36 47.48,72.5 v6(47.48,72.45) ; U2400.BJ15 48.33,67.05 v6(48.34,67.04) ; U2400.BV28 45.71,70.73 45.7,70.71 45.68,70.71 v6(45.67,70.7) ; 58.01,74.58 57.89,74.46 57.24,74.46 ; 58.01,74.58 58.24,74.36 U2400.M42 ; 58.01,74.58 58.01,74.97 ; 52.35,74.74 52.1,74.48 ; 52.35,74.74 52.65,74.74 ; 54.02,78.17 54.26,78.41 ; 48.84,67.62 48.84,67.63 ; 51.69,75.55 52.3,75.55 ; 54.89,78.27 54.89,78.46 55.09,78.66 U2400.AB58 55.72,78.66 55.78,78.6 55.78,78.6 55.91,78.47 55.91,78.16 U2400.Y56 ; U2400.BT46 46.04,75.27 45.77,75 ; 46.67,78.73 46.35,78.41 U2400.BT56 ; 50.57,75.6 50.57,76.09 v6(50.6,76.11) ; 47.18,78.67 47.22,78.67 47.48,78.41 U2400.BM56 47.73,78.1 48.05,78.42 ; U2400.K58 58.8,78.42 59.13,78.1 U2400.H56 59.37,78.42 59.59,78.64 59.59,78.65 59.6,78.66 U2400.F58
  BOTTOM w0.102: D9000.1 42.36,17.29 ; R8813.2 40.04,26.96 ; U2400.BJ27 48.77,70.46 48.85,70.54 ; 47.61,14.93 U7311.2 47.61,15.85 ; 53.99,76.46 U2400.AG49 53.99,75.6 ; v1(68.4,71.55) U3001.64 ; 48.8,72.16 48.34,72.16 U2400.BJ35 ; 39.67,25.82 R8812.2 ; v1(79.38,57.22) 79.44,57.22 U7942.29 ; 57.99,69.4 57.99,68.28 58.12,68.16 ; v1(62.6,16.42) v1(62.6,16.11)
  BOTTOM w0.114: v6(47.75,64.23) 47.75,63.7 v6(47.7,63.65) ; U2400.AP6 U2400.AM6 ; U2400.Y8 U2400.Y10 ; 57.39,65.39 U2400.R11 ; U2400.BB10 50.34,65.68 v6(50.34,66.22)
  BOTTOM w0.127: U2400.H10 U2400.F10 ; U2400.BN13 47.74,66.49 v6(47.75,66.5) 48.27,66.5 48.3,66.46 ; 48.9,75.04 48.81,74.95 48.36,74.95 U2400.BJ45 ; 53.16,78.53 53.16,78.11 U2400.AM56 ; 57.39,66.35 57.27,66.48 56.89,66.48 ; U2400.BL41 47.79,73.82 48.3,73.82 U2400.BJ41 ; U2400.BP10 v6(47.48,65.65) ; 54.68,77.55 54.29,77.55 U2400.AF54 ; U2400.BV12 45.85,66.21 45.88,66.24 46.07,66.24 46.08,66.23 46.33,66.23 U2400.BT12
  BOTTOM w0.145: v6(45.69,71.87) 45.71,71.89 46.14,71.89 46.16,71.87 U2400.BT34
  BOTTOM w0.152: 24.34,93.23 v1(24.73,93.23) ; v1(24.73,93.23) 24.73,93.62 ; v1(24.73,93.23) 25.11,93.23 ; v1(24.73,93.23) 24.73,92.85 ; v1(24.22,91.23) 24.61,91.23 ; v1(24.22,91.23) 24.22,90.85 ; v1(24.22,91.23) 24.22,91.62 ; v1(24.22,91.23) 23.84,91.23 ; v1(24.22,89.73) 24.61,89.73 ; v1(24.22,89.73) 24.22,90.12 ; v1(24.22,89.73) 23.84,89.73 ; v1(24.22,89.73) 24.22,89.35 ; v1(24.73,87.73) 25.11,87.73 ; v1(24.73,87.73) 24.34,87.73 ; v1(24.73,87.73) 24.73,87.35 ; v1(24.73,87.73) 24.73,88.12 ; 25.73,93.35 v1(25.73,93.73) ; v1(25.73,93.73) 25.34,93.73 ; v1(25.73,93.73) 25.73,94.12 ; v1(25.73,93.73) 26.11,93.73 ; v1(24.22,88.73) 24.22,89.12 ; v1(24.22,88.73) 24.22,88.35 ; v1(24.22,88.73) 24.61,88.73 ; v1(24.22,88.73) 23.84,88.73 ; v1(25.73,87.23) 26.11,87.23 ; v1(25.73,87.23) 25.34,87.23 ; v1(25.73,87.23) 25.73,87.62 ; v1(25.73,87.23) 25.73,86.85 ; 23.84,92.23 v1(24.22,92.23) ; v1(24.22,92.23) 24.22,92.62 ; v1(24.22,92.23) 24.22,91.85 ; v1(24.22,92.23) 24.61,92.23 ; 53.74,66.54 53.64,66.54 53.48,66.38 53.44,66.38 ; U2400.N49 57.95,75.66
  BOTTOM w0.178: U2400.BK20 U2400.BH20 ; U2400.V6 U2400.Y6 ; U2400.L37 U2400.L35 U2400.L33 ; 48.84,67.63 U2400.BJ17 U2400.BJ15 48.34,67.06 49.11,67.06 U2400.BF15 ; U2400.G13 U2400.J13 U2400.L13 U2400.L15 ; U2400.AR1 U2400.AU1 v6(51.67,63.02) ; U2400.U7 57.22,64.8 ; v6(47.77,69.32) U2400.BJ23 48.72,69.32 ; U1701.E5 U1701.D4 ; U2400.U11 56.82,66.46
  BOTTOM w0.203: v1(43.58,90.48) 43.81,90.28 ; U1701.R16 44.31,90.78 ; U2400.BV20 v6(45.43,68.19) ; v1(68.86,97.98) 69.09,97.78 ; U2400.U7 U2400.V6 ; U2400.BP6 46.92,64.51 v6(46.63,64.23) ; v1(68.36,97.48) 68.59,97.28 ; U1601.M17 61.59,92.28 ; U2400.BW30 U2400.BV28 ; U2400.AH2 v6(53.42,63.02) ; U2400.AB2 55.41,63.31 U2400.AC1 U2400.AD2 ; U2400.BM34 U2400.BN35 U2400.BM36 ; U2400.BV24 v6(45.43,69.89) ; U2400.G5 U2400.F6 ; U1601.T15 62.14,90.69
  BOTTOM w0.229: U2400.BV16 v6(45.43,67.06) ; v2(86.28,93.07) CON3800.30
  BOTTOM w0.254: U1601.A5 U1601.A4 U1601.B4 ; U1701.B3 v1(50.58,97.98) ; 9.35,93.12 U5401.86 9.35,92.16 ; 93.91,38.49 CON0901.16 ; CON0901.16 94.45,39.04 ; CON0901.16 93.36,39.04 ; 58.36,6.48 CON7305.10 58.36,5.36 ; 5.35,92.16 U5401.78 5.35,93.12 ; U2400.A47 61.52,75.45 61.52,75.08 U2400.A45 61.35,74.98 U2400.B44 ; 20.78,86.78 C1912.2 20.29,87.26 ; 87.07,28.55 v1(87.8,28.55) ; v1(87.8,28.55) 87.8,28.98 ; v1(87.8,28.55) 88.52,28.55 ; U1601.R8 v1(66.36,90.98) ; 40.37,25.94 C9007.2 41.11,25.94 ; 13.35,92.16 U5401.94 13.35,93.12 ; 31.73,81.79 C1904.2 v1(31.85,82.29) 32.26,82.29 ; U1915.B2 37.08,87.88 37.08,88.12 v1(37.08,88.12) ; 11.35,92.16 U5401.90 11.35,93.12 ; v1(68.86,96.48) U1601.D3 U1601.D4 U1601.C4 ; 57.46,2.43 v1(57.46,2.87) CON7305.13 v1(57.46,3.26) 57.46,3.67 ; 8.35,77.92 U5401.41 8.35,76.96 ; v1(31.69,12.84) 32.1,12.84 ; v1(31.69,12.84) 31.29,12.84 ; v1(31.69,12.84) 31.69,12.47 ; 40.37,22.26 R9000.2 41.11,22.26 ; 79.75,6.69 U7321.B1 ; CON5101.1 24,33.01 ; CON5101.1 24.88,32.5 ; CON5101.1 23.13,32.5 ; CON5101.1 24,31.99 ; R9003.2 41.11,26.68 ; R9003.2 40.74,27.09 ; R9003.2 40.37,26.68 ; 15.69,83.79 U5401.17 14.72,83.79 ; 6.35,93.12 U5401.80 6.35,92.16 ; v1(37.08,92.87) 37.22,93.01 U1915.B13 ; v1(37.08,92.24) 37.11,92.24 37.11,92.23 U1915.A11 ; C8800.1 39.29,23.4 ; C8800.1 39.66,23 ; C8800.1 38.92,23 ; 17.06,70.95 CON3301.13 ; CON3301.13 17.49,71.62 ; CON3301.13 v2(17.49,70.15) ; CON3301.13 17.93,70.95 ; 32.79,83.65 C1902.2 v1(32.67,83.15) 32.26,83.15 ; 40.37,25.21 R7154.2 41.11,25.21 ; 94.96,40.79 CON0901.10 ; CON0901.10 94.93,40.24 ; CON0901.10 94.96,39.69 ; D9000.1 43.21,16.69 ; D9000.1 42.36,16.09 ; D9000.1 41.51,16.69 ; 55.66,2.43 v1(55.66,2.9) CON7305.19 ; 9.77,70.95 CON3301.14 ; CON3301.14 10.25,70.17 ; CON3301.14 10.74,70.95 ; 40.67,13.82 C9000.2 ; C9000.2 41.04,14.23 ; C9000.2 40.3,14.23 ; CON3301.11 11.62,74.28 ; 40.37,24.47 C7150.2 41.11,24.47 ; v1(43.71,15.23) 43.71,15.63 ; v1(43.71,15.23) 44.08,15.23 ; v1(43.71,15.23) 43.34,15.23 ; C2127.2 12.11,112.7 ; 95.91,68.04 CON0700.17 ; CON0700.17 96.83,68.68 ; CON0700.17 94.98,68.68 ; CON0700.17 95.91,69.31 ; 6.85,92.16 U5401.81 6.85,93.12 ; 39.3,26.96 R8813.2 ; 53.86,3.67 CON7305.25 53.86,2.43 ; U2400.AM34 53.22,71.71 U2400.AK33 ; 11.85,93.12 U5401.91 11.85,92.16 ; C9008.2 42.85,28.06 ; C9008.2 42.85,27.33 ; C9008.2 43.26,27.7 ; C9008.2 42.44,27.7 ; 99.18,68.41 CON0700.18 100.26,69.09 ; v1(46.58,95.98) U1701.E10 v1(47.58,95.98) ; 23.13,16.5 CON5101.9 ; CON5101.9 24,17.01 ; CON5101.9 24.88,16.5 ; CON5101.9 24,15.99 ; 7.85,93.12 U5401.83 7.85,92.16 ; 4.49,84.79 U5401.62 3.52,84.79 ; 95.71,95.61 D2003.2 ; D2003.2 96.83,95.61 ; D2003.2 96.27,96.04 ; U1601.G5 U1601.F5 U1601.E5 66.89,95.98 v1(66.88,96) ; CON3301.9 v1(12.62,74.28) ; 1.65,58.87 CON2002.19 ; CON2002.19 1.65,59.83 ; CON2002.19 2.27,59.35 ; CON2002.19 0.97,59.35 ; 13.85,93.12 U5401.95 13.85,92.16 ; 14.72,80.79 U5401.23 ; 39.13,99.45 C3101.2 ; 93.36,41.44 CON0901.4 ; CON0901.4 94.45,41.44 ; CON0901.4 93.91,41.99 ; 9.85,76.96 U5401.38 9.85,77.92 ; 39.15,100.24 C1705.2 ; v1(67.36,93.48) U1601.J5 U1601.H5 ; 39.15,98.64 v1(39.6,98.64) ; 12.85,92.16 U5401.93 12.85,93.12 ; 10.35,92.16 U5401.88 10.35,93.12 ; U1601.G16 v1(62.36,94.98) U1601.H15 ; 8.35,93.12 U5401.84 8.35,92.16 ; U2400.U1 56.82,63.1 U2400.V2 ; 40.04,26.22 R8812.2 39.3,26.22 ; CON2002.20 1.65,70.28 ; CON2002.20 1.65,69.42 ; CON2002.20 2.27,69.85 ; CON2002.20 0.81,69.85 ; 99.65,98.3 SW2004.4 100.5,98.93 ; 84.67,27.25 v1(85.42,27.25) 85.42,26.79 ; 100.5,92.26 SW2004.5 99.65,92.9 ; 34.63,12.85 Q8805.1 ; Q8805.1 34.96,13.47 ; Q8805.1 34.63,14.1 ; v1(37.08,91.25) 37.1,91.23 U1915.A9 ; C2122.2 13.63,112.7 ; U1601.M6 U1601.M5 U1601.M4 ; 4.85,92.16 U5401.77 4.85,93.12 ; v1(42.13,34.05) 42.54,34.05 ; v1(42.13,34.05) 42.13,34.42 ; v1(42.13,34.05) 41.73,34.05 ; v1(42.13,34.05) 42.13,33.68 ; v1(50.58,96.48) U1701.D4 U1701.C4 ; CON2002.8 4.84,63.85 ; 11.35,112.7 C2101.2 10.82,112.2 v2(10.61,112.41) ; 14.72,82.29 U5401.20 15.69,82.29 ; C2102.2 12.87,112.7 ; CON0700.9 98.03,69.36 ; CON0700.9 98.73,68.59 ; CON0700.9 98.03,67.81 ; CON0700.9 97.33,68.59 ; 14.72,89.29 v1(15.2,89.29) ; 14.72,79.29 v1(15.2,79.29) 15.69,79.29 ; v2(19.99,91.85) C1905.2 20.75,92.33 ; U5401.68 4.49,87.79 ; 39.15,97.9 C1625.2 ; U1701.T15 v1(44.58,89.98) v1(44.08,89.98) ; 5.85,93.12 U5401.79 5.85,92.16 ; 39.15,97.14 C1623.2 ; 40.37,28.29 v1(40.37,28.66) ; v1(40.37,28.66) 40.37,29.02 ; v1(40.37,28.66) 39.96,28.66 ; v1(40.37,28.66) 40.77,28.66 ; 12.35,93.12 U5401.92 12.35,92.16 ; v1(37.08,88.73) 37.09,88.73 U1915.A4 ; 29.41,81.79 C1911.2 ; 10.85,92.16 U5401.89 10.85,93.12 ; U1601.E8 v1(65.36,95.98) ; 14.35,93.12 U5401.96 14.35,92.16 ; v2(20,90.36) 20.03,90.33 C1916.2 ; 46.9,15.39 U7311.2 ; C1914.2 v2(20,89.49) ; 27.34,89.73 v1(27.73,89.73) ; U1701.K5 U1701.J5 ; v1(37.08,89.72) 37.1,89.73 U1915.A6 ; 4.95,63.97 4.57,64.35 CON2002.9 ; 48.96,2.62 v1(48.96,3.16) CON7305.41 ; v1(61.86,89.98) v1(62.36,89.98) ; 7.35,93.12 U5401.82 7.35,92.16 ; 11.35,76.96 U5401.35 11.35,77.92 ; 9.85,92.16 U5401.87 9.85,93.12 ; 32.78,101.25 v1(32.78,100.82) 33.12,100.82 ; 8.85,92.16 U5401.85 8.85,93.12 ; v1(69.36,96.98) v1(69.36,97.48) ; 35.68,100.29 v1(35.23,100.29) 35.23,100.77 ; v2(49.46,98.84) 49.58,98.72 U1701.A5 U1701.A4 U1701.B4 ; 12.85,76.96 U5401.32 12.85,77.92 ; v1(34.39,82.29) 34.93,82.29 ; 39.15,96.4 C1723.2 ; 30.96,81.79 C1900.2 ; C1915.2 v2(20,91.09) ; v1(63.86,95.48) U1601.E12 U1601.D12 ; C1913.2 v2(20,88.76) ; 30.99,13.22 v1(30.99,13.62) ; 40.3,14.97 C9001.2 41.04,14.97 ; U1701.F5 U1701.E5 ; 20.19,88.02 C1903.2
  BOTTOM w0.305: v2(2.9,120.74) CON2101.23 v2(2.9,118.79) ; v2(10.2,118.82) CON2101.22 10.2,120.21 v2(9.7,120.71) ; v2(7.6,120.17) 7.75,120.01 CON2101.7 7.75,118.19 7.9,118.04 v2(8.05,118.04) ; CON3301.11 v2(11.62,72.97) ; 4.15,69.26 CON2002.18 v2(4.9,68.85) ; CON3301.9 12.62,73.13 v2(12.48,72.98) ; v2(8.41,120.18) 8.35,120.12 CON2101.5 v2(8.35,118.63) ; v2(3.86,123.02) 3.85,123.01 CON2101.20 v2(3.85,121.56) ; v1(39.6,68.18) 40.05,67.74 R2507.2 40.21,67.15 R2509.2 C2762.2 ; v2(5.89,121.6) 5.65,121.84 CON2101.14 v2(5.65,123.01) ; v2(4.8,118.5) 4.75,118.55 CON2101.17 4.75,121.05 v2(4.88,121.18)
  BOTTOM w0.406: v2(87.62,6.73) 87.64,6.74 C7330.2 ; v2(85.34,6.09) 85.08,5.83 C7388.2 ; C7389.2 83.99,6.79 v2(83.9,6.89)
  BOTTOM w0.432: v2(21.59,71.95) 21.59,71.94 21.74,71.8 R1007.1 ; C2101.2 C2127.2 C2102.2 C2122.2 v2(14.24,112.2) ; R1008.1 v2(20.95,71.95) ; v2(16.08,84.52) 16.13,84.46 16.56,84.46 R2540.2 ; v2(17.71,76.87) 17.71,77.35 C5411.2 ; C2819.2 58.1,81.77 C2820.2 56.63,81.77 C2821.2
  BOTTOM w0.457: v2(82.68,4.18) 83.15,3.71 83.27,3.71 C2301.1 ; v2(16.64,112.63) 16.03,112.63 R2104.1 ; v2(88.05,5.18) 88.04,5.19 C7331.2
  BOTTOM w0.508: CON8902.8 20.29,39.05 ; CON8902.8 18.98,38.12 ; CON8902.8 18.98,39.98 ; CON8902.8 17.67,39.05 ; CON5201.7 95.76,62.68 ; CON5201.7 97.06,61.92 ; CON5201.7 94.45,61.92 ; 17.67,55.25 CON8902.7 ; CON8902.7 18.98,54.32 ; CON8902.7 20.29,55.25 ; CON8902.7 18.98,56.18 ; CON0901.20 94.71,45.29 ; CON0901.20 96.15,44.44 ; CON0901.20 93.26,44.44 ; CON0901.20 94.71,43.59 ; CON5201.6 95.76,51.26 ; CON5201.6 94.45,52.02 ; CON5201.6 97.06,52.02 ; CON8001.6 69.43,3.42 ; CON8001.6 68.15,1.9 ; CON8001.6 70.71,1.9 ; CON8001.5 77.58,3.42 ; CON8001.5 78.86,1.9 ; CON8001.5 76.3,1.9 ; 15.44,61.03 U7112.3 ; U7112.3 16.5,61.63 ; U7112.3 16.5,60.43 ; U7112.3 17.55,61.03 ; U5401.G1 v2(15.1,93.81) ; 93.26,36.04 CON0901.21 ; CON0901.21 96.15,36.04 ; CON0901.21 94.71,35.19 ; CON0901.21 94.71,36.89 ; 98.11,36.04 CON0901.23 ; 17.76,7.62 U7911.1 ; U7911.1 19.04,9.9 ; U7911.1 17.76,12.17 ; CON5101.10 18.98,14.33 ; CON5101.10 20.29,13.4 ; CON5101.10 17.67,13.4 ; CON5101.10 18.98,12.47 ; U5401.G2 v2(15.1,76.83) ; 98.11,44.44 CON0901.22 ; 98.29,61.92 CON5201.9 ; U2301.4 85.73,1.85 v2(86.27,2.4) ; CON5101.11 18.98,36.53 ; CON5101.11 18.98,34.67 ; CON5101.11 17.67,35.6 ; CON5101.11 20.29,35.6 ; 15.44,59.76 U7112.4 ; U7112.4 16.5,59.16 ; U7112.4 17.55,59.76 ; U7112.4 16.5,60.36 ; 98.29,52.02 CON5201.8
  vias: v1(1.45,92.19) v1(1.45,91.35) v1(1.45,90.54) v1(1.47,89.67) v1(1.88,81.44) v1(1.93,92.14) v1(1.91,91.35) v1(1.91,90.51) v1(1.93,89.72) v1(4.88,113.94) v1(4.88,113.54) v1(4.89,113.15) v1(4.88,112.79) v1(4.96,117.85) v1(4.96,117.46) v1(4.96,117.06) v1(4.95,116.7) v1(4.99,116.05) v1(4.99,115.65) v1(4.99,115.26) v1(4.98,114.89) v1(5,108.85) v1(5.04,111.75) v1(5.04,111.36) v1(5.04,110.97) v1(5.03,110.6) v1(5.01,110) v1(5.01,109.61) v1(5.01,109.22) v1(5.7,113.91) v1(5.7,113.52) v1(5.7,113.13) v1(5.69,112.76) v1(5.77,117.82) v1(5.77,117.43) v1(5.78,117.04) v1(5.77,116.67) v1(5.8,116.02) v1(5.8,115.63) v1(5.8,115.24) v1(5.79,114.87) v1(5.85,111.73) v1(5.85,111.33) v1(5.85,110.94) v1(5.84,110.58) v1(5.82,109.98) v1(5.82,109.58) v1(5.83,109.19) v1(5.82,108.82) v1(7.09,91.18) v1(7.09,90.88) v1(7.09,90.57) v1(7.09,90.27) v1(7.09,89.96) v1(7.09,89.66) v1(7.09,89.35) v1(7.09,89.05) v1(7.09,88.75) v1(7.06,87.88) v1(7.06,87.58) v1(7.06,87.27) v1(7.06,86.97) v1(7.06,86.66) v1(7.06,86.36) v1(7.06,86.05) v1(7.06,85.75) v1(7.06,85.45) v1(7.01,84.63) v1(7.01,84.33) v1(7.01,84.02) v1(7.01,83.72) v1(7.01,83.42) v1(7.01,83.11) v1(7.01,82.81) v1(7.01,82.5) v1(7.01,82.2) v1(7.04,81.36) v1(7.04,81.06) v1(7.04,80.75) v1(7.04,80.45) v1(7.04,80.14) v1(7.04,79.84) v1(7.04,79.53) v1(7.04,79.23) v1(7.04,78.92) v1(7.3,109.24) v1(7.3,108.84) v1(7.3,108.45) v1(7.29,108.09) v1(7.88,73.93) v1(8.1,108.06) v1(8.08,84.62) v1(8.08,84.31) v1(8.08,84.01) v1(8.08,83.7) v1(8.08,83.4) v1(8.08,83.09) v1(8.08,82.79) v1(8.08,82.48) v1(8.08,82.18) v1(8.1,81.34) v1(8.1,81.04) v1(8.1,80.73) v1(8.1,80.43) v1(8.1,80.12) v1(8.1,79.82) v1(8.1,79.51) v1(8.1,79.21) v1(8.1,78.9) v1(8.11,109.21) v1(8.11,108.82) v1(8.11,108.43) v1(8.15,91.16) v1(8.15,90.86) v1(8.15,90.55) v1(8.15,90.25) v1(8.15,89.94) v1(8.15,89.64) v1(8.15,89.34) v1(8.15,89.03) v1(8.15,88.73) v1(8.13,87.86) v1(8.13,87.56) v1(8.13,87.25) v1(8.13,86.95) v1(8.13,86.64) v1(8.13,86.34) v1(8.13,86.04) v1(8.13,85.73) v1(8.13,85.43) v1(8.16,73.75) v1(8.16,72.48) v1(8.36,72.25) v1(8.77,107.66) v1(8.77,107.27) v1(8.77,106.88) v1(8.76,106.51) v1(8.9,73.75) v1(9.09,84.69) v1(9.09,84.39) v1(9.09,84.08) v1(9.09,83.78) v1(9.09,83.47) v1(9.09,83.17) v1(9.09,82.86) v1(9.09,82.56) v1(9.09,82.25) v1(9.18,98.88) v1(9.18,98.48) v1(9.18,98.09) v1(9.17,97.72) v1(9.17,91.24) v1(9.17,90.94) v1(9.17,90.63) v1(9.17,90.33) v1(9.17,90.02) v1(9.17,89.72) v1(9.17,89.41) v1(9.17,89.11) v1(9.17,88.8) v1(9.14,87.94) v1(9.14,87.64) v1(9.14,87.33) v1(9.14,87.03) v1(9.14,86.72) v1(9.14,86.42) v1(9.14,86.11) v1(9.14,85.81) v1(9.14,85.5) v1(9.12,81.42) v1(9.12,81.11) v1(9.12,80.81) v1(9.12,80.5) v1(9.12,80.2) v1(9.12,79.89) v1(9.12,79.59) v1(9.12,79.28) v1(9.12,78.98) v1(9.23,100.83) v1(9.23,100.44) v1(9.23,100.05) v1(9.22,99.68) v1(9.33,105.76) v1(9.33,105.36) v1(9.33,104.97) v1(9.32,104.61) v1(9.58,107.64) v1(9.58,107.24) v1(9.59,106.85) v1(9.58,106.49) v1(9.99,98.85) v1(9.99,98.46) v1(10.04,100.81) v1(10.04,100.41) v1(10.04,100.02) v1(10.03,99.65) v1(10.14,105.73) v1(10.14,105.34) v1(10.15,104.95) v1(10.14,104.58) v1(10.19,87.91) v1(10.19,87.61) v1(10.19,87.31) v1(10.19,87) v1(10.19,86.7) v1(10.19,86.39) v1(10.19,86.09) v1(10.19,85.78) v1(10.19,85.48) v1(10.14,84.67) v1(10.14,84.36) v1(10.14,84.06) v1(10.14,83.75) v1(10.14,83.45) v1(10.14,83.14) v1(10.14,82.84) v1(10.14,82.53) v1(10.14,82.23) v1(10.16,81.39) v1(10.16,81.09) v1(10.16,80.78) v1(10.16,80.48) v1(10.16,80.17) v1(10.16,79.87) v1(10.16,79.56) v1(10.16,79.26) v1(10.16,78.95) v1(10.19,74.73) v1(10.21,91.21) v1(10.21,90.91) v1(10.21,90.61) v1(10.21,90.3) v1(10.21,90) v1(10.21,89.69) v1(10.21,89.39) v1(10.21,89.08) v1(10.21,88.78) v1(10.47,73.62) v1(10.75,103.55) v1(10.75,103.15) v1(10.76,102.76) v1(10.74,102.4) v1(10.85,100.81) v1(10.85,100.41) v1(10.86,100.02) v1(10.85,99.65) v1(10.96,105.73) v1(10.96,105.34) v1(10.96,104.95) v1(10.95,104.58) v1(11,84.69) v1(11,84.39) v1(11,84.08) v1(11,83.78) v1(11,83.47) v1(11,83.17) v1(11,82.86) v1(11,82.56) v1(11,82.25) v1(11.05,87.94) v1(11.05,87.64) v1(11.05,87.33) v1(11.05,87.03) v1(11.05,86.72) v1(11.05,86.42) v1(11.05,86.11) v1(11.05,85.81) v1(11.05,85.5) v1(11.02,81.42) v1(11.02,81.11) v1(11.02,80.81) v1(11.02,80.5) v1(11.02,80.2) v1(11.02,79.89) v1(11.02,79.59) v1(11.02,79.28) v1(11.02,78.98) v1(11.15,91.18) v1(11.15,90.88) v1(11.15,90.57) v1(11.15,90.27) v1(11.15,89.96) v1(11.15,89.66) v1(11.15,89.35) v1(11.15,89.05) v1(11.15,88.75) v1(11.15,74.3) v1(11.49,103.55) v1(11.49,103.15) v1(11.49,102.76) v1(11.48,102.4) v1(11.57,100.78) v1(11.57,100.39) v1(11.57,100) v1(11.56,99.63) v1(11.67,105.71) v1(11.67,105.31) v1(11.67,104.92) v1(11.66,104.56) v1(11.79,95.65) v1(11.79,95.26) v1(11.8,94.86) v1(11.79,94.5) v1(12.09,91.18) v1(12.09,90.88) v1(12.09,90.57) v1(12.09,90.27) v1(12.09,89.96) v1(12.09,89.66) v1(12.09,89.35) v1(12.09,89.05) v1(12.09,88.75) v1(12.07,87.96) v1(12.07,87.66) v1(12.07,87.35) v1(12.07,87.05) v1(12.07,86.74) v1(12.07,86.44) v1(12.07,86.13) v1(12.07,85.83) v1(12.07,85.52) v1(12.04,84.63) v1(12.04,84.33) v1(12.04,84.02) v1(12.04,83.72) v1(12.04,83.42) v1(12.04,83.11) v1(12.04,82.81) v1(12.04,82.5) v1(12.04,82.2) v1(12.04,81.31) v1(12.04,81) v1(12.04,80.7) v1(12.04,80.39) v1(12.04,80.09) v1(12.04,79.79) v1(12.04,79.48) v1(12.04,79.18) v1(12.04,78.87) v1(12.7,104.43) v1(12.62,74.71) v1(12.71,105.58) v1(12.71,105.19) v1(12.71,104.8) v1(12.95,74.48) v1(13.39,103.57) v1(13.39,103.18) v1(13.4,102.79) v1(13.39,102.42) v1(13.32,96.74) v1(13.32,96.35) v1(13.32,95.96) v1(13.31,95.59) v1(13.52,105.56) v1(13.52,105.16) v1(13.52,104.77) v1(13.51,104.4) v1(13.75,99.79) v1(13.75,99.4) v1(13.75,99) v1(13.74,98.64) v1(14.2,102.4) v1(14.21,103.55) v1(14.21,103.15) v1(14.21,102.76) v1(14.33,105.56) v1(14.33,105.16) v1(14.34,104.77) v1(14.33,104.4) v1(14.5,96.53) v1(14.51,97.68) v1(14.51,97.29) v1(14.51,96.9) v1(15.04,105.53) v1(15.04,105.14) v1(15.05,104.75) v1(15.04,104.38) v1(15.02,103.55) v1(15.02,103.15) v1(15.09,74.35) v1(15.14,74.76) v1(15.6,74.38) v1(15.73,103.52) v1(15.73,103.13) v1(15.73,98.62) v1(15.73,98.23) v1(15.73,97.84) v1(15.72,97.47) v1(15.8,94.62) v1(15.86,100.81) v1(15.86,100.41) v1(15.86,100.02) v1(15.85,99.65) v1(15.81,95.78) v1(15.81,95.38) v1(15.81,94.99) v1(15.88,60.92) v1(15.88,59.65) v1(17.02,74.62) v1(17.48,104.34) v1(17.48,103.94) v1(17.49,103.55) v1(17.48,103.18) v1(17.79,2.18) v1(17.79,1.78) v1(17.79,1.39) v1(17.78,1.03) v1(18.07,7.18) v1(18.07,6.79) v1(18.07,6.4) v1(18.06,6.03) v1(18.07,5.2) v1(18.07,4.81) v1(18.07,4.42) v1(18.06,4.05) v1(18.3,104.31) v1(18.3,103.92) v1(18.3,103.53) v1(18.29,103.16) v1(18.3,3.23) v1(18.3,2.88) v1(18.68,5.35) v1(18.68,4.96) v1(18.68,4.57) v1(18.67,4.2) v1(18.75,7.41) v1(18.75,7.02) v1(18.76,6.62) v1(18.75,6.26) v1(18.78,2.86) v1(18.78,2.47) v1(18.78,2.08) v1(18.77,1.71) v1(18.9,94.67) v1(18.9,94.24) v1(18.9,93.48) v1(18.9,91.2) v1(18.9,87.09) v1(18.9,86.76) v1(18.9,68.82) v1(18.9,68.47) v1(18.85,62.97) v1(18.85,62.59) v1(18.85,62.24) v1(18.85,61.88) v1(18.91,101.94) v1(18.91,101.55) v1(18.92,101.16) v1(18.91,100.79) v1(18.91,98.16) v1(18.91,97.86) v1(18.92,97.57) v1(18.91,97.21) v1(18.91,93.85) v1(18.91,90.81) v1(18.91,90.38) v1(18.91,89.99) v1(18.91,87.85) v1(18.91,87.47) v1(18.95,84.45) v1(18.95,84.11) v1(18.95,83.75) v1(18.95,83.4) v1(18.91,80.8) v1(18.91,80.44) v1(18.92,79.77) v1(18.92,79.43) v1(18.91,77.45) v1(18.91,77.09) v1(18.91,76.7) v1(18.91,76.35) v1(18.91,73.82) v1(18.91,73.46) v1(18.92,72.12) v1(18.92,71.76) v1(18.91,70.4) v1(18.91,70.05) v1(19,18.93) v1(19,18.54) v1(19,18.15) v1(19.1,103.16) v1(19.03,58.1) v1(19.03,57.74) v1(19.03,50.86) v1(19.03,50.47) v1(19.03,50.08) v1(19.02,49.71) v1(19.05,34.25) v1(19.05,33.85) v1(19.05,33.46) v1(19.04,33.1) v1(19.03,17.79) v1(19.08,16.44) v1(19.08,16.05) v1(19.08,15.66) v1(19.07,15.29) v1(19.11,104.31) v1(19.11,103.92) v1(19.11,103.53) v1(19.13,47.63) v1(19.13,47.24) v1(19.13,46.85) v1(19.12,46.48) v1(19.13,35.78) v1(19.13,35.42) v1(19.13,24.55) v1(19.13,24.15) v1(19.13,23.76) v1(19.12,23.39) v1(19.18,22.06) v1(19.18,21.66) v1(19.18,21.27) v1(19.17,20.9) v1(19.2,13.19) v1(19.23,45.09) v1(19.23,44.7) v1(19.23,44.31) v1(19.22,43.94) v1(19.21,13.55) v1(19.38,50.86) v1(19.38,50.47) v1(19.38,50.08) v1(19.37,49.71) v1(19.36,42.25) v1(19.36,41.86) v1(19.36,41.46) v1(19.35,41.1) v1(19.4,31.55) v1(19.4,28.88) v1(19.46,35.78) v1(19.46,35.42) v1(19.41,32.7) v1(19.41,32.31) v1(19.41,31.91) v1(19.41,30.03) v1(19.41,29.64) v1(19.41,29.25) v1(19.46,27.19) v1(19.46,26.79) v1(19.46,26.4) v1(19.45,26.04) v1(19.49,2.51) v1(19.49,2.11) v1(19.49,1.72) v1(19.48,1.36) v1(19.58,23.89) v1(19.58,23.49) v1(19.59,23.1) v1(19.58,22.73) v1(19.54,13.55) v1(19.53,13.19) v1(19.56,11.39) v1(19.56,10.99) v1(19.56,10.6) v1(19.55,10.24) v1(19.57,8.93) v1(19.57,8.54) v1(19.57,8.15) v1(19.56,7.78) v1(19.63,18.4) v1(19.63,18.01) v1(19.64,17.61) v1(19.63,17.25) v1(19.7,14.76) v1(19.79,97.48) v1(19.79,97.08) v1(19.8,96.69) v1(19.79,96.33) v1(19.71,15.91) v1(19.71,15.52) v1(19.71,15.12) v1(19.82,104.29) v1(19.82,103.89) v1(19.82,103.5) v1(19.81,103.13) v1(19.86,45.68) v1(19.86,45.28) v1(19.87,44.89) v1(19.86,44.53) v1(19.86,36.1) v1(19.86,35.78) v1(19.86,35.42) v1(19.86,35.09) v1(19.81,21.52) v1(19.81,21.13) v1(19.82,20.74) v1(19.81,20.37) v1(19.89,13.88) v1(19.89,13.55) v1(19.89,13.19) v1(19.89,12.86) v1(20,85.54) v1(20,85.15) v1(20,84.76) v1(19.99,84.39) v1(19.99,42.83) v1(19.99,42.44) v1(19.99,42.05) v1(19.98,41.68) v1(20.04,33.28) v1(20.04,32.89) v1(20.04,32.5) v1(20.03,32.13) v1(20.04,30.62) v1(20.04,30.22) v1(20.04,29.83) v1(20.03,29.46) v1(20.09,27.77) v1(20.09,27.38) v1(20.09,26.99) v1(20.08,26.62) v1(20.19,50.81) v1(20.17,50.4) v1(20.17,50.02) v1(20.17,49.67) v1(20.19,10.86) v1(20.19,10.46) v1(20.2,10.07) v1(20.19,9.7) v1(20.18,8.65) v1(20.18,8.26) v1(20.18,7.87) v1(20.17,7.5) v1(20.12,1.97) v1(20.12,1.58) v1(20.13,1.19) v1(20.12,0.82) v1(20.22,24.47) v1(20.22,24.08) v1(20.22,23.68) v1(20.21,23.32) v1(20.27,18.98) v1(20.27,18.59) v1(20.27,18.2) v1(20.26,17.83) v1(20.35,16.49) v1(20.35,16.1) v1(20.35,15.71) v1(20.34,15.34) v1(20.5,50.81) v1(20.5,50.42) v1(20.5,50.02) v1(20.49,49.66) v1(20.5,45.2) v1(20.5,44.8) v1(20.5,44.41) v1(20.49,44.04) v1(20.45,22.11) v1(20.45,21.71) v1(20.45,21.32) v1(20.44,20.96) v1(20.63,85.01) v1(20.63,84.61) v1(20.64,84.22) v1(20.63,83.86) v1(20.63,42.35) v1(20.63,41.96) v1(20.63,41.57) v1(20.62,41.2) v1(20.68,32.8) v1(20.68,32.41) v1(20.68,32.02) v1(20.67,31.65) v1(20.68,30.13) v1(20.68,29.74) v1(20.68,29.35) v1(20.67,28.98) v1(20.7,3.49) v1(20.73,95.45) v1(20.73,95.05) v1(20.74,94.66) v1(20.73,94.29) v1(20.8,47.61) v1(20.8,47.22) v1(20.8,46.46) v1(20.73,27.29) v1(20.73,26.9) v1(20.73,26.5) v1(20.72,26.14) v1(20.8,5.78) v1(20.71,4.64) v1(20.71,4.25) v1(20.71,3.86) v1(20.81,46.82) v1(20.85,23.99) v1(20.85,23.59) v1(20.86,23.2) v1(20.85,22.84) v1(20.9,18.5) v1(20.9,18.11) v1(20.9,17.35) v1(20.83,11.44) v1(20.83,11.05) v1(20.83,10.65) v1(20.82,10.29) v1(20.91,17.72) v1(20.98,16.01) v1(20.98,15.62) v1(20.98,15.23) v1(20.97,14.86) v1(20.99,8.5) v1(20.99,8.11) v1(20.99,7.72) v1(20.98,7.35) v1(21.08,21.63) v1(21.08,21.23) v1(21.09,20.84) v1(21.08,20.47) v1(21.27,85.59) v1(21.27,85.2) v1(21.27,84.81) v1(21.26,84.44) v1(21.3,29.41) v1(21.31,30.57) v1(21.31,30.17) v1(21.31,29.78) v1(21.39,27.8) v1(21.39,27.4) v1(21.39,27.01) v1(21.38,26.65) v1(21.37,4.26) v1(21.37,3.87) v1(21.37,3.48) v1(21.36,3.11) v1(21.42,94.71) v1(21.42,94.32) v1(21.42,93.92) v1(21.41,93.56) v1(21.9,85.11) v1(21.9,84.71) v1(21.9,83.96) v1(21.91,84.32) v1(21.98,4.57) v1(21.98,4.17) v1(21.98,3.78) v1(21.97,3.41) v1(22.08,94.58) v1(22.08,94.19) v1(22.08,93.8) v1(22.07,93.43) v1(22.61,85.69) v1(22.61,85.3) v1(22.62,84.91) v1(22.61,84.54) v1(22.77,3.21) v1(22.77,2.85) v1(23.17,85.08) v1(23.17,84.69) v1(23.18,84.3) v1(23.17,83.93) v1(23.21,57.2) v1(23.29,36.81) v1(23.27,36.28) v1(23.27,35.6) v1(23.29,34.81) v1(23.27,34.07) v1(23.29,33.34) v1(23.37,15.66) v1(23.35,4.44) v1(23.35,4.04) v1(23.35,3.65) v1(23.34,3.29) v1(23.57,57.2) v1(23.6,36.28) v1(23.6,35.6) v1(23.6,34.07) v1(23.65,98.33) v1(23.62,97.93) v1(23.7,84.21) v1(23.7,74.03) v1(23.62,36.81) v1(23.62,34.81) v1(23.62,33.34) v1(23.7,15.66) v1(23.71,85.36) v1(23.71,84.97) v1(23.71,84.58) v1(23.9,57.2) v1(23.85,55.05) v1(23.83,3.68) v1(23.83,3.28) v1(23.84,2.89) v1(23.83,2.52) v1(23.95,36.81) v1(23.93,36.28) v1(23.93,35.6) v1(23.95,34.81) v1(23.93,34.07) v1(23.92,33.72) v1(24.09,95.57) v1(24.09,95.18) v1(24.09,94.79) v1(24.08,94.42) v1(24.01,15.53) v1(24.23,57.2) v1(24.21,55.05) v1(24.38,54.26) v1(24.46,99.07) v1(24.54,55.05) v1(24.62,98.04) v1(24.62,97.64) v1(24.62,97.25) v1(24.61,96.89) v1(24.63,5.14) v1(24.74,54.26) v1(24.71,10.32) v1(24.87,55.05) v1(24.95,95.6) v1(24.95,95.2) v1(24.95,94.81) v1(24.94,94.45) v1(25.05,100.59) v1(25.07,54.26) v1(25.21,39.86) v1(25.38,98.01) v1(25.38,97.62) v1(25.39,97.23) v1(25.38,96.86) v1(25.4,54.26) v1(25.39,10.32) v1(25.48,56.27) v1(25.48,55.56) v1(25.48,54.77) v1(25.44,39.71) v1(25.73,102.32) v1(25.73,101.99) v1(25.73,99.1) v1(25.83,56.27) v1(25.83,55.56) v1(25.83,54.77) v1(25.99,97.99) v1(25.99,97.59) v1(26,97.2) v1(25.98,96.83) v1(25.99,95.6) v1(25.99,95.2) v1(26,94.81) v1(25.98,94.45) v1(26.11,100.59) v1(26.16,56.27) v1(26.16,55.56) v1(26.16,54.77) v1(26.49,56.27) v1(26.49,55.56) v1(26.49,54.77) v1(26.59,103.5) v1(26.8,57.23) v1(26.88,94.58) v1(26.88,94.19) v1(26.88,93.8) v1(26.87,93.43) v1(26.9,71.08) v1(26.82,54.26) v1(27,103.5) v1(27.1,51.85) v1(27.1,48.83) v1(27.1,44.64) v1(27.1,41.21) v1(27.1,37.68) v1(27.1,30.74) v1(27.1,27.21) v1(27.1,23.66) v1(27.1,20.15) v1(27.1,16.62) v1(27.15,70.93) v1(27.16,57.23) v1(27.18,54.26) v1(27.11,53.13) v1(27.11,52.65) v1(27.11,52.23) v1(27.11,49.77) v1(27.11,49.46) v1(27.11,49.16) v1(27.11,45.96) v1(27.11,45.65) v1(27.11,45.12) v1(27.11,42.63) v1(27.11,42.15) v1(27.11,41.62) v1(27.11,39.05) v1(27.11,38.65) v1(27.11,38.12) v1(27.11,35.63) v1(27.11,35.15) v1(27.11,34.62) v1(27.11,34.14) v1(27.11,32.13) v1(27.11,31.65) v1(27.11,31.12) v1(27.11,28.63) v1(27.11,28.15) v1(27.11,27.62) v1(27.11,25.13) v1(27.11,24.65) v1(27.11,24.12) v1(27.11,21.63) v1(27.11,21.15) v1(27.11,20.62) v1(27.11,18.13) v1(27.11,17.65) v1(27.11,17.12) v1(27.49,57.23) v1(27.51,54.26) v1(27.69,88.73) v1(27.66,55.51) v1(27.72,103.49) v1(27.74,72.53) v1(27.79,71) v1(27.71,56.27) v1(27.82,57.23) v1(27.84,54.26) v1(27.96,72.69) v1(28.02,95.6) v1(28.02,95.2) v1(28.03,94.81) v1(28.02,94.45) v1(28.07,56.27) v1(28.02,55.51) v1(28.14,103.49) v1(28.19,87.83) v1(28.22,101.38) v1(28.25,99.35) v1(28.25,98.62) v1(28.25,97.88) v1(28.26,89.27) v1(28.4,56.27) v1(28.35,55.51) v1(28.58,71) v1(28.68,55.51) v1(28.73,56.27) v1(28.72,54.8) v1(28.72,50.86) v1(28.72,49.19) v1(28.72,48.86) v1(28.72,10.9) v1(28.86,95.6) v1(28.86,95.2) v1(28.87,94.81) v1(28.86,94.45) v1(28.95,50.71) v1(29.05,49.19) v1(29.05,48.86) v1(29.08,43.04) v1(29.08,26.94) v1(29.08,22.23) v1(29.13,55.92) v1(29.26,54.8) v1(29.23,44.13) v1(29.23,43.83) v1(29.23,43.52) v1(29.26,42.78) v1(29.25,22.46) v1(29.26,10.9) v1(29.3,7.5) v1(29.33,71) v1(29.36,49.19) v1(29.31,27.12) v1(29.49,55.92) v1(29.48,50.86) v1(29.5,31.85) v1(29.54,82.29) v1(29.65,95.65) v1(29.65,95.26) v1(29.65,94.86) v1(29.64,94.5) v1(29.66,49.19) v1(29.73,90.73) v1(29.74,57.18) v1(29.74,54.8) v1(29.74,50.68) v1(29.72,26.35) v1(29.72,26.07) v1(29.72,25.79) v1(29.72,25.51) v1(29.72,25.21) v1(29.74,10.9) v1(29.82,55.92) v1(29.92,52.08) v1(30.08,85.11) v1(30.08,84.71) v1(30.08,84.32) v1(30.07,83.96) v1(30.09,58.53) v1(30.07,57.18) v1(30.09,51.83) v1(30.02,26.35) v1(30.02,26.07) v1(30.02,25.79) v1(30.02,25.51) v1(30.02,25.21) v1(30.1,17.21) v1(30.09,16.9) v1(30.15,55.92) v1(30.22,103.5) v1(30.22,54.8) v1(30.28,27.24) v1(30.28,26.93) v1(30.28,26.63) v1(30.22,10.9) v1(30.4,94.5) v1(30.4,57.18) v1(30.4,26.12) v1(30.35,25.51) v1(30.35,25.21) v1(30.41,95.65) v1(30.41,95.26) v1(30.41,94.86) v1(30.46,86.53) v1(30.46,86.14) v1(30.47,85.75) v1(30.46,85.38) v1(30.58,25.9) v1(30.58,22.9) v1(30.58,19.83) v1(30.56,5.83) v1(30.61,27.24) v1(30.61,26.94) v1(30.61,26.63) v1(30.66,25.51) v1(30.66,25.21) v1(30.76,103.5) v1(30.73,91.73) v1(30.73,72.68) v1(30.77,57.18) v1(30.8,20.01) v1(30.73,16.8) v1(30.81,23.08) v1(30.88,17.03) v1(30.97,86.23) v1(30.97,85.83) v1(30.97,85.44) v1(30.96,85.07) v1(30.96,72.53) v1(31.09,82.29) v1(31.15,95.7) v1(31.15,95.31) v1(31.15,94.92) v1(31.14,94.55) v1(31.17,59.3) v1(31.24,103.5) v1(31.22,89.23) v1(31.5,71.08) v1(31.5,9.46) v1(31.42,4.18) v1(31.7,2.75) v1(31.7,2.42) v1(31.7,2.07) v1(31.7,1.74) v1(31.72,103.5) v1(31.73,70.93) v1(32,94.55) v1(31.97,6.62) v1(31.93,5.55) v1(32,4.76) v1(32.01,95.7) v1(32.01,95.31) v1(32.01,94.92) v1(32.01,61.43) v1(32.08,5.81) v1(32.06,2.75) v1(32.06,2.42) v1(32.06,2.06) v1(32.06,1.73) v1(32.22,90.23) v1(32.22,10.9) v1(32.23,4.1) v1(32.36,43.41) v1(32.46,68.06) v1(32.63,62.99) v1(32.79,54.8) v1(32.76,43.01) v1(32.76,10.9) v1(32.92,23.89) v1(32.92,23.58) v1(32.92,23.25) v1(32.92,22.95) v1(33.1,54.8) v1(33.08,40.37) v1(33.08,40.06) v1(33.08,39.76) v1(33.08,39.46) v1(33.08,39.15) v1(33.12,68.03) v1(33.14,57.21) v1(33.22,88.76) v1(33.22,23.89) v1(33.22,23.58) v1(33.22,23.25) v1(33.22,22.95) v1(33.24,10.9) v1(33.38,65.03) v1(33.4,54.8) v1(33.33,2.75) v1(33.32,2.12) v1(33.49,57.21) v1(33.45,40.37) v1(33.45,40.07) v1(33.45,39.76) v1(33.45,39.46) v1(33.45,39.15) v1(33.6,85.46) v1(33.55,45.96) v1(33.54,24.54) v1(33.54,24.24) v1(33.53,23.89) v1(33.53,23.58) v1(33.53,23.25) v1(33.53,22.95) v1(33.61,86.61) v1(33.61,86.21) v1(33.62,85.82) v1(33.76,103.44) v1(33.78,71.08) v1(33.72,54.8) v1(33.78,40.37) v1(33.78,40.07) v1(33.78,39.76) v1(33.78,39.46) v1(33.78,39.15) v1(33.72,10.9) v1(33.82,57.21) v1(33.86,24.24) v1(33.98,65.03) v1(33.96,45.96) v1(34.01,70.93) v1(34.12,86.2) v1(34.12,85.81) v1(34.12,85.42) v1(34.11,85.05) v1(34.15,61.08) v1(34.16,24.24) v1(34.2,6.2) v1(34.16,2.75) v1(34.18,2.17) v1(34.24,103.44) v1(34.27,23.86) v1(34.27,23.56) v1(34.27,23.23) v1(34.27,22.92) v1(34.37,95.7) v1(34.37,95.31) v1(34.38,94.92) v1(34.37,94.55) v1(34.31,49.59) v1(34.39,5.55) v1(34.47,24.24) v1(34.56,49.44) v1(34.57,23.86) v1(34.57,23.56) v1(34.57,23.23) v1(34.57,22.92) v1(34.52,20.02) v1(34.54,5.78) v1(34.67,103.44) v1(34.66,68.49) v1(34.64,45.93) v1(34.62,41.08) v1(34.62,13.7) v1(34.62,13.29) v1(34.78,92.86) v1(34.78,92.46) v1(34.78,92.07) v1(34.77,91.7) v1(34.78,91.23) v1(34.78,90.84) v1(34.78,90.44) v1(34.77,90.08) v1(34.72,25.52) v1(34.72,25.24) v1(34.75,19.87) v1(34.87,23.86) v1(34.87,23.56) v1(34.87,23.23) v1(34.87,22.92) v1(34.82,6.19) v1(35.08,103.44) v1(35.05,5.55) v1(35.2,49.28) v1(35.12,45.93) v1(35.17,42.78) v1(35.2,5.78) v1(35.15,2.78) v1(35.17,2.1) v1(35.26,57.2) v1(35.22,25.52) v1(35.22,25.23) v1(35.34,71.09) v1(35.33,42.56) v1(35.43,50.43) v1(35.42,7) v1(35.46,6.36) v1(35.56,70.87) v1(35.64,54.8) v1(35.66,50.28) v1(35.75,88.41) v1(35.75,88.02) v1(35.75,87.63) v1(35.74,87.26) v1(35.72,10.9) v1(35.9,54.8) v1(36.1,92.63) v1(36.1,92.23) v1(36.1,91.84) v1(36.09,91.48) v1(36.1,90.75) v1(36.1,90.35) v1(36.1,89.96) v1(36.09,89.6) v1(36.2,107.94) v1(36.2,87.23) v1(36.21,109.1) v1(36.21,108.7) v1(36.21,108.31) v1(36.21,93.74) v1(36.26,54.8) v1(36.27,38.54) v1(36.26,10.9) v1(36.44,50.28) v1(36.58,65.9) v1(36.6,45.58) v1(36.57,38.24) v1(36.64,57.2) v1(36.7,50.13) v1(36.75,45.32) v1(36.74,10.9) v1(36.71,2.69) v1(36.71,2.36) v1(36.71,2.01) v1(36.71,1.68) v1(36.86,54.8) v1(36.93,4.86) v1(37.02,109.07) v1(37.02,108.68) v1(37.02,108.29) v1(37.01,107.92) v1(37.07,2.69) v1(37.07,2.36) v1(37.07,2) v1(37.07,1.67) v1(37.16,20.41) v1(37.14,19.95) v1(37.14,19.47) v1(37.16,18.78) v1(37.14,18.32) v1(37.14,17.84) v1(37.22,103.5) v1(37.25,47.76) v1(37.24,42.25) v1(37.22,10.9) v1(37.36,50.48) v1(37.31,45.35) v1(37.39,43.01) v1(37.49,47.91) v1(37.5,45.53) v1(37.41,21.94) v1(37.41,21.21) v1(37.47,4.15) v1(37.51,50.25) v1(37.56,21.72) v1(37.56,20.98) v1(37.57,20.41) v1(37.57,19.95) v1(37.57,19.47) v1(37.57,18.78) v1(37.57,18.32) v1(37.57,17.84) v1(37.56,8.55) v1(37.59,5.53) v1(37.54,4.86) v1(37.61,7.79) v1(37.64,6.92) v1(37.76,103.5) v1(37.74,9.67) v1(37.74,5.76) v1(37.83,109.07) v1(37.83,108.68) v1(37.84,108.29) v1(37.83,107.92) v1(38,47.29) v1(38.07,111.04) v1(38.07,110.64) v1(38.07,110.25) v1(38.06,109.89) v1(38.17,57.17) v1(38.2,7.25) v1(38.2,6.54) v1(38.2,5.17) v1(38.21,103.52) v1(38.25,8.57) v1(38.23,5.75) v1(38.35,20.47) v1(38.32,20.01) v1(38.55,109.05) v1(38.55,108.65) v1(38.55,108.26) v1(38.54,107.89) v1(38.53,57.17) v1(38.7,103.52) v1(38.75,20.47) v1(38.75,20.01) v1(38.74,2.92) v1(38.88,111.01) v1(38.88,110.62) v1(38.88,110.23) v1(38.87,109.86) v1(38.88,59.59) v1(38.83,57.17) v1(38.91,8.12) v1(38.96,2.7) v1(39.26,36.36) v1(39.26,35.62) v1(39.21,22.88) v1(39.21,20.47) v1(39.21,20.01) v1(39.22,10.9) v1(39.37,49.57) v1(39.36,23.11) v1(39.42,36.1) v1(39.42,35.39) v1(39.52,100.21) v1(39.6,99.48) v1(39.59,97.9) v1(39.59,97.14) v1(39.59,96.45) v1(39.59,26.83) v1(39.59,26.09) v1(39.69,111.01) v1(39.69,110.62) v1(39.69,110.23) v1(39.68,109.86) v1(39.62,49.41) v1(39.62,34.83) v1(39.62,34.53) v1(39.62,34.22) v1(39.62,33.69) v1(39.62,33.39) v1(39.62,33.08) v1(39.76,54.69) v1(39.72,52.51) v1(39.74,27.09) v1(39.76,10.9) v1(39.82,36.59) v1(39.82,36.28) v1(39.83,35.98) v1(39.85,35.67) v1(39.85,35.37) v1(40,111.74) v1(39.95,34.83) v1(39.95,34.53) v1(39.95,34.22) v1(39.95,33.69) v1(39.95,33.39) v1(39.95,33.08) v1(40.01,112.9) v1(40.01,112.5) v1(40.01,112.11) v1(40.15,52.51) v1(40.15,36.59) v1(40.15,36.28) v1(40.16,35.98) v1(40.18,35.67) v1(40.18,35.37) v1(40.3,103.56) v1(40.24,54.69) v1(40.24,10.9) v1(40.4,110.99) v1(40.4,110.59) v1(40.4,109.84) v1(40.33,34.73) v1(40.33,34.43) v1(40.34,34.12) v1(40.33,33.77) v1(40.34,33.46) v1(40.41,110.2) v1(40.46,36.59) v1(40.46,36.28) v1(40.46,35.98) v1(40.48,35.65) v1(40.48,35.34) v1(40.49,35.04) v1(40.58,57.19) v1(40.58,15.1) v1(40.58,14.36) v1(40.69,102.02) v1(40.63,54.69) v1(40.66,34.73) v1(40.66,34.43) v1(40.67,34.12) v1(40.66,33.77) v1(40.66,25.08) v1(40.66,24.34) v1(40.67,22.16) v1(40.78,103.56) v1(40.79,36.59) v1(40.79,36.28) v1(40.79,35.98) v1(40.76,14.84) v1(40.76,14.11) v1(40.72,10.9) v1(40.82,112.87) v1(40.82,112.48) v1(40.82,112.09) v1(40.81,111.72) v1(40.81,35.65) v1(40.81,35.34) v1(40.82,35.04) v1(40.81,26.81) v1(40.81,26.07) v1(40.81,25.33) v1(40.81,24.6) v1(40.82,22.39) v1(40.94,70.1) v1(40.92,57.19) v1(41.08,61.19) v1(41.12,50.35) v1(41.12,49.92) v1(41.28,102.02) v1(41.27,57.19) v1(41.27,2.78) v1(41.33,54.67) v1(41.44,70.1) v1(41.6,57.19) v1(41.57,38.36) v1(41.63,112.87) v1(41.63,112.48) v1(41.64,112.09) v1(41.63,111.72) v1(41.62,103.56) v1(41.93,16.9) v1(41.91,16.44) v1(42.15,103.56) v1(42.11,38.36) v1(42.26,58.78) v1(42.21,21.63) v1(42.35,112.85) v1(42.35,112.45) v1(42.35,112.06) v1(42.34,111.69) v1(42.36,21.4) v1(42.34,16.9) v1(42.34,16.44) v1(42.31,2.1) v1(42.44,48.04) v1(42.44,47.66) v1(42.6,68.38) v1(42.55,5.26) v1(42.55,4.92) v1(42.69,66.2) v1(42.62,64.01) v1(42.64,3.5) v1(42.64,3.16) v1(42.73,102.04) v1(42.72,65.44) v1(42.72,27.77) v1(42.79,16.9) v1(42.79,16.44) v1(42.72,10.9) v1(42.9,54.88) v1(42.85,5.26) v1(42.85,4.92) v1(42.95,43.5) v1(42.97,27.62) v1(42.93,3.5) v1(42.93,3.16) v1(43.06,47.99) v1(43.05,42.51) v1(43.05,6.94) v1(43.23,54.88) v1(43.29,47.84) v1(43.3,43.5) v1(43.3,42.35) v1(43.26,10.9) v1(43.38,52.51) v1(43.46,102.04) v1(43.5,37.19) v1(43.47,25.9) v1(43.47,25.62) v1(43.54,96.48) v1(43.58,95.48) v1(43.58,92.48) v1(43.51,91.98) v1(43.58,90.98) v1(43.59,40.8) v1(43.58,17.77) v1(43.64,112.9) v1(43.64,112.5) v1(43.64,112.11) v1(43.63,111.74) v1(43.61,93.91) v1(43.68,52.53) v1(43.76,37.04) v1(43.73,35.6) v1(43.74,10.9) v1(43.84,57.27) v1(43.81,17.61) v1(43.97,25.9) v1(43.97,25.62) v1(44.05,90.99) v1(44.11,94.94) v1(44.19,57.27) v1(44.17,54.87) v1(44.22,103.5) v1(44.26,102.04) v1(44.29,40.55) v1(44.22,10.9) v1(44.32,38.13) v1(44.45,112.87) v1(44.45,112.48) v1(44.45,112.09) v1(44.44,111.72) v1(44.41,54.63) v1(44.49,37.88) v1(44.58,94.97) v1(44.58,94.48) v1(44.58,59.22) v1(44.55,36.33) v1(44.67,46.14) v1(44.65,45.1) v1(44.67,40.55) v1(44.76,103.5) v1(44.9,44.94) v1(44.99,102.04) v1(44.97,25.93) v1(44.97,25.59) v1(45.08,97.98) v1(45.08,91.48) v1(45.26,112.87) v1(45.26,112.48) v1(45.27,112.09) v1(45.26,111.72) v1(45.29,59.22) v1(45.25,26.97) v1(45.31,103.5) v1(45.54,40.52) v1(45.59,26.97) v1(45.65,92.03) v1(45.65,89.93) v1(45.67,57.11) v1(45.66,35.62) v1(45.66,34.62) v1(45.8,103.5) v1(45.98,112.85) v1(45.98,112.45) v1(45.98,112.06) v1(45.97,111.69) v1(45.99,61.09) v1(45.92,40.52) v1(45.95,35.62) v1(45.95,34.62) v1(46.08,97.98) v1(46.08,96.48) v1(46.08,95.98) v1(46.08,95.48) v1(46.06,94.54) v1(46.08,92.98) v1(46.13,89.98) v1(46.3,45.99) v1(46.25,30.47) v1(46.22,10.9) v1(46.58,92.48) v1(46.68,17.51) v1(46.73,54.8) v1(46.73,33.23) v1(46.78,30.47) v1(46.76,10.9) v1(46.86,40.55) v1(46.86,17.22) v1(47.07,83.93) v1(47.06,54.8) v1(47.01,17.51) v1(47.09,9.62) v1(47.14,49.08) v1(47.19,33.23) v1(47.19,17.22) v1(47.27,112.94) v1(47.27,112.54) v1(47.27,112.15) v1(47.26,111.79) v1(47.27,109.01) v1(47.27,108.62) v1(47.27,108.23) v1(47.26,107.86) v1(47.24,40.55) v1(47.21,15.53) v1(47.24,10.9) v1(47.39,54.79) v1(47.39,30.47) v1(47.32,9.47) v1(47.43,39.91) v1(47.48,26.97) v1(47.47,22.92) v1(47.58,89.98) v1(47.52,59.39) v1(47.57,57.23) v1(47.6,39.66) v1(47.54,15.53) v1(47.7,54.8) v1(47.69,46.66) v1(47.7,46.16) v1(47.68,38.11) v1(47.68,37.83) v1(47.65,23.17) v1(47.72,103.5) v1(47.73,50.36) v1(47.8,49.28) v1(47.8,48.96) v1(47.75,45.68) v1(47.75,45.02) v1(47.75,44.56) v1(47.72,43.9) v1(47.72,43.42) v1(47.72,10.9) v1(47.72,4.53) v1(47.91,83.93) v1(47.82,48.37) v1(47.82,47.99) v1(47.82,26.97) v1(47.88,9.62) v1(47.85,5.56) v1(47.85,5.16) v1(47.92,57.23) v1(47.93,50.62) v1(47.97,49.56) v1(47.97,46.85) v1(47.95,45.99) v1(47.93,33.23) v1(47.93,30.47) v1(47.93,15.53) v1(47.95,4.38) v1(48.08,112.91) v1(48.08,112.52) v1(48.09,112.13) v1(48.08,111.76) v1(48.08,108.99) v1(48.08,108.59) v1(48.09,108.2) v1(48.08,107.83) v1(48.08,97.98) v1(48.08,95.98) v1(48.08,92.48) v1(48.08,90.98) v1(48.05,44.89) v1(48.18,85.96) v1(48.11,9.47) v1(48.26,103.5) v1(48.21,61.07) v1(48.21,60.23) v1(48.21,59.42) v1(48.21,52.69) v1(48.28,33.23) v1(48.32,57.24) v1(48.36,36.56) v1(48.41,13.24) v1(48.58,95.98) v1(48.58,90.98) v1(48.52,90.47) v1(48.57,52.69) v1(48.51,20.15) v1(48.56,13.5) v1(48.67,57.24) v1(48.74,20) v1(48.71,1.79) v1(48.9,112.91) v1(48.9,112.52) v1(48.9,112.13) v1(48.89,111.76) v1(48.9,108.99) v1(48.9,108.59) v1(48.9,108.2) v1(48.89,107.83) v1(48.81,103.5) v1(48.84,24.62) v1(48.81,9.72) v1(48.99,24.37) v1(48.96,3.57) v1(49.08,95.98) v1(49.08,92.48) v1(49.03,89.98) v1(49.07,52.69) v1(49.09,12.76) v1(49.09,6.82) v1(49.3,103.5) v1(49.4,52.69) v1(49.32,26.35) v1(49.39,23.73) v1(49.32,12.61) v1(49.6,111.74) v1(49.6,107.81) v1(49.58,94.98) v1(49.58,94.07) v1(49.58,92.98) v1(49.58,92.48) v1(49.53,20.15) v1(49.61,112.89) v1(49.61,112.49) v1(49.61,112.1) v1(49.61,108.96) v1(49.61,108.57) v1(49.61,108.18) v1(49.62,94.59) v1(49.63,54.83) v1(49.66,26.35) v1(49.68,19.9) v1(49.73,61.07) v1(49.73,60.31) v1(49.71,52.66) v1(49.72,10.9) v1(49.86,12.76) v1(49.94,54.83) v1(49.98,1.89) v1(50.08,92.54) v1(50.09,89.94) v1(50.2,111.3) v1(50.2,110.91) v1(50.2,110.15) v1(50.19,86.5) v1(50.19,52.69) v1(50.11,12.61) v1(50.19,9.77) v1(50.21,110.52) v1(50.24,54.83) v1(50.26,10.9) v1(50.29,6.85) v1(50.48,109) v1(50.48,108.61) v1(50.48,108.21) v1(50.47,107.85) v1(50.5,52.69) v1(50.49,27.47) v1(50.49,27.16) v1(50.49,26.32) v1(50.49,25.97) v1(50.49,24.83) v1(50.6,112.9) v1(50.6,112.5) v1(50.6,111.74) v1(50.55,54.83) v1(50.51,25.38) v1(50.51,24.24) v1(50.51,23.73) v1(50.61,112.11) v1(50.62,12.76) v1(50.62,1.89) v1(50.76,103.63) v1(50.8,52.69) v1(50.78,32.62) v1(50.74,10.9) v1(50.87,12.61) v1(51,57.3) v1(51.02,111.28) v1(51.02,110.88) v1(51.02,110.49) v1(51.01,110.12) v1(51.08,97.98) v1(51.08,96.98) v1(51.08,96.48) v1(51.08,32.62) v1(51.29,108.97) v1(51.29,108.58) v1(51.29,108.19) v1(51.28,107.82) v1(51.25,103.63) v1(51.25,59.56) v1(51.22,10.9) v1(51.36,61.05) v1(51.36,60.44) v1(51.37,57.28) v1(51.31,52.69) v1(51.42,112.87) v1(51.42,112.48) v1(51.42,112.09) v1(51.41,111.72) v1(51.58,97.48) v1(51.58,96.98) v1(51.58,96.48) v1(51.58,95.48) v1(51.58,94.98) v1(51.58,92.48) v1(51.58,91.48) v1(51.61,52.69) v1(51.63,1.89) v1(51.76,9.77) v1(51.86,57.28) v1(51.92,52.69) v1(52.09,103.63) v1(52.01,4.13) v1(52.18,57.27) v1(52.23,112.87) v1(52.23,112.48) v1(52.23,112.09) v1(52.22,111.72) v1(52.32,13.73) v1(52.32,13.42) v1(52.32,13.12) v1(52.4,5.27) v1(52.4,4.89) v1(52.4,4.51) v1(52.4,3.88) v1(52.6,52.69) v1(52.52,20.08) v1(52.52,1.89) v1(52.62,103.63) v1(52.66,31.45) v1(52.72,109.55) v1(52.72,109.15) v1(52.72,108.76) v1(52.71,108.4) v1(52.76,84.31) v1(52.79,37.31) v1(52.79,37.01) v1(52.75,19.92) v1(52.78,12.61) v1(52.81,86.85) v1(52.85,36.38) v1(52.85,36.07) v1(52.94,112.85) v1(52.94,112.45) v1(52.94,112.06) v1(52.93,111.69) v1(52.91,52.69) v1(52.95,31.45) v1(52.93,12.36) v1(53.1,37.31) v1(53.1,37.01) v1(53.14,101.91) v1(53.11,54.68) v1(53.15,36.38) v1(53.15,36.07) v1(53.22,111.33) v1(53.22,110.94) v1(53.23,110.55) v1(53.22,110.18) v1(53.21,52.69) v1(53.25,31.45) v1(53.22,10.9) v1(53.28,5.15) v1(53.28,4.38) v1(53.28,3.75) v1(53.37,58.76) v1(53.31,20.08) v1(53.53,109.52) v1(53.53,109.13) v1(53.53,108.74) v1(53.52,108.37) v1(53.52,25.71) v1(53.52,25.21) v1(53.54,24.67) v1(53.54,24.36) v1(53.54,24.06) v1(53.54,23.28) v1(53.59,22.13) v1(53.54,19.92) v1(53.56,14.29) v1(53.64,54.68) v1(53.72,14.54) v1(53.76,10.9) v1(53.87,101.91) v1(53.81,25.71) v1(53.81,25.21) v1(53.83,24.67) v1(53.83,24.36) v1(53.83,24.06) v1(53.83,23.28) v1(53.88,3.24) v1(53.88,2.85) v1(53.92,4.76) v1(53.92,4.13) v1(54.1,111.83) v1(54.04,111.31) v1(54.04,110.91) v1(54.04,110.52) v1(54.03,110.16) v1(54.05,22.13) v1(54.05,20.08) v1(54.11,112.98) v1(54.11,112.59) v1(54.11,112.2) v1(54.17,57.31) v1(54.12,54.68) v1(54.28,86.65) v1(54.28,19.92) v1(54.24,10.9) v1(54.28,8.88) v1(54.36,109.05) v1(54.36,108.66) v1(54.37,108.27) v1(54.35,107.9) v1(54.32,103.49) v1(54.47,57.31) v1(54.55,54.73) v1(54.61,101.15) v1(54.65,52.57) v1(54.78,103.49) v1(54.8,57.31) v1(54.72,10.9) v1(54.76,6.09) v1(54.76,5.75) v1(54.85,111.31) v1(54.85,110.91) v1(54.85,110.52) v1(54.84,110.16) v1(54.83,20.08) v1(54.89,8.27) v1(54.89,6.54) v1(54.92,112.96) v1(54.92,112.56) v1(54.92,112.17) v1(54.91,111.8) v1(54.93,52.36) v1(55.09,19.92) v1(55.18,109.03) v1(55.18,108.64) v1(55.18,108.24) v1(55.17,107.88) v1(55.14,61.05) v1(55.14,60.28) v1(55.14,59.57) v1(55.11,57.31) v1(55.26,103.5) v1(55.32,17.18) v1(55.32,12.61) v1(55.32,3.75) v1(55.43,52.56) v1(55.47,12.38) v1(55.56,111.28) v1(55.56,110.89) v1(55.56,110.5) v1(55.55,110.13) v1(55.54,30.39) v1(55.54,30.08) v1(55.67,17.18) v1(55.66,3.29) v1(55.73,112.96) v1(55.73,112.56) v1(55.74,112.17) v1(55.73,111.8) v1(55.77,103.48) v1(55.72,52.35) v1(55.8,6.56) v1(55.83,30.08) v1(55.85,25.78) v1(55.82,20.33) v1(55.9,13.73) v1(55.9,13.42) v1(55.9,13.14) v1(55.82,3.75) v1(55.99,109.03) v1(55.99,108.64) v1(55.99,108.24) v1(55.98,107.88) v1(56.08,20.15) v1(56.03,17.18) v1(56.12,101.16) v1(56.29,6.54) v1(56.45,112.93) v1(56.45,112.54) v1(56.45,112.14) v1(56.44,111.78) v1(56.56,6.09) v1(56.56,5.75) v1(56.7,109) v1(56.7,108.61) v1(56.7,108.22) v1(56.69,107.85) v1(56.67,6.54) v1(56.76,54.7) v1(56.74,20.08) v1(56.71,17.66) v1(56.72,10.9) v1(56.85,101.16) v1(56.97,19.9) v1(56.97,17.51) v1(57,6.54) v1(57.1,41.39) v1(57.1,41.09) v1(57.1,40.78) v1(57.09,8.14) v1(57.2,59.33) v1(57.24,58.93) v1(57.25,54.7) v1(57.26,10.9) v1(57.25,3.88) v1(57.38,99.63) v1(57.4,98.89) v1(57.38,98.08) v1(57.4,8.83) v1(57.38,6.51) v1(57.49,111.21) v1(57.49,110.81) v1(57.49,110.42) v1(57.48,110.06) v1(57.44,61.02) v1(57.46,60.31) v1(57.45,13.14) v1(57.45,5.4) v1(57.61,112.94) v1(57.61,112.54) v1(57.62,112.15) v1(57.61,111.79) v1(57.63,101.94) v1(57.61,57.29) v1(57.63,12.91) v1(57.65,3.85) v1(57.73,54.7) v1(57.74,10.9) v1(57.79,6.54) v1(57.92,57.29) v1(58.09,54.7) v1(58.09,8.14) v1(58.17,60.21) v1(58.14,20.69) v1(58.3,111.18) v1(58.3,110.79) v1(58.3,110.4) v1(58.29,110.03) v1(58.22,103.5) v1(58.25,25.78) v1(58.25,25.47) v1(58.25,25.18) v1(58.25,24.64) v1(58.25,24.33) v1(58.25,24.04) v1(58.23,22.22) v1(58.22,21.89) v1(58.22,10.9) v1(58.36,6.09) v1(58.36,5.75) v1(58.43,112.91) v1(58.43,112.52) v1(58.43,112.13) v1(58.42,111.76) v1(58.43,23.21) v1(58.45,22.88) v1(58.47,4.97) v1(58.62,8.73) v1(58.7,6.82) v1(58.76,103.5) v1(58.8,16.57) v1(58.92,20.08) v1(59.1,110.03) v1(59.11,111.18) v1(59.11,110.79) v1(59.11,110.4) v1(59.11,101.1) v1(59.21,40.6) v1(59.21,40.31) v1(59.14,29.67) v1(59.14,29.36) v1(59.11,24.41) v1(59.11,24.12) v1(59.15,16.57) v1(59.24,112.91) v1(59.24,112.52) v1(59.24,112.13) v1(59.23,111.76) v1(59.25,6.82) v1(59.31,103.52) v1(59.33,8.17) v1(59.43,29.67) v1(59.43,29.36) v1(59.42,24.41) v1(59.42,24.12) v1(59.56,84.97) v1(59.69,60.89) v1(59.64,57.3) v1(59.66,20.08) v1(59.8,103.52) v1(59.72,60.18) v1(59.77,20.69) v1(59.82,111.16) v1(59.82,110.76) v1(59.83,110.37) v1(59.82,110.01) v1(59.85,101.11) v1(59.84,16.09) v1(59.95,112.89) v1(59.95,112.49) v1(59.95,112.1) v1(59.94,111.74) v1(59.94,57.3) v1(60.1,50.49) v1(60.1,50.16) v1(60.1,49.83) v1(60.09,15.94) v1(60.15,108.93) v1(60.15,108.53) v1(60.15,108.14) v1(60.14,107.78) v1(60.13,49.37) v1(60.13,49.04) v1(60.13,48.71) v1(60.13,48.29) v1(60.13,47.96) v1(60.13,47.63) v1(60.13,47.16) v1(60.13,46.83) v1(60.13,46.5) v1(60.22,10.9) v1(60.36,25.31) v1(60.36,25.02) v1(60.36,24.74) v1(60.39,24.36) v1(60.39,24.06) v1(60.39,23.78) v1(60.42,54.81) v1(60.42,20.08) v1(60.59,101.95) v1(60.54,26.44) v1(60.54,26.16) v1(60.55,16.87) v1(60.76,10.9) v1(60.86,28.74) v1(60.86,28.46) v1(60.86,28.13) v1(60.85,27.56) v1(60.84,27.28) v1(60.84,26.97) v1(60.85,26.44) v1(60.85,16.87) v1(60.96,108.9) v1(60.96,108.51) v1(60.96,108.12) v1(60.95,107.75) v1(60.96,85.38) v1(60.95,54.81) v1(61.08,112.98) v1(61.08,112.59) v1(61.08,112.2) v1(61.07,111.83) v1(61.03,111.33) v1(61.03,110.94) v1(61.04,110.55) v1(61.03,110.18) v1(61.05,50.48) v1(61.05,50.15) v1(61.05,49.82) v1(61.07,49.31) v1(61.07,48.98) v1(61.07,48.65) v1(61.05,48.19) v1(61.05,47.86) v1(61.05,47.53) v1(61.05,47.13) v1(61.05,46.8) v1(61.05,46.47) v1(61.24,10.9) v1(61.35,101.95) v1(61.34,96.46) v1(61.31,95.52) v1(61.36,93.98) v1(61.38,92.48) v1(61.36,91.98) v1(61.36,90.98) v1(61.34,90.48) v1(61.44,54.81) v1(61.77,108.9) v1(61.77,108.51) v1(61.77,108.12) v1(61.76,107.75) v1(61.72,103.5) v1(61.72,10.9) v1(61.76,3.51) v1(61.76,3.12) v1(61.89,112.96) v1(61.89,112.56) v1(61.89,112.17) v1(61.88,111.8) v1(61.85,111.31) v1(61.85,110.91) v1(61.85,110.52) v1(61.84,110.16) v1(61.86,90.98) v1(61.88,57.25) v1(61.92,54.81) v1(62.04,41.31) v1(62.04,41.01) v1(62.04,40.7) v1(62.04,40.12) v1(62.04,39.81) v1(62.26,103.5) v1(62.33,90.46) v1(62.31,51.99) v1(62.31,51.23) v1(62.48,108.88) v1(62.48,108.48) v1(62.49,108.09) v1(62.48,107.73) v1(62.55,57.3) v1(62.54,52.5) v1(62.55,51.7) v1(62.54,50.96) v1(62.6,15.78) v1(62.51,9.69) v1(62.7,112.96) v1(62.7,112.56) v1(62.7,112.17) v1(62.69,111.8) v1(62.66,111.31) v1(62.66,110.91) v1(62.66,110.52) v1(62.65,110.16) v1(62.87,103.5) v1(62.86,97.98) v1(62.86,57.3) v1(62.87,9.69) v1(62.9,4.87) v1(62.92,91.48) v1(62.93,22.44) v1(63.05,53.23) v1(63.04,22.13) v1(63.03,2.57) v1(63.15,32.13) v1(63.25,53.8) v1(63.22,22.44) v1(63.4,111.78) v1(63.37,111.28) v1(63.37,110.89) v1(63.37,110.5) v1(63.36,110.13) v1(63.35,103.5) v1(63.36,91.98) v1(63.32,89.98) v1(63.38,82.34) v1(63.35,57.29) v1(63.41,112.93) v1(63.41,112.54) v1(63.41,112.14) v1(63.45,58.81) v1(63.41,37.11) v1(63.41,36.8) v1(63.45,31.83) v1(63.52,53.46) v1(63.6,36.21) v1(63.6,35.91) v1(63.63,30.54) v1(63.8,92.98) v1(63.73,57.16) v1(63.72,37.11) v1(63.72,36.8) v1(63.75,31.83) v1(63.72,10.9) v1(63.86,97.98) v1(63.86,94.48) v1(63.89,13.93) v1(63.88,13.57) v1(63.96,89.98) v1(63.95,54.78) v1(63.97,52.36) v1(63.91,36.21) v1(63.91,35.91) v1(64.18,52.11) v1(64.19,30.54) v1(64.21,36.21) v1(64.21,35.91) v1(64.24,31.82) v1(64.26,10.9) v1(64.36,95.98) v1(64.36,92.48) v1(64.38,52.36) v1(64.31,18.12) v1(64.49,54.78) v1(64.44,20.43) v1(64.57,52.11) v1(64.54,37.11) v1(64.54,36.8) v1(64.54,31.82) v1(64.54,17.97) v1(64.67,57.28) v1(64.74,10.9) v1(64.86,95.98) v1(64.85,61.35) v1(64.85,37.11) v1(64.85,36.8) v1(64.85,31.83) v1(64.99,66.16) v1(64.97,54.78) v1(64.97,22.87) v1(65.06,58.79) v1(65.09,52.39) v1(65.15,86.85) v1(65.22,103.5) v1(65.3,52.1) v1(65.26,27.22) v1(65.26,26.92) v1(65.22,10.9) v1(65.36,89.98) v1(65.45,54.78) v1(65.56,71.35) v1(65.54,69.65) v1(65.58,68.91) v1(65.6,63.57) v1(65.58,62.82) v1(65.53,53.02) v1(65.51,52.38) v1(65.53,42.96) v1(65.55,27.22) v1(65.55,26.92) v1(65.76,103.5) v1(65.8,65.33) v1(65.71,62.19) v1(65.77,58.76) v1(65.71,52.11) v1(65.71,13.09) v1(65.86,97.98) v1(65.86,92.48) v1(65.81,63.08) v1(65.97,57.3) v1(66.29,85.33) v1(66.27,68.18) v1(66.31,103.52) v1(66.31,96) v1(66.36,90.48) v1(66.31,61.39) v1(66.33,57.3) v1(66.36,29.09) v1(66.47,24.17) v1(66.52,65.35) v1(66.52,21.75) v1(66.69,57.3) v1(66.8,103.52) v1(66.8,92.54) v1(66.86,89.98) v1(67.05,68.92) v1(67.24,68.58) v1(67.26,63.84) v1(67.22,54.8) v1(67.22,11) v1(67.36,92.98) v1(67.36,68.93) v1(67.64,5.05) v1(67.62,4.28) v1(67.62,3.49) v1(67.79,62.81) v1(67.76,54.8) v1(67.76,11) v1(67.85,97.97) v1(67.86,89.98) v1(67.95,63.05) v1(67.92,5.67) v1(68.02,71.54) v1(68.15,58.68) v1(68.2,57.32) v1(68.22,116.76) v1(68.24,54.8) v1(68.24,11) v1(68.36,97.98) v1(68.58,29.06) v1(68.58,28.76) v1(68.72,103.5) v1(68.78,71.54) v1(68.71,59.42) v1(68.73,57.32) v1(68.72,54.8) v1(68.72,11) v1(68.86,96.98) v1(68.87,29.06) v1(68.87,28.76) v1(69.06,86.85) v1(69.05,59.42) v1(69.09,57.33) v1(69.14,6.77) v1(69.26,103.5) v1(69.27,27.49) v1(69.35,101.1) v1(69.36,96.48) v1(69.36,95.48) v1(69.36,94.98) v1(69.36,92.48) v1(69.36,91.48) v1(69.39,59.42) v1(69.37,39.98) v1(69.55,113.14) v1(69.57,57.33) v1(69.52,40.23) v1(69.59,9.57) v1(69.59,9.23) v1(69.79,103.52) v1(69.75,39.98) v1(69.72,29.06) v1(69.72,28.76) v1(69.84,61.46) v1(69.9,40.23) v1(69.89,9.57) v1(69.89,9.23) v1(69.98,50.58) v1(69.98,50.15) v1(69.98,49.49) v1(69.98,49.11) v1(69.98,48.34) v1(69.98,47.96) v1(69.98,47.2) v1(69.98,45.53) v1(69.98,44.97) v1(69.98,44.59) v1(70.09,101.95) v1(70.08,83.47) v1(70.01,29.06) v1(70.01,28.76) v1(70.14,23.02) v1(70.27,103.52) v1(70.23,50.3) v1(70.23,50) v1(70.23,49.34) v1(70.23,48.96) v1(70.23,48.19) v1(70.23,47.81) v1(70.23,47.05) v1(70.26,45.53) v1(70.23,44.82) v1(70.23,44.43) v1(70.24,38.21) v1(70.34,39.26) v1(70.34,38.88) v1(70.33,37.88) v1(70.33,37.56) v1(70.34,36.63) v1(70.34,35.94) v1(70.34,35.55) v1(70.59,39.11) v1(70.58,36.89) v1(70.59,36.48) v1(70.59,35.78) v1(70.72,11.03) v1(70.82,101.95) v1(70.83,54.8) v1(70.88,29.05) v1(70.88,28.75) v1(70.92,86.83) v1(70.94,50.48) v1(70.95,45.05) v1(70.95,44.67) v1(70.96,26.01) v1(71.07,60.7) v1(71.12,74.74) v1(71.15,35.5) v1(71.16,29.05) v1(71.16,28.75) v1(71.18,9.74) v1(71.26,54.8) v1(71.26,11.03) v1(71.41,60.7) v1(71.43,50.48) v1(71.55,101.1) v1(71.62,26.46) v1(71.76,60.7) v1(71.74,54.8) v1(71.74,11.03) v1(71.88,50.48) v1(71.92,57.22) v1(71.96,33.54) v1(71.96,33.16) v1(71.99,29.08) v1(71.99,28.78) v1(71.99,26.45) v1(71.92,9.71) v1(72.1,116.11) v1(72.1,114.63) v1(72.18,27.29) v1(72.22,103.5) v1(72.29,101.1) v1(72.22,54.8) v1(72.24,42.49) v1(72.24,42.18) v1(72.21,33.39) v1(72.21,33.01) v1(72.28,29.08) v1(72.28,28.78) v1(72.22,11.03) v1(72.45,57.22) v1(72.6,100.39) v1(72.6,98.84) v1(72.6,96.43) v1(72.56,72.9) v1(72.61,22.95) v1(72.76,103.5) v1(72.93,57.22) v1(72.98,44.27) v1(73.03,101.1) v1(73.05,19.86) v1(73.2,46.44) v1(73.11,42.82) v1(73.24,103.5) v1(73.23,44.08) v1(73.26,42.59) v1(73.36,100.36) v1(73.31,62.85) v1(73.44,80.3) v1(73.41,57.22) v1(73.51,87.84) v1(73.51,45.73) v1(73.59,33.06) v1(73.72,103.5) v1(73.76,101.1) v1(73.79,35.57) v1(73.74,34.48) v1(73.77,9.61) v1(73.8,8.87) v1(73.84,97.88) v1(73.84,97.13) v1(73.88,94.6) v1(74,98.09) v1(74,97.34) v1(73.91,95.72) v1(73.97,80.43) v1(73.94,46.44) v1(73.94,6.54) v1(73.94,6.2) v1(73.94,5.82) v1(74.09,35.57) v1(74.01,13.26) v1(74.18,12.99) v1(74.22,87.84) v1(74.22,54.8) v1(74.24,53.53) v1(74.22,11.03) v1(74.23,6.54) v1(74.23,6.2) v1(74.23,5.82) v1(74.38,83.28) v1(74.35,82.8) v1(74.47,36) v1(74.47,35.7) v1(74.42,33.15) v1(74.6,83.46) v1(74.55,82.64) v1(74.56,41.2) v1(74.58,29.78) v1(74.68,32.86) v1(74.65,30.9) v1(74.68,24.52) v1(74.8,62.85) v1(74.76,54.8) v1(74.78,41.02) v1(74.8,36) v1(74.8,35.7) v1(74.76,11.03) v1(74.84,80.19) v1(74.83,9.5) v1(74.98,45.77) v1(75.1,18.12) v1(75.1,17.23) v1(75.2,94.62) v1(75.2,94.09) v1(75.2,93.63) v1(75.17,93.18) v1(75.15,92.69) v1(75.15,92.24) v1(75.17,91.83) v1(75.17,91.37) v1(75.17,90.87) v1(75.18,85.13) v1(75.16,46.02) v1(75.13,36) v1(75.13,35.7) v1(75.19,34.61) v1(75.19,33.03) v1(75.28,57.2) v1(75.24,54.8) v1(75.24,11.03) v1(75.21,10.26) v1(75.21,9.25) v1(75.22,6.69) v1(75.22,6.35) v1(75.22,5.98) v1(75.22,5.64) v1(75.36,45.77) v1(75.37,34.38) v1(75.34,9.76) v1(75.47,103.46) v1(75.5,42.72) v1(75.55,94.62) v1(75.55,94.09) v1(75.55,93.63) v1(75.55,93.18) v1(75.55,92.67) v1(75.51,92.24) v1(75.55,91.83) v1(75.53,91.32) v1(75.58,90.87) v1(75.54,81.19) v1(75.59,61.12) v1(75.51,46.02) v1(75.51,6.69) v1(75.51,6.35) v1(75.51,5.98) v1(75.51,5.64) v1(75.72,54.8) v1(75.77,42.72) v1(75.72,11.03) v1(75.81,57.2) v1(75.85,10.26) v1(76,96.99) v1(75.91,94.62) v1(75.93,94.09) v1(75.93,93.63) v1(75.93,93.18) v1(75.93,92.64) v1(75.91,92.22) v1(75.92,91.83) v1(75.93,91.35) v1(75.96,90.87) v1(75.93,61.12) v1(75.99,14.82) v1(75.97,9.25) v1(76.1,45.76) v1(76.1,9.76) v1(76.14,77.81) v1(76.2,32.88) v1(76.28,96.99) v1(76.29,94.62) v1(76.29,94.09) v1(76.29,93.63) v1(76.3,93.2) v1(76.29,92.24) v1(76.25,61.12) v1(76.29,57.2) v1(76.28,46.01) v1(76.34,103.46) v1(76.31,92.64) v1(76.33,91.81) v1(76.33,91.32) v1(76.35,90.87) v1(76.32,74.03) v1(76.33,24.57) v1(76.48,45.76) v1(76.48,10.26) v1(76.56,96.99) v1(76.51,87.74) v1(76.53,45.04) v1(76.67,94.62) v1(76.67,94.09) v1(76.67,93.63) v1(76.69,93.2) v1(76.69,92.64) v1(76.66,92.23) v1(76.63,46.01) v1(76.7,19.97) v1(76.7,7.58) v1(76.79,103.46) v1(76.71,91.81) v1(76.71,91.32) v1(76.71,90.87) v1(76.78,57.2) v1(76.79,32.58) v1(76.84,96.99) v1(76.86,9.76) v1(76.86,9.25) v1(76.91,79.54) v1(76.96,78.42) v1(77.08,94.62) v1(77.04,94.09) v1(77.05,93.61) v1(77.07,93.2) v1(77.04,92.64) v1(77.06,92.24) v1(77.06,91.78) v1(77.09,91.32) v1(77.06,87.74) v1(77.12,90.87) v1(77.2,41.35) v1(77.2,41.05) v1(77.24,10.26) v1(77.32,103.46) v1(77.34,66.74) v1(77.42,94.62) v1(77.45,94.09) v1(77.45,93.58) v1(77.45,93.2) v1(77.41,92.64) v1(77.43,92.21) v1(77.43,91.81) v1(77.45,91.32) v1(77.47,90.84) v1(77.52,51.01) v1(77.52,50.68) v1(77.52,50.33) v1(77.54,28.67) v1(77.61,66.74) v1(77.8,93.58) v1(77.8,93.2) v1(77.79,92.64) v1(77.79,92.21) v1(77.79,91.81) v1(77.8,91.32) v1(77.8,90.84) v1(77.73,75.48) v1(77.72,11.03) v1(77.75,9.76) v1(77.83,94.62) v1(77.84,94.09) v1(77.87,74.66) v1(77.88,51.01) v1(77.88,50.68) v1(77.88,50.35) v1(77.86,41.35) v1(77.86,41.05) v1(78.09,90.84) v1(78.2,93.2) v1(78.19,92.64) v1(78.12,92.19) v1(78.12,91.81) v1(78.12,91.3) v1(78.18,83.25) v1(78.21,94.62) v1(78.21,94.07) v1(78.22,93.58) v1(78.24,79.42) v1(78.21,67.52) v1(78.26,11.03) v1(78.39,5.83) v1(78.49,41.35) v1(78.49,41.02) v1(78.51,83.25) v1(78.58,74.66) v1(78.58,74.38) v1(78.58,74.1) v1(78.74,66.42) v1(78.73,57.21) v1(78.74,11.03) v1(78.84,83.25) v1(78.82,14.61) v1(79.08,57.22) v1(79.02,9.53) v1(79.17,68.75) v1(79.2,65.67) v1(79.22,103.67) v1(79.27,27.86) v1(79.22,11.03) v1(79.4,81.21) v1(79.35,68.96) v1(79.38,65.9) v1(79.32,63.46) v1(79.53,49.72) v1(79.53,49.39) v1(79.53,49.06) v1(79.64,85.85) v1(79.76,103.64) v1(79.76,7.11) v1(79.87,86.03) v1(79.89,77.92) v1(79.88,49.72) v1(79.88,49.39) v1(79.88,49.06) v1(79.93,57.22) v1(79.96,12.4) v1(79.93,11.87) v1(80.06,43.55) v1(80.04,27.59) v1(80.04,22.62) v1(80.11,76.78) v1(80.29,43.39) v1(80.29,12.4) v1(80.26,11.87) v1(80.37,103.6) v1(80.32,98.38) v1(80.32,96.82) v1(80.39,84.08) v1(80.57,98.54) v1(80.56,96.98) v1(80.53,89.85) v1(80.56,84.32) v1(80.65,24.29) v1(80.75,90.01) v1(80.72,71.76) v1(80.85,103.6) v1(80.82,43.55) v1(80.87,25.29) v1(80.87,20.69) v1(80.85,20.15) v1(80.85,19.47) v1(81.05,43.39) v1(81.1,16.49) v1(81.08,15.96) v1(81.2,20.69) v1(81.18,20.15) v1(81.18,19.47) v1(81.28,13.12) v1(81.31,13.65) v1(81.43,56.75) v1(81.41,56.22) v1(81.43,16.49) v1(81.41,15.96) v1(81.53,20.69) v1(81.51,20.15) v1(81.51,19.47) v1(81.64,13.65) v1(81.61,13.12) v1(81.76,56.75) v1(81.74,56.22) v1(82.2,56.63) v1(82.17,56.09) v1(82.29,101.84) v1(82.29,101.01) v1(82.28,100.67) v1(82.29,80.75) v1(82.29,80.39) v1(82.28,80.01) v1(82.28,79.58) v1(82.28,73.96) v1(82.29,73.62) v1(82.3,73.26) v1(82.3,72.93) v1(82.24,52.2) v1(82.23,49.55) v1(82.31,101.39) v1(82.4,87.61) v1(82.39,86.5) v1(82.39,85.98) v1(82.34,84.27) v1(82.33,83.84) v1(82.32,83.48) v1(82.32,83) v1(82.38,77.04) v1(82.36,76.53) v1(82.38,76.16) v1(82.37,75.61) v1(82.4,70.42) v1(82.39,70.02) v1(82.4,48.52) v1(82.4,29.55) v1(82.33,24.37) v1(82.33,24.01) v1(82.33,23.28) v1(82.33,22.95) v1(82.4,17.1) v1(82.4,16.7) v1(82.37,14.61) v1(82.37,14.28) v1(82.4,12.81) v1(82.4,12.46) v1(82.44,98.37) v1(82.49,94.58) v1(82.49,94.2) v1(82.49,93.81) v1(82.46,91.39) v1(82.44,90.97) v1(82.44,90.48) v1(82.44,90.08) v1(82.42,86.94) v1(82.41,69.65) v1(82.41,69.25) v1(82.5,65.95) v1(82.5,65.58) v1(82.44,63.36) v1(82.46,62.96) v1(82.45,62.59) v1(82.43,62.25) v1(82.5,56.09) v1(82.41,48.12) v1(82.41,47.79) v1(82.43,45.77) v1(82.43,45.29) v1(82.43,44.8) v1(82.43,44.27) v1(82.43,42.27) v1(82.43,41.79) v1(82.43,41.3) v1(82.43,40.77) v1(82.43,38.79) v1(82.43,38.31) v1(82.43,37.83) v1(82.43,37.29) v1(82.43,35.32) v1(82.43,34.89) v1(82.43,33.94) v1(82.43,33.61) v1(82.45,32.55) v1(82.43,31.72) v1(82.43,31.23) v1(82.43,30.75) v1(82.43,30.22) v1(82.43,28.29) v1(82.43,27.81) v1(82.43,27.33) v1(82.43,26.79) v1(82.46,21.27) v1(82.46,20.79) v1(82.46,20.3) v1(82.46,19.77) v1(82.42,18.12) v1(82.42,17.76) v1(82.52,96.93) v1(82.51,96.6) v1(82.52,96.27) v1(82.51,94.94) v1(82.53,65.17) v1(82.53,64.84) v1(82.53,56.63) v1(82.52,52.95) v1(82.52,52.62) v1(82.52,52.36) v1(82.63,7.65) v1(82.63,7.15) v1(83.08,42.4) v1(83.19,51.98) v1(83.16,51.44) v1(83.13,50.94) v1(83.11,50.4) v1(83.11,42.94) v1(83.16,41.51) v1(83.13,40.98) v1(83.16,40.17) v1(83.13,39.63) v1(83.16,26.48) v1(83.13,25.94) v1(83.24,53.07) v1(83.21,52.54) v1(83.26,47.23) v1(83.24,46.69) v1(83.29,46.19) v1(83.26,45.65) v1(83.24,24.17) v1(83.26,23.56) v1(83.29,22.93) v1(83.24,21.68) v1(83.26,20.89) v1(83.49,51.44) v1(83.47,50.94) v1(83.44,50.4) v1(83.44,42.94) v1(83.41,42.4) v1(83.49,41.51) v1(83.47,40.98) v1(83.49,40.17) v1(83.47,39.63) v1(83.49,26.48) v1(83.47,25.94) v1(83.57,53.07) v1(83.54,52.54) v1(83.52,51.98) v1(83.59,47.23) v1(83.57,46.69) v1(83.59,45.65) v1(83.62,46.19) v1(83.67,34.76) v1(83.64,34.22) v1(83.67,33.39) v1(83.64,32.85) v1(83.71,88.96) v1(83.77,31.81) v1(83.74,31.28) v1(83.8,30.57) v1(83.77,30.03) v1(83.88,89.15) v1(83.85,60.54) v1(83.82,60) v1(83.85,58.56) v1(83.82,58.02) v1(83.9,28.56) v1(83.87,28.03) v1(83.9,26.48) v1(83.85,25.92) v1(84,43.6) v1(83.97,43.06) v1(83.95,42.25) v1(83.92,41.72) v1(83.97,40.83) v1(83.95,40.29) v1(84,34.76) v1(83.97,34.22) v1(84,33.39) v1(83.97,32.85) v1(83.95,19.57) v1(83.95,19.03) v1(83.97,18.35) v1(84.1,31.81) v1(84.07,31.28) v1(84.1,30.03) v1(84.07,21.73) v1(84.1,20.89) v1(84.18,60.54) v1(84.15,60) v1(84.18,58.56) v1(84.15,58.02) v1(84.13,30.57) v1(84.2,28.03) v1(84.3,43.06) v1(84.28,42.25) v1(84.25,41.72) v1(84.3,40.83) v1(84.28,40.29) v1(84.23,28.56) v1(84.3,18.35) v1(84.33,43.6) v1(84.33,19.57) v1(84.33,19.03) v1(84.46,21.75) v1(84.51,20.89) v1(84.86,21.75) v1(84.96,59.67) v1(84.97,59.34) v1(84.96,59.01) v1(84.96,32.09) v1(84.91,20.89) v1(85.27,21.73) v1(85.29,20.89) v1(85.27,20.48) v1(85.24,19.95) v1(85.24,19.26) v1(85.28,11.26) v1(85.47,61) v1(85.55,99.92) v1(85.55,99.53) v1(85.55,90.27) v1(85.55,87.07) v1(85.53,86.17) v1(85.53,85.86) v1(85.6,19.95) v1(85.6,19.26) v1(85.62,20.48) v1(85.73,61.16) v1(85.85,99.92) v1(85.86,99.54) v1(85.83,86.19) v1(85.83,85.87) v1(85.9,82.71) v1(85.88,77.76) v1(86.21,82.71) v1(86.21,77.76) v1(86.27,57.19) v1(86.27,56.83) v1(86.21,26.35) v1(86.21,25.92) v1(86.4,66.39) v1(86.49,7.1) v1(86.56,82.71) v1(86.51,63.41) v1(86.53,32.04) v1(86.56,30.24) v1(86.59,25.94) v1(86.56,22.67) v1(86.56,21.73) v1(86.59,19.97) v1(86.62,66.54) v1(86.61,26.37) v1(86.64,20.91) v1(86.61,14.49) v1(86.61,11.44) v1(86.86,82.71) v1(86.94,22.67) v1(86.94,21.73) v1(86.97,20.91) v1(86.94,19.97) v1(87.2,82.71) v1(87.13,66.39) v1(87.2,17.26) v1(87.29,30.24) v1(87.28,22.67) v1(87.28,21.73) v1(87.35,99.88) v1(87.35,99.55) v1(87.38,86.14) v1(87.39,85.82) v1(87.36,66.54) v1(87.4,20.94) v1(87.33,19.97) v1(87.37,14.49) v1(87.37,11.44) v1(87.4,2.8) v1(87.68,99.88) v1(87.66,99.56) v1(87.65,95.47) v1(87.65,87.07) v1(87.68,85.84) v1(87.71,86.17) v1(87.76,26.4) v1(87.73,25.87) v1(87.73,20.94) v1(87.71,19.97) v1(87.76,2.8) v1(87.9,109.04) v1(87.86,66.39) v1(88.08,66.54) v1(88.09,2.8) v1(88.14,26.4) v1(88.11,25.87) v1(88.13,14.49) v1(88.13,11.44) v1(88.34,65.56) v1(88.48,112.11) v1(88.44,109.53) v1(88.48,108) v1(88.49,56.26) v1(88.6,66.38) v1(88.7,112.29) v1(88.66,109.7) v1(88.68,108.16) v1(88.62,65.56) v1(88.74,56.42) v1(88.9,100.37) v1(88.82,66.54) v1(88.99,98.94) v1(88.93,96.78) v1(88.95,95.39) v1(88.91,94.35) v1(88.93,93.81) v1(88.93,93.33) v1(89.02,97.89) v1(89.22,112.11) v1(89.21,108.01) v1(89.23,59.37) v1(89.23,56.97) v1(89.24,56.26) v1(89.33,66.38) v1(89.42,112.29) v1(89.42,108.18) v1(89.46,59.52) v1(89.47,57.13) v1(89.46,56.43) v1(89.45,35.85) v1(89.59,59.98) v1(89.61,60.51) v1(89.94,60.51) v1(89.92,59.98) v1(90.14,89.83) v1(90.14,88.99) v1(90.14,88.16) v1(90.19,84.93) v1(90.19,84.09) v1(90.26,87.49) v1(90.31,88.44) v1(90.47,85.21) v1(90.47,84.37) v1(90.58,61.68) v1(90.55,61.15) v1(90.6,60.26) v1(90.58,59.73) v1(90.88,61.15) v1(90.91,61.68) v1(90.93,60.26) v1(90.91,59.73) v1(92.79,62.27) v1(92.76,61.73) v1(92.76,60.06) v1(92.74,59.52) v1(92.84,90.03) v1(92.85,67.15) v1(92.99,82.56) v1(93.03,67.37) v1(93.09,61.73) v1(93.09,60.06) v1(93.07,59.52) v1(93.12,62.27) v1(93.37,82.56) v1(93.47,64.02) v1(93.45,63.48) v1(93.68,82.56) v1(93.8,64.02) v1(93.78,63.48) v1(94.9,65.21) v1(94.87,64.68) v1(95.2,64.68) v1(95.23,65.21) v1(95.86,66.38) v1(95.83,65.85) v1(96.19,92.67) v1(96.19,66.38) v1(96.17,65.85) v1(96.36,92.87) v1(97.77,82.86) v1(97.75,82.21) v1(97.76,68.95) v1(97.77,68.26) v1(98.03,82.54) v1(98.3,82.85) v1(98.32,82.18) v1(98.31,68.95) v1(98.31,68.26) v2(0.77,122.25) v2(0.77,119.71) v2(0.77,117.17) v2(0.77,114.63) v2(0.77,112.09) v2(0.77,109.55) v2(0.77,107.01) v2(0.77,104.47) v2(0.77,101.93) v2(0.78,99.4) v2(0.77,96.85) v2(0.77,94.31) v2(0.77,91.77) v2(0.77,89.23) v2(0.77,86.69) v2(0.77,84.15) v2(0.77,79.07) v2(0.77,76.53) v2(0.77,73.99) v2(0.77,71.45) v2(0.77,68.91) v2(0.77,66.37) v2(0.77,63.83) v2(0.77,61.29) v2(1.18,58.76) v2(2.57,124.03) v2(2.68,115.87) v2(2.69,114.84) v2(2.69,112.46) v2(2.67,109.69) v2(2.69,106.97) v2(2.67,103.79) v2(2.79,117.52) v2(2.71,113.74) v2(2.73,111.1) v2(2.73,108.46) v2(2.76,105.53) v2(2.76,102.09) v2(2.74,100.44) v2(2.74,98.87) v2(2.79,97.16) v2(2.79,86.95) v2(2.79,59.5) v2(3.33,122.36) v2(3.39,84.69) v2(3.53,120.17) v2(3.54,58.76) v2(3.7,115.87) v2(3.68,109.69) v2(3.68,103.79) v2(3.71,114.84) v2(3.72,113.74) v2(3.71,112.46) v2(3.75,111.1) v2(3.75,108.46) v2(3.71,106.97) v2(3.78,105.53) v2(3.78,102.09) v2(3.76,100.44) v2(3.76,98.87) v2(3.81,117.52) v2(3.81,97.16) v2(3.96,76.74) v2(4.1,94.27) v2(4.16,118.65) v2(4.67,91.53) v2(4.67,90.79) v2(4.61,89.29) v2(4.61,87.79) v2(4.9,106.56) v2(4.83,103.97) v2(4.89,102.38) v2(4.83,100.77) v2(4.85,98.89) v2(4.88,97.35) v2(4.94,108.06) v2(4.96,105.58) v2(5,94.25) v2(5.11,124.03) v2(5.13,91.98) v2(5.49,91.09) v2(5.49,89.32) v2(5.46,87.82) v2(5.46,85.73) v2(5.84,103.97) v2(5.9,102.38) v2(5.84,100.77) v2(5.87,98.89) v2(5.9,97.35) v2(5.86,63.97) v2(5.96,108.06) v2(5.92,106.56) v2(5.98,105.58) v2(5.94,73.24) v2(6.02,94.25) v2(6.1,91.09) v2(6.1,89.32) v2(6.07,87.82) v2(6.07,85.73) v2(6.1,80.6) v2(6.1,79.97) v2(6.1,79.36) v2(6.1,78.7) v2(6.06,58.77) v2(6.15,91.98) v2(6.28,70.2) v2(6.32,68.63) v2(6.83,103.82) v2(6.89,102.22) v2(6.83,100.62) v2(6.86,98.74) v2(6.89,97.2) v2(6.88,63.97) v2(6.97,122.99) v2(6.97,105.42) v2(7.09,91.98) v2(7.65,124.03) v2(7.7,121.36) v2(7.78,70.18) v2(7.74,68.66) v2(7.72,63.97) v2(7.88,122.99) v2(7.85,103.82) v2(7.85,100.62) v2(7.87,98.74) v2(7.91,97.2) v2(7.99,105.42) v2(7.91,102.22) v2(8.13,91.98) v2(8.35,78.09) v2(8.35,76.83) v2(8.62,58.76) v2(8.97,63.97) v2(9.01,94.05) v2(9.14,91.98) v2(9.16,70.15) v2(9.16,68.64) v2(9.85,78.11) v2(9.86,76.83) v2(10.03,94.05) v2(10.19,124.03) v2(10.11,91.98) v2(11.15,94.05) v2(11.13,91.98) v2(11.16,58.76) v2(11.23,121.29) v2(11.35,78.11) v2(12.09,91.98) v2(12.17,119.27) v2(12.16,94.05) v2(12.6,67.84) v2(12.6,63.64) v2(12.72,114.24) v2(12.85,78.14) v2(13.08,91.98) v2(13.13,91.2) v2(13.11,89.14) v2(13.11,87.87) v2(13.11,85.48) v2(13.11,80.64) v2(13.11,80.01) v2(13.11,79.35) v2(13.11,78.71) v2(13.7,58.76) v2(13.74,114.24) v2(13.74,91.2) v2(13.72,89.14) v2(13.74,87.84) v2(13.72,85.48) v2(14,68.74) v2(14.01,67.87) v2(14.12,91.98) v2(14.32,107.58) v2(14.45,83.78) v2(14.45,82.31) v2(14.45,80.58) v2(15.06,63.97) v2(15.13,70.19) v2(15.34,107.58) v2(15.37,68.88) v2(15.34,67.79) v2(15.47,119.03) v2(15.49,106.11) v2(15.88,83.91) v2(15.88,82.4) v2(16,115.28) v2(16,114.04) v2(16.25,58.69) v2(16.4,71.64) v2(16.51,106.11) v2(16.66,69.52) v2(16.71,67.84) v2(16.99,119.03) v2(16.99,115.28) v2(16.99,114.04) v2(16.94,111.29) v2(17.32,107.99) v2(17.53,56.5) v2(17.53,53.96) v2(17.53,51.42) v2(17.53,48.88) v2(17.53,46.34) v2(17.53,43.8) v2(17.53,41.26) v2(17.53,38.72) v2(17.53,36.18) v2(17.53,33.64) v2(17.53,31.1) v2(17.53,28.56) v2(17.53,26.02) v2(17.53,23.48) v2(17.53,20.94) v2(17.53,18.4) v2(17.53,15.86) v2(17.53,5.46) v2(17.53,3.16) v2(17.79,90.89) v2(17.79,90.08) v2(17.79,89.27) v2(17.78,69.43) v2(17.86,111.08) v2(17.83,67.86) v2(17.88,63.77) v2(17.86,62.87) v2(18.33,107.99) v2(18.35,0.79) v2(19.05,106.24) v2(19.23,110.83) v2(19.96,93.65) v2(19.97,92.94) v2(20.06,106.24) v2(20.02,86.51) v2(20.04,53.65) v2(20.57,109.77) v2(20.52,99.6) v2(20.71,96.81) v2(20.82,108.57) v2(20.9,12.48) v2(20.85,9.43) v2(20.89,0.79) v2(20.96,112.13) v2(20.93,13.52) v2(21.59,109.77) v2(21.84,108.57) v2(21.96,100.13) v2(21.91,96.8) v2(22.15,113.83) v2(22.58,100.19) v2(22.96,109.74) v2(23.03,108.6) v2(23.04,107.61) v2(23.41,110.9) v2(23.42,99.15) v2(23.5,97.34) v2(23.43,0.79) v2(23.97,109.74) v2(24.05,108.6) v2(24.06,107.61) v2(24.41,113.83) v2(24.71,113.08) v2(25.45,109.64) v2(25.5,108.68) v2(25.5,107.66) v2(25.97,0.79) v2(26.46,109.64) v2(26.51,108.68) v2(26.51,107.66) v2(26.7,7.81) v2(27.13,113.83) v2(27.76,109.66) v2(27.99,107.69) v2(28.01,108.65) v2(28.51,0.79) v2(28.78,109.66) v2(29,107.69) v2(29.03,108.65) v2(29.67,113.83) v2(30.43,107.76) v2(30.56,108.87) v2(30.76,110.02) v2(30.86,112.49) v2(30.86,111.31) v2(31.05,0.79) v2(32.08,108.95) v2(32.08,107.78) v2(32.16,112.53) v2(32.11,111.41) v2(32.11,110.14) v2(32.21,113.83) v2(33.53,110.14) v2(33.53,108.98) v2(33.59,0.79) v2(33.63,107.76) v2(33.81,112.46) v2(33.91,111.41) v2(34.75,113.83) v2(35.28,112.43) v2(35.23,109) v2(35.36,111.44) v2(35.38,110.19) v2(36.13,0.79) v2(36.83,112.38) v2(37.03,111.44) v2(37.29,113.83) v2(38.3,112.35) v2(38.67,0.79) v2(40.39,7.76) v2(40.46,6.26) v2(40.46,5.6) v2(40.72,3.87) v2(40.93,108.19) v2(41.21,0.79) v2(41.66,7.63) v2(41.68,6.66) v2(41.98,109.28) v2(41.95,108.19) v2(41.94,3.9) v2(42.98,6.28) v2(43.06,110.57) v2(43.05,7.58) v2(43.28,109.36) v2(43.38,108.14) v2(44.78,110.65) v2(44.78,109.31) v2(44.79,108.14) v2(44.91,113.83) v2(45.49,22.82) v2(45.81,108.14) v2(45.95,109.33) v2(46.1,22.82) v2(47.06,110.78) v2(47.45,113.83) v2(48.07,110.78) v2(49.78,109.53) v2(49.99,113.83) v2(51.37,0.79) v2(51.87,109.66) v2(52.53,113.83) v2(53.91,0.79) v2(54.43,109.61) v2(55.07,113.83) v2(55.65,109.66) v2(56.45,0.79) v2(57.18,109.53) v2(57.61,113.83) v2(58.99,0.79) v2(59.87,109.48) v2(60.15,113.83) v2(60.76,109.51) v2(61.53,0.79) v2(62.69,113.83) v2(62.76,109.56) v2(64.07,0.8) v2(64.45,109.48) v2(64.58,104.77) v2(65.32,113.88) v2(65.33,104.77) v2(66.37,109.48) v2(66.6,0.77) v2(66.68,118.5) v2(66.68,115.96) v2(68.38,118.58) v2(68.52,120.24) v2(69.04,110.75) v2(69.44,118.55) v2(69.65,109.66) v2(69.73,111.82) v2(69.93,117.05) v2(70.54,118.5) v2(70.64,110.86) v2(70.99,117.03) v2(71.06,120.24) v2(71.2,111.72) v2(71.25,112.94) v2(71.6,118.48) v2(71.53,109.74) v2(71.62,2.85) v2(72.19,117.03) v2(72.24,110.78) v2(72.37,3.57) v2(72.54,111.82) v2(72.73,118.58) v2(72.72,109.71) v2(73.25,117) v2(73.28,110.8) v2(73.38,115.33) v2(73.6,120.24) v2(73.79,118.55) v2(74.23,0.79) v2(74.44,117.84) v2(74.44,115.3) v2(74.52,109.69) v2(74.93,98.84) v2(75.49,112.99) v2(75.54,2.6) v2(75.99,109.59) v2(76.2,100.44) v2(76.15,0.79) v2(76.69,3.6) v2(76.89,99.65) v2(76.94,112) v2(77.78,100.85) v2(78.03,112.83) v2(78.25,3.55) v2(78.51,104.81) v2(78.64,100.85) v2(79.15,112) v2(79.75,58.71) v2(80.57,112.83) v2(80.54,109.46) v2(81.03,11.97) v2(81.52,112.05) v2(82.63,110.63) v2(83.11,112.83) v2(83.24,106.97) v2(83.26,96.07) v2(83.31,109.55) v2(83.39,87.41) v2(83.39,86.42) v2(83.4,81.06) v2(83.4,77.71) v2(83.4,73.91) v2(83.44,84.73) v2(83.44,82.18) v2(83.46,71.71) v2(83.54,101.3) v2(83.54,12.48) v2(83.72,112.05) v2(84.05,110.57) v2(84.39,0.79) v2(84.48,105.83) v2(84.63,109.64) v2(85.07,110.57) v2(85.55,4.9) v2(85.65,112.83) v2(85.65,104.78) v2(85.88,49.01) v2(85.91,109.56) v2(85.91,50.94) v2(85.91,50.25) v2(85.91,49.62) v2(86.36,110.63) v2(86.47,69.21) v2(86.61,112.02) v2(86.67,103.74) v2(86.72,2.91) v2(86.93,0.79) v2(87.07,109.59) v2(87.25,69.21) v2(87.76,13.04) v2(87.78,12.15) v2(87.88,23.17) v2(87.86,21.7) v2(88.19,112.83) v2(88.88,75.7) v2(88.9,74.1) v2(88.9,72.3) v2(89.02,27.58) v2(89.02,25.04) v2(89.02,22.5) v2(89.02,19.96) v2(89.02,17.42) v2(89.02,14.88) v2(89.02,12.34) v2(89.02,9.8) v2(89.02,7.26) v2(89.02,4.72) v2(89.02,2.18) v2(89.22,30.06) v2(90.2,113.12) v2(90.47,113.98) v2(90.58,116.52) v2(90.59,106.6) v2(90.55,48.42) v2(90.6,45.3) v2(90.6,42.12) v2(90.56,37.45) v2(90.65,43.7) v2(90.75,104.96) v2(90.78,102.83) v2(90.73,40.9) v2(90.91,119.03) v2(90.91,52.52) v2(90.91,50.63) v2(90.97,39.38) v2(91.09,57.41) v2(91.16,47.15) v2(91.52,109.59) v2(91.59,62.47) v2(91.52,42.55) v2(91.62,74) v2(91.64,72.4) v2(91.64,70.6) v2(91.69,69.15) v2(91.67,68.46) v2(91.62,60.87) v2(91.62,59.06) v2(91.75,77.4) v2(92.15,53.04) v2(92.61,110.75) v2(92.61,78.55) v2(92.77,35.8) v2(92.84,80.25) v2(92.96,104.38) v2(93.07,102.2) v2(93.45,119.03) v2(93.73,113.8) v2(93.73,112.05) v2(93.73,99.53) v2(93.9,96.5) v2(93.94,95.56) v2(93.95,94.47) v2(93.93,46.3) v2(94.26,115.68) v2(94.26,74.61) v2(94.29,73.01) v2(94.29,71.21) v2(94.23,69.43) v2(94.26,67.83) v2(94.26,66.02) v2(94.26,60.28) v2(94.26,58.48) v2(94.27,52.67) v2(94.34,76.34) v2(94.31,62.61) v2(94.72,79.84) v2(95.05,72.12) v2(95.05,70.32) v2(95.02,37.45) v2(95.15,113.95) v2(95.17,112.05) v2(95.12,77.2) v2(95.15,75.6) v2(95.15,73.8) v2(95.17,63.38) v2(95.13,51.13) v2(95.25,82.92) v2(95.25,82.18) v2(95.33,69.44) v2(95.35,67.91) v2(95.48,117.87) v2(95.44,59.36) v2(95.42,54.3) v2(95.5,48.45) v2(95.48,46.97) v2(95.99,119.03) v2(96.01,98.18) v2(96.29,63.07) v2(96.27,49.2) v2(96.29,45.73) v2(96.7,118.32) v2(96.67,108.72) v2(96.77,35.89) v2(96.82,114.53) v2(97,69.66) v2(97.1,81.42) v2(97.1,74.43) v2(97.02,51.4) v2(97.2,98.86) v2(97.18,97.42) v2(97.19,91.71) v2(97.13,79.87) v2(97.16,78.27) v2(97.16,76.46) v2(97.13,72.83) v2(97.13,71.03) v2(97.13,62.54) v2(97.17,44.92) v2(97.3,117.17) v2(97.29,93.88) v2(97.3,48.11) v2(97.31,107.28) v2(97.33,104.21) v2(97.33,101.67) v2(97.35,89.33) v2(97.33,86.79) v2(97.39,66.9) v2(97.33,64.41) v2(97.32,47) v2(97.34,36.4) v2(97.48,84.26) v2(97.52,50.64) v2(97.59,35.8) v2(97.66,61.71) v2(97.63,52.25) v2(97.61,45.59) v2(97.84,62.85) v2(98.15,98.1) v2(98.32,114.49) v2(98.37,99.35) v2(98.5,109.24) v2(98.5,81.32) v2(98.68,79.66) v2(98.71,78.06) v2(98.71,76.26) v2(98.73,74.46) v2(98.76,72.86) v2(98.76,71.05) v2(98.98,112.2) v2(98.93,83.25) v2(99.06,113.88) v2(99.19,97.82) v2(99.47,90.76) v2(99.7,76.41) v2(99.7,69.83) v2(99.85,79.61) v2(99.82,74.46) v2(99.94,114.55) v2(100.43,112.48) v2(100.43,110.14) v2(100.44,80.77) v2(100.44,78.23) v2(100.44,75.69) v2(100.44,73.15) v2(100.44,70.61) v2(100.84,91.93) v3(7.57,90.89) v3(7.57,90.18) v3(7.57,89.52) v3(7.57,88.83) v3(7.54,87.74) v3(7.54,87.03) v3(7.54,86.37) v3(7.54,85.68) v3(7.63,80.69) v3(7.65,80.15) v3(7.65,79.49) v3(7.65,78.8) v3(8.56,80.69) v3(8.56,80.12) v3(8.56,79.46) v3(8.56,78.78) v3(8.61,90.84) v3(8.61,90.13) v3(8.61,89.47) v3(8.61,88.78) v3(8.64,87.67) v3(8.64,86.95) v3(8.64,86.29) v3(8.64,85.61) v3(9.65,90.87) v3(9.65,90.15) v3(9.65,89.49) v3(9.65,88.81) v3(9.64,80.67) v3(9.63,80.1) v3(9.63,79.44) v3(9.63,78.75) v3(9.73,87.72) v3(9.73,87) v3(9.73,86.34) v3(9.73,85.66) v3(10.59,80.69) v3(10.59,80.07) v3(10.59,79.41) v3(10.59,78.72) v3(10.67,90.84) v3(10.67,90.13) v3(10.67,89.47) v3(10.67,88.78) v3(10.64,87.67) v3(10.64,86.95) v3(10.64,86.29) v3(10.64,85.61) v3(11.53,87.64) v3(11.53,86.93) v3(11.53,86.27) v3(11.53,85.58) v3(11.57,80.69) v3(11.56,80.05) v3(11.56,79.38) v3(11.56,78.7) v3(11.66,90.81) v3(11.66,90.1) v3(11.66,89.44) v3(11.66,88.76) v3(19.84,48.12) v3(20.02,52.79) v3(20.8,48.65) v3(21.13,49.84) v3(23.7,73.54) v3(25.59,57.26) v3(33.33,9.48) v3(34.39,8.37) v3(34.93,7.86) v3(39.19,7.66) v3(40.08,8.67) v3(41.25,23.35) v3(42.39,22.29) v3(42.39,19.75) v3(42.39,14.77) v3(43.23,18.78) v3(43.79,21.04) v3(44.22,17.97) v3(44.55,12.53) v3(45.01,17.05) v3(45.34,19.11) v3(45.47,11.77) v3(45.57,24.06) v3(45.82,18.32) v3(45.97,20.74) v3(46.1,6.23) v3(46.15,19.03) v3(46.3,7.12) v3(46.53,15.05) v3(47.14,19.95) v3(47.22,7.1) v3(47.78,18.55) v3(48.11,3.67) v3(48.29,14.16) v3(48.34,16.47) v3(48.49,20.71) v3(48.41,14.89) v3(48.54,18.53) v3(49.15,19.57) v3(49.33,4.71) v3(49.84,3.62) v3(49.99,20.33) v3(50.04,11.62) v3(50.19,14.89) v3(50.17,14.26) v3(50.24,16.55) v3(50.8,6) v3(50.83,16.06) v3(50.85,14.61) v3(50.98,19.62) v3(51.08,3.51) v3(51.23,11.59) v3(51.33,14.16) v3(51.44,16.44) v3(51.84,6.05) v3(52.6,11.62) v3(54.95,65.24) v3(56.57,15.83) v3(58.27,16.29) v3(60.61,14.92) v3(60.76,12.53) v3(61.88,12.84) v3(65.51,13.45) v3(67.59,16.55) v3(69.44,42.53) v3(70.54,41.74) v3(72.34,19.36) v3(72.37,18.5) v3(72.42,17.66) v3(73.1,41.41) v3(75.06,26.22) v3(75.31,27.01) v3(75.36,23.96) v3(75.49,20.63) v3(75.72,26.2) v3(76.02,21.85) v3(76.38,39.96) v3(76.35,39.05) v3(76.63,49.9) v3(76.61,46.69) v3(76.68,43.06) v3(76.66,20.76) v3(77.01,24.29) v3(77.01,21.88) v3(77.37,48.17) v3(77.39,43.39) v3(77.32,42.43) v3(77.6,23.83) v3(77.9,49.72) v3(78.18,52.13) v3(78.21,31.35) v3(78.26,24.83) v3(78.33,48.17) v3(78.36,46.92) v3(78.46,42.96) v3(78.46,38.24) v3(78.49,32.04) v3(78.44,26.48) v3(78.94,40.09) v3(78.94,39.13) v3(79.02,25.89) v3(80.04,34.38) v3(80.14,35.93) v3(80.16,28.81) v3(80.16,25.92) v3(80.37,29.73) v3(80.57,35.52) v3(80.79,24.89) v3(80.98,28.64) v3(81.05,34.4) v3(81.05,29.93) v3(81.13,44.61) v3(81.13,42.33) v3(81.15,41.39) v3(82.02,43.77) v3(82.02,42.66) v3(82.04,37.27) v4(1.45,92.19) v4(1.45,91.35) v4(1.45,90.54) v4(1.47,89.67) v4(1.88,81.44) v4(1.93,92.14) v4(1.91,91.35) v4(1.91,90.51) v4(1.93,89.72) v4(4.88,113.94) v4(4.88,113.54) v4(4.89,113.15) v4(4.88,112.79) v4(4.96,117.85) v4(4.96,117.46) v4(4.96,117.06) v4(4.95,116.7) v4(4.99,116.05) v4(4.99,115.65) v4(4.99,115.26) v4(4.98,114.89) v4(5,108.85) v4(5.04,111.75) v4(5.04,111.36) v4(5.04,110.97) v4(5.03,110.6) v4(5.01,110) v4(5.01,109.61) v4(5.01,109.22) v4(5.7,113.91) v4(5.7,113.52) v4(5.7,113.13) v4(5.69,112.76) v4(5.77,117.82) v4(5.77,117.43) v4(5.78,117.04) v4(5.77,116.67) v4(5.8,116.02) v4(5.8,115.63) v4(5.8,115.24) v4(5.79,114.87) v4(5.85,111.73) v4(5.85,111.33) v4(5.85,110.94) v4(5.84,110.58) v4(5.82,109.98) v4(5.82,109.58) v4(5.83,109.19) v4(5.82,108.82) v4(7.09,91.18) v4(7.09,90.88) v4(7.09,90.57) v4(7.09,90.27) v4(7.09,89.96) v4(7.09,89.66) v4(7.09,89.35) v4(7.09,89.05) v4(7.09,88.75) v4(7.06,87.88) v4(7.06,87.58) v4(7.06,87.27) v4(7.06,86.97) v4(7.06,86.66) v4(7.06,86.36) v4(7.06,86.05) v4(7.06,85.75) v4(7.06,85.45) v4(7.01,84.63) v4(7.01,84.33) v4(7.01,84.02) v4(7.01,83.72) v4(7.01,83.42) v4(7.01,83.11) v4(7.01,82.81) v4(7.01,82.5) v4(7.01,82.2) v4(7.04,81.36) v4(7.04,81.06) v4(7.04,80.75) v4(7.04,80.45) v4(7.04,80.14) v4(7.04,79.84) v4(7.04,79.53) v4(7.04,79.23) v4(7.04,78.92) v4(7.3,109.24) v4(7.3,108.84) v4(7.3,108.45) v4(7.29,108.09) v4(7.88,73.93) v4(8.1,108.06) v4(8.08,84.62) v4(8.08,84.31) v4(8.08,84.01) v4(8.08,83.7) v4(8.08,83.4) v4(8.08,83.09) v4(8.08,82.79) v4(8.08,82.48) v4(8.08,82.18) v4(8.1,81.34) v4(8.1,81.04) v4(8.1,80.73) v4(8.1,80.43) v4(8.1,80.12) v4(8.1,79.82) v4(8.1,79.51) v4(8.1,79.21) v4(8.1,78.9) v4(8.11,109.21) v4(8.11,108.82) v4(8.11,108.43) v4(8.15,91.16) v4(8.15,90.86) v4(8.15,90.55) v4(8.15,90.25) v4(8.15,89.94) v4(8.15,89.64) v4(8.15,89.34) v4(8.15,89.03) v4(8.15,88.73) v4(8.13,87.86) v4(8.13,87.56) v4(8.13,87.25) v4(8.13,86.95) v4(8.13,86.64) v4(8.13,86.34) v4(8.13,86.04) v4(8.13,85.73) v4(8.13,85.43) v4(8.16,73.75) v4(8.16,72.48) v4(8.36,72.25) v4(8.77,107.66) v4(8.77,107.27) v4(8.77,106.88) v4(8.76,106.51) v4(8.9,73.75) v4(9.09,84.69) v4(9.09,84.39) v4(9.09,84.08) v4(9.09,83.78) v4(9.09,83.47) v4(9.09,83.17) v4(9.09,82.86) v4(9.09,82.56) v4(9.09,82.25) v4(9.18,98.88) v4(9.18,98.48) v4(9.18,98.09) v4(9.17,97.72) v4(9.17,91.24) v4(9.17,90.94) v4(9.17,90.63) v4(9.17,90.33) v4(9.17,90.02) v4(9.17,89.72) v4(9.17,89.41) v4(9.17,89.11) v4(9.17,88.8) v4(9.14,87.94) v4(9.14,87.64) v4(9.14,87.33) v4(9.14,87.03) v4(9.14,86.72) v4(9.14,86.42) v4(9.14,86.11) v4(9.14,85.81) v4(9.14,85.5) v4(9.12,81.42) v4(9.12,81.11) v4(9.12,80.81) v4(9.12,80.5) v4(9.12,80.2) v4(9.12,79.89) v4(9.12,79.59) v4(9.12,79.28) v4(9.12,78.98) v4(9.23,100.83) v4(9.23,100.44) v4(9.23,100.05) v4(9.22,99.68) v4(9.33,105.76) v4(9.33,105.36) v4(9.33,104.97) v4(9.32,104.61) v4(9.58,107.64) v4(9.58,107.24) v4(9.59,106.85) v4(9.58,106.49) v4(9.99,98.85) v4(9.99,98.46) v4(10.04,100.81) v4(10.04,100.41) v4(10.04,100.02) v4(10.03,99.65) v4(10.14,105.73) v4(10.14,105.34) v4(10.15,104.95) v4(10.14,104.58) v4(10.19,87.91) v4(10.19,87.61) v4(10.19,87.31) v4(10.19,87) v4(10.19,86.7) v4(10.19,86.39) v4(10.19,86.09) v4(10.19,85.78) v4(10.19,85.48) v4(10.14,84.67) v4(10.14,84.36) v4(10.14,84.06) v4(10.14,83.75) v4(10.14,83.45) v4(10.14,83.14) v4(10.14,82.84) v4(10.14,82.53) v4(10.14,82.23) v4(10.16,81.39) v4(10.16,81.09) v4(10.16,80.78) v4(10.16,80.48) v4(10.16,80.17) v4(10.16,79.87) v4(10.16,79.56) v4(10.16,79.26) v4(10.16,78.95) v4(10.19,74.73) v4(10.21,91.21) v4(10.21,90.91) v4(10.21,90.61) v4(10.21,90.3) v4(10.21,90) v4(10.21,89.69) v4(10.21,89.39) v4(10.21,89.08) v4(10.21,88.78) v4(10.47,73.62) v4(10.75,103.55) v4(10.75,103.15) v4(10.76,102.76) v4(10.74,102.4) v4(10.85,100.81) v4(10.85,100.41) v4(10.86,100.02) v4(10.85,99.65) v4(10.96,105.73) v4(10.96,105.34) v4(10.96,104.95) v4(10.95,104.58) v4(11,84.69) v4(11,84.39) v4(11,84.08) v4(11,83.78) v4(11,83.47) v4(11,83.17) v4(11,82.86) v4(11,82.56) v4(11,82.25) v4(11.05,87.94) v4(11.05,87.64) v4(11.05,87.33) v4(11.05,87.03) v4(11.05,86.72) v4(11.05,86.42) v4(11.05,86.11) v4(11.05,85.81) v4(11.05,85.5) v4(11.02,81.42) v4(11.02,81.11) v4(11.02,80.81) v4(11.02,80.5) v4(11.02,80.2) v4(11.02,79.89) v4(11.02,79.59) v4(11.02,79.28) v4(11.02,78.98) v4(11.15,91.18) v4(11.15,90.88) v4(11.15,90.57) v4(11.15,90.27) v4(11.15,89.96) v4(11.15,89.66) v4(11.15,89.35) v4(11.15,89.05) v4(11.15,88.75) v4(11.15,74.3) v4(11.49,103.55) v4(11.49,103.15) v4(11.49,102.76) v4(11.48,102.4) v4(11.57,100.78) v4(11.57,100.39) v4(11.57,100) v4(11.56,99.63) v4(11.67,105.71) v4(11.67,105.31) v4(11.67,104.92) v4(11.66,104.56) v4(11.79,95.65) v4(11.79,95.26) v4(11.8,94.86) v4(11.79,94.5) v4(12.09,91.18) v4(12.09,90.88) v4(12.09,90.57) v4(12.09,90.27) v4(12.09,89.96) v4(12.09,89.66) v4(12.09,89.35) v4(12.09,89.05) v4(12.09,88.75) v4(12.07,87.96) v4(12.07,87.66) v4(12.07,87.35) v4(12.07,87.05) v4(12.07,86.74) v4(12.07,86.44) v4(12.07,86.13) v4(12.07,85.83) v4(12.07,85.52) v4(12.04,84.63) v4(12.04,84.33) v4(12.04,84.02) v4(12.04,83.72) v4(12.04,83.42) v4(12.04,83.11) v4(12.04,82.81) v4(12.04,82.5) v4(12.04,82.2) v4(12.04,81.31) v4(12.04,81) v4(12.04,80.7) v4(12.04,80.39) v4(12.04,80.09) v4(12.04,79.79) v4(12.04,79.48) v4(12.04,79.18) v4(12.04,78.87) v4(12.7,104.43) v4(12.62,74.71) v4(12.71,105.58) v4(12.71,105.19) v4(12.71,104.8) v4(12.95,74.48) v4(13.39,103.57) v4(13.39,103.18) v4(13.4,102.79) v4(13.39,102.42) v4(13.32,96.74) v4(13.32,96.35) v4(13.32,95.96) v4(13.31,95.59) v4(13.52,105.56) v4(13.52,105.16) v4(13.52,104.77) v4(13.51,104.4) v4(13.75,99.79) v4(13.75,99.4) v4(13.75,99) v4(13.74,98.64) v4(14.2,102.4) v4(14.21,103.55) v4(14.21,103.15) v4(14.21,102.76) v4(14.33,105.56) v4(14.33,105.16) v4(14.34,104.77) v4(14.33,104.4) v4(14.5,96.53) v4(14.51,97.68) v4(14.51,97.29) v4(14.51,96.9) v4(15.04,105.53) v4(15.04,105.14) v4(15.05,104.75) v4(15.04,104.38) v4(15.02,103.55) v4(15.02,103.15) v4(15.09,74.35) v4(15.14,74.76) v4(15.6,74.38) v4(15.73,103.52) v4(15.73,103.13) v4(15.73,98.62) v4(15.73,98.23) v4(15.73,97.84) v4(15.72,97.47) v4(15.8,94.62) v4(15.86,100.81) v4(15.86,100.41) v4(15.86,100.02) v4(15.85,99.65) v4(15.81,95.78) v4(15.81,95.38) v4(15.81,94.99) v4(15.88,60.92) v4(15.88,59.65) v4(17.02,74.62) v4(17.48,104.34) v4(17.48,103.94) v4(17.49,103.55) v4(17.48,103.18) v4(17.79,2.18) v4(17.79,1.78) v4(17.79,1.39) v4(17.78,1.03) v4(18.07,7.18) v4(18.07,6.79) v4(18.07,6.4) v4(18.06,6.03) v4(18.07,5.2) v4(18.07,4.81) v4(18.07,4.42) v4(18.06,4.05) v4(18.3,104.31) v4(18.3,103.92) v4(18.3,103.53) v4(18.29,103.16) v4(18.3,3.23) v4(18.3,2.88) v4(18.68,5.35) v4(18.68,4.96) v4(18.68,4.57) v4(18.67,4.2) v4(18.75,7.41) v4(18.75,7.02) v4(18.76,6.62) v4(18.75,6.26) v4(18.78,2.86) v4(18.78,2.47) v4(18.78,2.08) v4(18.77,1.71) v4(18.9,94.67) v4(18.9,94.24) v4(18.9,93.48) v4(18.9,91.2) v4(18.9,87.09) v4(18.9,86.76) v4(18.9,68.82) v4(18.9,68.47) v4(18.85,62.97) v4(18.85,62.59) v4(18.85,62.24) v4(18.85,61.88) v4(18.91,101.94) v4(18.91,101.55) v4(18.92,101.16) v4(18.91,100.79) v4(18.91,98.16) v4(18.91,97.86) v4(18.92,97.57) v4(18.91,97.21) v4(18.91,93.85) v4(18.91,90.81) v4(18.91,90.38) v4(18.91,89.99) v4(18.91,87.85) v4(18.91,87.47) v4(18.95,84.45) v4(18.95,84.11) v4(18.95,83.75) v4(18.95,83.4) v4(18.91,80.8) v4(18.91,80.44) v4(18.92,79.77) v4(18.92,79.43) v4(18.91,77.45) v4(18.91,77.09) v4(18.91,76.7) v4(18.91,76.35) v4(18.91,73.82) v4(18.91,73.46) v4(18.92,72.12) v4(18.92,71.76) v4(18.91,70.4) v4(18.91,70.05) v4(19,18.93) v4(19,18.54) v4(19,18.15) v4(19.1,103.16) v4(19.03,58.1) v4(19.03,57.74) v4(19.03,50.86) v4(19.03,50.47) v4(19.03,50.08) v4(19.02,49.71) v4(19.05,34.25) v4(19.05,33.85) v4(19.05,33.46) v4(19.04,33.1) v4(19.03,17.79) v4(19.08,16.44) v4(19.08,16.05) v4(19.08,15.66) v4(19.07,15.29) v4(19.11,104.31) v4(19.11,103.92) v4(19.11,103.53) v4(19.13,47.63) v4(19.13,47.24) v4(19.13,46.85) v4(19.12,46.48) v4(19.13,35.78) v4(19.13,35.42) v4(19.13,24.55) v4(19.13,24.15) v4(19.13,23.76) v4(19.12,23.39) v4(19.18,22.06) v4(19.18,21.66) v4(19.18,21.27) v4(19.17,20.9) v4(19.2,13.19) v4(19.23,45.09) v4(19.23,44.7) v4(19.23,44.31) v4(19.22,43.94) v4(19.21,13.55) v4(19.38,50.86) v4(19.38,50.47) v4(19.38,50.08) v4(19.37,49.71) v4(19.36,42.25) v4(19.36,41.86) v4(19.36,41.46) v4(19.35,41.1) v4(19.4,31.55) v4(19.4,28.88) v4(19.46,35.78) v4(19.46,35.42) v4(19.41,32.7) v4(19.41,32.31) v4(19.41,31.91) v4(19.41,30.03) v4(19.41,29.64) v4(19.41,29.25) v4(19.46,27.19) v4(19.46,26.79) v4(19.46,26.4) v4(19.45,26.04) v4(19.49,2.51) v4(19.49,2.11) v4(19.49,1.72) v4(19.48,1.36) v4(19.58,23.89) v4(19.58,23.49) v4(19.59,23.1) v4(19.58,22.73) v4(19.54,13.55) v4(19.53,13.19) v4(19.56,11.39) v4(19.56,10.99) v4(19.56,10.6) v4(19.55,10.24) v4(19.57,8.93) v4(19.57,8.54) v4(19.57,8.15) v4(19.56,7.78) v4(19.63,18.4) v4(19.63,18.01) v4(19.64,17.61) v4(19.63,17.25) v4(19.7,14.76) v4(19.79,97.48) v4(19.79,97.08) v4(19.8,96.69) v4(19.79,96.33) v4(19.71,15.91) v4(19.71,15.52) v4(19.71,15.12) v4(19.82,104.29) v4(19.82,103.89) v4(19.82,103.5) v4(19.81,103.13) v4(19.86,45.68) v4(19.86,45.28) v4(19.87,44.89) v4(19.86,44.53) v4(19.86,36.1) v4(19.86,35.78) v4(19.86,35.42) v4(19.86,35.09) v4(19.81,21.52) v4(19.81,21.13) v4(19.82,20.74) v4(19.81,20.37) v4(19.89,13.88) v4(19.89,13.55) v4(19.89,13.19) v4(19.89,12.86) v4(20,85.54) v4(20,85.15) v4(20,84.76) v4(19.99,84.39) v4(19.99,42.83) v4(19.99,42.44) v4(19.99,42.05) v4(19.98,41.68) v4(20.04,33.28) v4(20.04,32.89) v4(20.04,32.5) v4(20.03,32.13) v4(20.04,30.62) v4(20.04,30.22) v4(20.04,29.83) v4(20.03,29.46) v4(20.09,27.77) v4(20.09,27.38) v4(20.09,26.99) v4(20.08,26.62) v4(20.19,50.81) v4(20.17,50.4) v4(20.17,50.02) v4(20.17,49.67) v4(20.19,10.86) v4(20.19,10.46) v4(20.2,10.07) v4(20.19,9.7) v4(20.18,8.65) v4(20.18,8.26) v4(20.18,7.87) v4(20.17,7.5) v4(20.12,1.97) v4(20.12,1.58) v4(20.13,1.19) v4(20.12,0.82) v4(20.22,24.47) v4(20.22,24.08) v4(20.22,23.68) v4(20.21,23.32) v4(20.27,18.98) v4(20.27,18.59) v4(20.27,18.2) v4(20.26,17.83) v4(20.35,16.49) v4(20.35,16.1) v4(20.35,15.71) v4(20.34,15.34) v4(20.5,50.81) v4(20.5,50.42) v4(20.5,50.02) v4(20.49,49.66) v4(20.5,45.2) v4(20.5,44.8) v4(20.5,44.41) v4(20.49,44.04) v4(20.45,22.11) v4(20.45,21.71) v4(20.45,21.32) v4(20.44,20.96) v4(20.63,85.01) v4(20.63,84.61) v4(20.64,84.22) v4(20.63,83.86) v4(20.63,42.35) v4(20.63,41.96) v4(20.63,41.57) v4(20.62,41.2) v4(20.68,32.8) v4(20.68,32.41) v4(20.68,32.02) v4(20.67,31.65) v4(20.68,30.13) v4(20.68,29.74) v4(20.68,29.35) v4(20.67,28.98) v4(20.7,3.49) v4(20.73,95.45) v4(20.73,95.05) v4(20.74,94.66) v4(20.73,94.29) v4(20.8,47.61) v4(20.8,47.22) v4(20.8,46.46) v4(20.73,27.29) v4(20.73,26.9) v4(20.73,26.5) v4(20.72,26.14) v4(20.8,5.78) v4(20.71,4.64) v4(20.71,4.25) v4(20.71,3.86) v4(20.81,46.82) v4(20.85,23.99) v4(20.85,23.59) v4(20.86,23.2) v4(20.85,22.84) v4(20.9,18.5) v4(20.9,18.11) v4(20.9,17.35) v4(20.83,11.44) v4(20.83,11.05) v4(20.83,10.65) v4(20.82,10.29) v4(20.91,17.72) v4(20.98,16.01) v4(20.98,15.62) v4(20.98,15.23) v4(20.97,14.86) v4(20.99,8.5) v4(20.99,8.11) v4(20.99,7.72) v4(20.98,7.35) v4(21.08,21.63) v4(21.08,21.23) v4(21.09,20.84) v4(21.08,20.47) v4(21.27,85.59) v4(21.27,85.2) v4(21.27,84.81) v4(21.26,84.44) v4(21.3,29.41) v4(21.31,30.57) v4(21.31,30.17) v4(21.31,29.78) v4(21.39,27.8) v4(21.39,27.4) v4(21.39,27.01) v4(21.38,26.65) v4(21.37,4.26) v4(21.37,3.87) v4(21.37,3.48) v4(21.36,3.11) v4(21.42,94.71) v4(21.42,94.32) v4(21.42,93.92) v4(21.41,93.56) v4(21.9,85.11) v4(21.9,84.71) v4(21.9,83.96) v4(21.91,84.32) v4(21.98,4.57) v4(21.98,4.17) v4(21.98,3.78) v4(21.97,3.41) v4(22.08,94.58) v4(22.08,94.19) v4(22.08,93.8) v4(22.07,93.43) v4(22.61,85.69) v4(22.61,85.3) v4(22.62,84.91) v4(22.61,84.54) v4(22.77,3.21) v4(22.77,2.85) v4(23.17,85.08) v4(23.17,84.69) v4(23.18,84.3) v4(23.17,83.93) v4(23.21,57.2) v4(23.29,36.81) v4(23.27,36.28) v4(23.27,35.6) v4(23.29,34.81) v4(23.27,34.07) v4(23.29,33.34) v4(23.37,15.66) v4(23.35,4.44) v4(23.35,4.04) v4(23.35,3.65) v4(23.34,3.29) v4(23.57,57.2) v4(23.6,36.28) v4(23.6,35.6) v4(23.6,34.07) v4(23.65,98.33) v4(23.62,97.93) v4(23.7,84.21) v4(23.7,74.03) v4(23.62,36.81) v4(23.62,34.81) v4(23.62,33.34) v4(23.7,15.66) v4(23.71,85.36) v4(23.71,84.97) v4(23.71,84.58) v4(23.9,57.2) v4(23.85,55.05) v4(23.83,3.68) v4(23.83,3.28) v4(23.84,2.89) v4(23.83,2.52) v4(23.95,36.81) v4(23.93,36.28) v4(23.93,35.6) v4(23.95,34.81) v4(23.93,34.07) v4(23.92,33.72) v4(24.09,95.57) v4(24.09,95.18) v4(24.09,94.79) v4(24.08,94.42) v4(24.01,15.53) v4(24.23,57.2) v4(24.21,55.05) v4(24.38,54.26) v4(24.46,99.07) v4(24.54,55.05) v4(24.62,98.04) v4(24.62,97.64) v4(24.62,97.25) v4(24.61,96.89) v4(24.63,5.14) v4(24.74,54.26) v4(24.71,10.32) v4(24.87,55.05) v4(24.95,95.6) v4(24.95,95.2) v4(24.95,94.81) v4(24.94,94.45) v4(25.05,100.59) v4(25.07,54.26) v4(25.21,39.86) v4(25.38,98.01) v4(25.38,97.62) v4(25.39,97.23) v4(25.38,96.86) v4(25.4,54.26) v4(25.39,10.32) v4(25.48,56.27) v4(25.48,55.56) v4(25.48,54.77) v4(25.44,39.71) v4(25.73,102.32) v4(25.73,101.99) v4(25.73,99.1) v4(25.83,56.27) v4(25.83,55.56) v4(25.83,54.77) v4(25.99,97.99) v4(25.99,97.59) v4(26,97.2) v4(25.98,96.83) v4(25.99,95.6) v4(25.99,95.2) v4(26,94.81) v4(25.98,94.45) v4(26.11,100.59) v4(26.16,56.27) v4(26.16,55.56) v4(26.16,54.77) v4(26.49,56.27) v4(26.49,55.56) v4(26.49,54.77) v4(26.59,103.5) v4(26.8,57.23) v4(26.88,94.58) v4(26.88,94.19) v4(26.88,93.8) v4(26.87,93.43) v4(26.9,71.08) v4(26.82,54.26) v4(27,103.5) v4(27.1,51.85) v4(27.1,48.83) v4(27.1,44.64) v4(27.1,41.21) v4(27.1,37.68) v4(27.1,30.74) v4(27.1,27.21) v4(27.1,23.66) v4(27.1,20.15) v4(27.1,16.62) v4(27.15,70.93) v4(27.16,57.23) v4(27.18,54.26) v4(27.11,53.13) v4(27.11,52.65) v4(27.11,52.23) v4(27.11,49.77) v4(27.11,49.46) v4(27.11,49.16) v4(27.11,45.96) v4(27.11,45.65) v4(27.11,45.12) v4(27.11,42.63) v4(27.11,42.15) v4(27.11,41.62) v4(27.11,39.05) v4(27.11,38.65) v4(27.11,38.12) v4(27.11,35.63) v4(27.11,35.15) v4(27.11,34.62) v4(27.11,34.14) v4(27.11,32.13) v4(27.11,31.65) v4(27.11,31.12) v4(27.11,28.63) v4(27.11,28.15) v4(27.11,27.62) v4(27.11,25.13) v4(27.11,24.65) v4(27.11,24.12) v4(27.11,21.63) v4(27.11,21.15) v4(27.11,20.62) v4(27.11,18.13) v4(27.11,17.65) v4(27.11,17.12) v4(27.49,57.23) v4(27.51,54.26) v4(27.69,88.73) v4(27.66,55.51) v4(27.72,103.49) v4(27.74,72.53) v4(27.79,71) v4(27.71,56.27) v4(27.82,57.23) v4(27.84,54.26) v4(27.96,72.69) v4(28.02,95.6) v4(28.02,95.2) v4(28.03,94.81) v4(28.02,94.45) v4(28.07,56.27) v4(28.02,55.51) v4(28.14,103.49) v4(28.19,87.83) v4(28.22,101.38) v4(28.25,99.35) v4(28.25,98.62) v4(28.25,97.88) v4(28.26,89.27) v4(28.4,56.27) v4(28.35,55.51) v4(28.58,71) v4(28.68,55.51) v4(28.73,56.27) v4(28.72,50.86) v4(28.72,49.19) v4(28.72,48.86) v4(28.72,10.9) v4(28.86,95.6) v4(28.86,95.2) v4(28.87,94.81) v4(28.86,94.45) v4(28.95,50.71) v4(29.05,49.19) v4(29.05,48.86) v4(29.08,43.04) v4(29.08,26.94) v4(29.08,22.23) v4(29.13,55.92) v4(29.23,44.13) v4(29.23,43.83) v4(29.23,43.52) v4(29.26,42.78) v4(29.25,22.46) v4(29.26,10.9) v4(29.3,7.5) v4(29.33,71) v4(29.36,49.19) v4(29.31,27.12) v4(29.49,55.92) v4(29.48,50.86) v4(29.5,31.85) v4(29.54,82.29) v4(29.65,95.65) v4(29.65,95.26) v4(29.65,94.86) v4(29.64,94.5) v4(29.66,49.19) v4(29.73,90.73) v4(29.74,57.18) v4(29.74,50.68) v4(29.72,26.35) v4(29.72,26.07) v4(29.72,25.79) v4(29.72,25.51) v4(29.72,25.21) v4(29.74,10.9) v4(29.82,55.92) v4(29.92,52.08) v4(30.08,85.11) v4(30.08,84.71) v4(30.08,84.32) v4(30.07,83.96) v4(30.09,58.53) v4(30.07,57.18) v4(30.09,51.83) v4(30.02,26.35) v4(30.02,26.07) v4(30.02,25.79) v4(30.02,25.51) v4(30.02,25.21) v4(30.1,17.21) v4(30.09,16.9) v4(30.15,55.92) v4(30.22,103.5) v4(30.28,27.24) v4(30.28,26.93) v4(30.28,26.63) v4(30.22,10.9) v4(30.4,94.5) v4(30.4,57.18) v4(30.4,26.12) v4(30.35,25.51) v4(30.35,25.21) v4(30.41,95.65) v4(30.41,95.26) v4(30.41,94.86) v4(30.46,86.53) v4(30.46,86.14) v4(30.47,85.75) v4(30.46,85.38) v4(30.58,25.9) v4(30.58,22.9) v4(30.58,19.83) v4(30.56,5.83) v4(30.61,27.24) v4(30.61,26.94) v4(30.61,26.63) v4(30.66,25.51) v4(30.66,25.21) v4(30.76,103.5) v4(30.73,91.73) v4(30.73,72.68) v4(30.77,57.18) v4(30.8,20.01) v4(30.73,16.8) v4(30.81,23.08) v4(30.88,17.03) v4(30.97,86.23) v4(30.97,85.83) v4(30.97,85.44) v4(30.96,85.07) v4(30.96,72.53) v4(31.09,82.29) v4(31.15,95.7) v4(31.15,95.31) v4(31.15,94.92) v4(31.14,94.55) v4(31.17,59.3) v4(31.24,103.5) v4(31.22,89.23) v4(31.5,71.08) v4(31.5,9.46) v4(31.42,4.18) v4(31.7,2.75) v4(31.7,2.42) v4(31.7,2.07) v4(31.7,1.74) v4(31.72,103.5) v4(31.73,70.93) v4(32,94.55) v4(31.97,6.62) v4(31.93,5.55) v4(32,4.76) v4(32.01,95.7) v4(32.01,95.31) v4(32.01,94.92) v4(32.01,61.43) v4(32.08,5.81) v4(32.06,2.75) v4(32.06,2.42) v4(32.06,2.06) v4(32.06,1.73) v4(32.22,90.23) v4(32.22,10.9) v4(32.23,4.1) v4(32.36,43.41) v4(32.46,68.06) v4(32.63,62.99) v4(32.76,43.01) v4(32.76,10.9) v4(32.92,23.89) v4(32.92,23.58) v4(32.92,23.25) v4(32.92,22.95) v4(33.08,40.37) v4(33.08,40.06) v4(33.08,39.76) v4(33.08,39.46) v4(33.08,39.15) v4(33.12,68.03) v4(33.14,57.21) v4(33.22,88.76) v4(33.22,23.89) v4(33.22,23.58) v4(33.22,23.25) v4(33.22,22.95) v4(33.24,10.9) v4(33.38,65.03) v4(33.33,2.75) v4(33.32,2.12) v4(33.49,57.21) v4(33.45,40.37) v4(33.45,40.07) v4(33.45,39.76) v4(33.45,39.46) v4(33.45,39.15) v4(33.6,85.46) v4(33.55,45.96) v4(33.54,24.54) v4(33.54,24.24) v4(33.53,23.89) v4(33.53,23.58) v4(33.53,23.25) v4(33.53,22.95) v4(33.61,86.61) v4(33.61,86.21) v4(33.62,85.82) v4(33.76,103.44) v4(33.78,71.08) v4(33.78,40.37) v4(33.78,40.07) v4(33.78,39.76) v4(33.78,39.46) v4(33.78,39.15) v4(33.72,10.9) v4(33.82,57.21) v4(33.86,24.24) v4(33.98,65.03) v4(33.96,45.96) v4(34.01,70.93) v4(34.12,86.2) v4(34.12,85.81) v4(34.12,85.42) v4(34.11,85.05) v4(34.15,61.08) v4(34.16,24.24) v4(34.2,6.2) v4(34.16,2.75) v4(34.18,2.17) v4(34.24,103.44) v4(34.27,23.86) v4(34.27,23.56) v4(34.27,23.23) v4(34.27,22.92) v4(34.37,95.7) v4(34.37,95.31) v4(34.38,94.92) v4(34.37,94.55) v4(34.31,49.59) v4(34.39,5.55) v4(34.47,24.24) v4(34.56,49.44) v4(34.57,23.86) v4(34.57,23.56) v4(34.57,23.23) v4(34.57,22.92) v4(34.52,20.02) v4(34.54,5.78) v4(34.67,103.44) v4(34.66,68.49) v4(34.64,45.93) v4(34.62,41.08) v4(34.62,13.7) v4(34.62,13.29) v4(34.78,92.86) v4(34.78,92.46) v4(34.78,92.07) v4(34.77,91.7) v4(34.78,91.23) v4(34.78,90.84) v4(34.78,90.44) v4(34.77,90.08) v4(34.72,25.52) v4(34.72,25.24) v4(34.75,19.87) v4(34.87,23.86) v4(34.87,23.56) v4(34.87,23.23) v4(34.87,22.92) v4(34.82,6.19) v4(35.08,103.44) v4(35.05,5.55) v4(35.2,49.28) v4(35.12,45.93) v4(35.17,42.78) v4(35.2,5.78) v4(35.15,2.78) v4(35.17,2.1) v4(35.26,57.2) v4(35.22,25.52) v4(35.22,25.23) v4(35.34,71.09) v4(35.33,42.56) v4(35.43,50.43) v4(35.42,7) v4(35.46,6.36) v4(35.56,70.87) v4(35.64,54.8) v4(35.66,50.28) v4(35.75,88.41) v4(35.75,88.02) v4(35.75,87.63) v4(35.74,87.26) v4(35.72,10.9) v4(35.9,54.8) v4(36.1,92.63) v4(36.1,92.23) v4(36.1,91.84) v4(36.09,91.48) v4(36.1,90.75) v4(36.1,90.35) v4(36.1,89.96) v4(36.09,89.6) v4(36.2,107.94) v4(36.2,87.23) v4(36.21,109.1) v4(36.21,108.7) v4(36.21,108.31) v4(36.21,93.74) v4(36.26,54.8) v4(36.27,38.54) v4(36.26,10.9) v4(36.44,50.28) v4(36.58,65.9) v4(36.6,45.58) v4(36.57,38.24) v4(36.64,57.2) v4(36.7,50.13) v4(36.75,45.32) v4(36.74,10.9) v4(36.71,2.69) v4(36.71,2.36) v4(36.71,2.01) v4(36.71,1.68) v4(36.86,54.8) v4(36.93,4.86) v4(37.02,109.07) v4(37.02,108.68) v4(37.02,108.29) v4(37.01,107.92) v4(37.07,2.69) v4(37.07,2.36) v4(37.07,2) v4(37.07,1.67) v4(37.16,20.41) v4(37.14,19.95) v4(37.14,19.47) v4(37.16,18.78) v4(37.14,18.32) v4(37.14,17.84) v4(37.22,103.5) v4(37.25,47.76) v4(37.24,42.25) v4(37.22,10.9) v4(37.36,50.48) v4(37.31,45.35) v4(37.39,43.01) v4(37.49,47.91) v4(37.5,45.53) v4(37.41,21.94) v4(37.41,21.21) v4(37.47,4.15) v4(37.51,50.25) v4(37.56,21.72) v4(37.56,20.98) v4(37.57,20.41) v4(37.57,19.95) v4(37.57,19.47) v4(37.57,18.78) v4(37.57,18.32) v4(37.57,17.84) v4(37.56,8.55) v4(37.59,5.53) v4(37.54,4.86) v4(37.61,7.79) v4(37.64,6.92) v4(37.76,103.5) v4(37.74,9.67) v4(37.74,5.76) v4(37.83,109.07) v4(37.83,108.68) v4(37.84,108.29) v4(37.83,107.92) v4(38,47.29) v4(38.07,111.04) v4(38.07,110.64) v4(38.07,110.25) v4(38.06,109.89) v4(38.17,57.17) v4(38.2,7.25) v4(38.2,6.54) v4(38.2,5.17) v4(38.21,103.52) v4(38.25,8.57) v4(38.23,5.75) v4(38.35,20.47) v4(38.32,20.01) v4(38.55,109.05) v4(38.55,108.65) v4(38.55,108.26) v4(38.54,107.89) v4(38.53,57.17) v4(38.7,103.52) v4(38.75,20.47) v4(38.75,20.01) v4(38.74,2.92) v4(38.88,111.01) v4(38.88,110.62) v4(38.88,110.23) v4(38.87,109.86) v4(38.88,59.59) v4(38.83,57.17) v4(38.91,8.12) v4(38.96,2.7) v4(39.26,36.36) v4(39.26,35.62) v4(39.21,22.88) v4(39.21,20.47) v4(39.21,20.01) v4(39.22,10.9) v4(39.37,49.57) v4(39.36,23.11) v4(39.42,36.1) v4(39.42,35.39) v4(39.52,100.21) v4(39.6,99.48) v4(39.59,97.9) v4(39.59,97.14) v4(39.59,96.45) v4(39.59,26.83) v4(39.59,26.09) v4(39.69,111.01) v4(39.69,110.62) v4(39.69,110.23) v4(39.68,109.86) v4(39.62,49.41) v4(39.62,34.83) v4(39.62,34.53) v4(39.62,34.22) v4(39.62,33.69) v4(39.62,33.39) v4(39.62,33.08) v4(39.76,54.69) v4(39.72,52.51) v4(39.74,27.09) v4(39.76,10.9) v4(39.82,36.59) v4(39.82,36.28) v4(39.83,35.98) v4(39.85,35.67) v4(39.85,35.37) v4(40,111.74) v4(39.95,34.83) v4(39.95,34.53) v4(39.95,34.22) v4(39.95,33.69) v4(39.95,33.39) v4(39.95,33.08) v4(40.01,112.9) v4(40.01,112.5) v4(40.01,112.11) v4(40.15,52.51) v4(40.15,36.59) v4(40.15,36.28) v4(40.16,35.98) v4(40.18,35.67) v4(40.18,35.37) v4(40.3,103.56) v4(40.24,54.69) v4(40.24,10.9) v4(40.4,110.99) v4(40.4,110.59) v4(40.4,109.84) v4(40.33,34.73) v4(40.33,34.43) v4(40.34,34.12) v4(40.33,33.77) v4(40.34,33.46) v4(40.41,110.2) v4(40.46,36.59) v4(40.46,36.28) v4(40.46,35.98) v4(40.48,35.65) v4(40.48,35.34) v4(40.49,35.04) v4(40.58,57.19) v4(40.58,15.1) v4(40.58,14.36) v4(40.69,102.02) v4(40.63,54.69) v4(40.66,34.73) v4(40.66,34.43) v4(40.67,34.12) v4(40.66,33.77) v4(40.66,25.08) v4(40.66,24.34) v4(40.67,22.16) v4(40.78,103.56) v4(40.79,36.59) v4(40.79,36.28) v4(40.79,35.98) v4(40.76,14.84) v4(40.76,14.11) v4(40.72,10.9) v4(40.82,112.87) v4(40.82,112.48) v4(40.82,112.09) v4(40.81,111.72) v4(40.81,35.65) v4(40.81,35.34) v4(40.82,35.04) v4(40.81,26.81) v4(40.81,26.07) v4(40.81,25.33) v4(40.81,24.6) v4(40.82,22.39) v4(40.94,70.1) v4(40.92,57.19) v4(41.08,61.19) v4(41.12,50.35) v4(41.12,49.92) v4(41.28,102.02) v4(41.27,57.19) v4(41.27,2.78) v4(41.33,54.67) v4(41.44,70.1) v4(41.6,57.19) v4(41.57,38.36) v4(41.63,112.87) v4(41.63,112.48) v4(41.64,112.09) v4(41.63,111.72) v4(41.62,103.56) v4(41.93,16.9) v4(41.91,16.44) v4(42.15,103.56) v4(42.11,38.36) v4(42.26,58.78) v4(42.21,21.63) v4(42.35,112.85) v4(42.35,112.45) v4(42.35,112.06) v4(42.34,111.69) v4(42.36,21.4) v4(42.34,16.9) v4(42.34,16.44) v4(42.31,2.1) v4(42.44,48.04) v4(42.44,47.66) v4(42.6,68.38) v4(42.55,5.26) v4(42.55,4.92) v4(42.69,66.2) v4(42.62,64.01) v4(42.64,3.5) v4(42.64,3.16) v4(42.73,102.04) v4(42.72,65.44) v4(42.72,27.77) v4(42.79,16.9) v4(42.79,16.44) v4(42.72,10.9) v4(42.9,54.88) v4(42.85,5.26) v4(42.85,4.92) v4(42.95,43.5) v4(42.97,27.62) v4(42.93,3.5) v4(42.93,3.16) v4(43.06,47.99) v4(43.05,42.51) v4(43.05,6.94) v4(43.23,54.88) v4(43.29,47.84) v4(43.3,43.5) v4(43.3,42.35) v4(43.26,10.9) v4(43.38,52.51) v4(43.46,102.04) v4(43.5,37.19) v4(43.47,25.9) v4(43.47,25.62) v4(43.54,96.48) v4(43.58,95.48) v4(43.58,92.48) v4(43.51,91.98) v4(43.58,90.98) v4(43.59,40.8) v4(43.58,17.77) v4(43.64,112.9) v4(43.64,112.5) v4(43.64,112.11) v4(43.63,111.74) v4(43.61,93.91) v4(43.68,52.53) v4(43.76,37.04) v4(43.73,35.6) v4(43.74,10.9) v4(43.84,57.27) v4(43.81,17.61) v4(43.97,25.9) v4(43.97,25.62) v4(44.05,90.99) v4(44.11,94.94) v4(44.19,57.27) v4(44.17,54.87) v4(44.22,103.5) v4(44.26,102.04) v4(44.29,40.55) v4(44.22,10.9) v4(44.32,38.13) v4(44.45,112.87) v4(44.45,112.48) v4(44.45,112.09) v4(44.44,111.72) v4(44.41,54.63) v4(44.49,37.88) v4(44.58,94.97) v4(44.58,94.48) v4(44.58,59.22) v4(44.55,36.33) v4(44.67,46.14) v4(44.65,45.1) v4(44.67,40.55) v4(44.76,103.5) v4(44.9,44.94) v4(44.99,102.04) v4(44.97,25.93) v4(44.97,25.59) v4(45.08,97.98) v4(45.08,91.48) v4(45.26,112.87) v4(45.26,112.48) v4(45.27,112.09) v4(45.26,111.72) v4(45.29,59.22) v4(45.25,26.97) v4(45.31,103.5) v4(45.54,40.52) v4(45.59,26.97) v4(45.65,92.03) v4(45.65,89.93) v4(45.67,57.11) v4(45.66,35.62) v4(45.66,34.62) v4(45.8,103.5) v4(45.98,112.85) v4(45.98,112.45) v4(45.98,112.06) v4(45.97,111.69) v4(45.99,61.09) v4(45.92,40.52) v4(45.95,35.62) v4(45.95,34.62) v4(46.08,97.98) v4(46.08,96.48) v4(46.08,95.98) v4(46.08,95.48) v4(46.06,94.54) v4(46.08,92.98) v4(46.13,89.98) v4(46.3,45.99) v4(46.25,30.47) v4(46.22,10.9) v4(46.58,92.48) v4(46.68,17.51) v4(46.73,54.8) v4(46.73,33.23) v4(46.78,30.47) v4(46.76,10.9) v4(46.86,40.55) v4(46.86,17.22) v4(47.07,83.93) v4(47.06,54.8) v4(47.01,17.51) v4(47.09,9.62) v4(47.14,49.08) v4(47.19,33.23) v4(47.19,17.22) v4(47.27,112.94) v4(47.27,112.54) v4(47.27,112.15) v4(47.26,111.79) v4(47.27,109.01) v4(47.27,108.62) v4(47.27,108.23) v4(47.26,107.86) v4(47.24,40.55) v4(47.21,15.53) v4(47.24,10.9) v4(47.39,54.79) v4(47.39,30.47) v4(47.32,9.47) v4(47.48,26.97) v4(47.47,22.92) v4(47.58,89.98) v4(47.52,59.39) v4(47.57,57.23) v4(47.54,15.53) v4(47.7,54.8) v4(47.69,46.66) v4(47.7,46.16) v4(47.68,38.11) v4(47.68,37.83) v4(47.65,23.17) v4(47.72,103.5) v4(47.73,50.36) v4(47.8,49.28) v4(47.8,48.96) v4(47.75,45.68) v4(47.75,45.02) v4(47.75,44.56) v4(47.72,43.9) v4(47.72,43.42) v4(47.72,10.9) v4(47.72,4.53) v4(47.91,83.93) v4(47.82,48.37) v4(47.82,47.99) v4(47.82,26.97) v4(47.88,9.62) v4(47.85,5.56) v4(47.85,5.16) v4(47.92,57.23) v4(47.93,50.62) v4(47.97,49.56) v4(47.97,46.85) v4(47.95,45.99) v4(47.93,33.23) v4(47.93,30.47) v4(47.93,15.53) v4(47.95,4.38) v4(48.08,112.91) v4(48.08,112.52) v4(48.09,112.13) v4(48.08,111.76) v4(48.08,108.99) v4(48.08,108.59) v4(48.09,108.2) v4(48.08,107.83) v4(48.08,97.98) v4(48.08,95.98) v4(48.08,92.48) v4(48.08,90.98) v4(48.05,44.89) v4(48.18,85.96) v4(48.11,9.47) v4(48.26,103.5) v4(48.21,61.07) v4(48.21,60.23) v4(48.21,59.42) v4(48.21,52.69) v4(48.28,33.23) v4(48.32,57.24) v4(48.36,36.56) v4(48.41,13.24) v4(48.58,95.98) v4(48.58,90.98) v4(48.52,90.47) v4(48.57,52.69) v4(48.51,20.15) v4(48.56,13.5) v4(48.67,57.24) v4(48.74,20) v4(48.71,1.79) v4(48.9,112.91) v4(48.9,112.52) v4(48.9,112.13) v4(48.89,111.76) v4(48.9,108.99) v4(48.9,108.59) v4(48.9,108.2) v4(48.89,107.83) v4(48.81,103.5) v4(48.84,24.62) v4(48.81,9.72) v4(48.99,24.37) v4(48.96,3.57) v4(49.08,95.98) v4(49.08,92.48) v4(49.03,89.98) v4(49.07,52.69) v4(49.09,12.76) v4(49.09,6.82) v4(49.3,103.5) v4(49.4,52.69) v4(49.32,26.35) v4(49.39,23.73) v4(49.32,12.61) v4(49.6,111.74) v4(49.6,107.81) v4(49.58,94.98) v4(49.58,94.07) v4(49.58,92.98) v4(49.58,92.48) v4(49.56,32.57) v4(49.53,20.15) v4(49.61,112.89) v4(49.61,112.49) v4(49.61,112.1) v4(49.61,108.96) v4(49.61,108.57) v4(49.61,108.18) v4(49.62,94.59) v4(49.63,54.83) v4(49.66,26.35) v4(49.68,19.9) v4(49.73,61.07) v4(49.73,60.31) v4(49.71,52.66) v4(49.72,10.9) v4(49.84,41.87) v4(49.86,12.76) v4(49.94,54.83) v4(49.98,1.89) v4(50.08,92.54) v4(50.09,89.94) v4(50.01,46.52) v4(50.01,45.88) v4(50.01,45.22) v4(50.2,111.3) v4(50.2,110.91) v4(50.2,110.15) v4(50.19,86.5) v4(50.19,52.69) v4(50.12,44.46) v4(50.12,43.8) v4(50.11,12.61) v4(50.19,9.77) v4(50.21,110.52) v4(50.24,54.83) v4(50.26,10.9) v4(50.29,6.85) v4(50.48,109) v4(50.48,108.61) v4(50.48,108.21) v4(50.47,107.85) v4(50.5,52.69) v4(50.42,42.73) v4(50.49,27.47) v4(50.49,27.16) v4(50.49,26.32) v4(50.49,25.97) v4(50.49,24.83) v4(50.6,112.9) v4(50.6,112.5) v4(50.6,111.74) v4(50.55,54.83) v4(50.51,25.38) v4(50.51,24.24) v4(50.51,23.73) v4(50.61,112.11) v4(50.62,12.76) v4(50.62,1.89) v4(50.76,103.63) v4(50.8,52.69) v4(50.75,46.52) v4(50.75,45.88) v4(50.75,45.22) v4(50.71,44.46) v4(50.71,43.8) v4(50.78,32.62) v4(50.74,10.9) v4(50.87,12.61) v4(51,57.3) v4(51.02,111.28) v4(51.02,110.88) v4(51.02,110.49) v4(51.01,110.12) v4(51.08,97.98) v4(51.08,96.98) v4(51.08,96.48) v4(51.08,32.62) v4(51.11,41.89) v4(51.29,108.97) v4(51.29,108.58) v4(51.29,108.19) v4(51.28,107.82) v4(51.25,103.63) v4(51.25,59.56) v4(51.23,43.6) v4(51.22,10.9) v4(51.36,61.05) v4(51.36,60.44) v4(51.37,57.28) v4(51.31,52.69) v4(51.32,46.52) v4(51.32,45.88) v4(51.32,45.22) v4(51.42,112.87) v4(51.42,112.48) v4(51.42,112.09) v4(51.41,111.72) v4(51.58,97.48) v4(51.58,96.98) v4(51.58,96.48) v4(51.58,95.48) v4(51.58,94.98) v4(51.58,92.48) v4(51.58,91.48) v4(51.61,52.69) v4(51.63,1.89) v4(51.76,9.77) v4(51.86,57.28) v4(51.92,52.69) v4(51.92,46.52) v4(51.92,45.88) v4(51.92,45.22) v4(52.09,103.63) v4(52.01,4.13) v4(52.18,57.27) v4(52.23,112.87) v4(52.23,112.48) v4(52.23,112.09) v4(52.22,111.72) v4(52.32,13.73) v4(52.32,13.42) v4(52.32,13.12) v4(52.4,5.27) v4(52.4,4.89) v4(52.4,4.51) v4(52.4,3.88) v4(52.6,52.69) v4(52.52,20.08) v4(52.52,1.89) v4(52.62,103.63) v4(52.61,46.52) v4(52.61,45.88) v4(52.61,45.22) v4(52.66,31.45) v4(52.72,109.55) v4(52.72,109.15) v4(52.72,108.76) v4(52.71,108.4) v4(52.76,84.31) v4(52.79,37.01) v4(52.75,19.92) v4(52.78,12.61) v4(52.81,86.85) v4(52.94,112.85) v4(52.94,112.45) v4(52.94,112.06) v4(52.93,111.69) v4(52.91,52.69) v4(52.95,31.45) v4(52.93,12.36) v4(53.1,37.01) v4(53.14,101.91) v4(53.11,54.68) v4(53.22,111.33) v4(53.22,110.94) v4(53.23,110.55) v4(53.22,110.18) v4(53.21,52.69) v4(53.25,31.45) v4(53.22,10.9) v4(53.28,5.15) v4(53.28,4.38) v4(53.28,3.75) v4(53.37,58.76) v4(53.31,20.08) v4(53.42,40.22) v4(53.53,109.52) v4(53.53,109.13) v4(53.53,108.74) v4(53.52,108.37) v4(53.52,25.71) v4(53.52,25.21) v4(53.54,24.67) v4(53.54,24.36) v4(53.54,24.06) v4(53.54,23.28) v4(53.59,22.13) v4(53.54,19.92) v4(53.56,14.29) v4(53.64,54.68) v4(53.72,14.54) v4(53.76,10.9) v4(53.87,101.91) v4(53.81,25.71) v4(53.81,25.21) v4(53.83,24.67) v4(53.83,24.36) v4(53.83,24.06) v4(53.83,23.28) v4(53.88,3.24) v4(53.88,2.85) v4(53.92,4.76) v4(53.92,4.13) v4(54.1,111.83) v4(54.04,111.31) v4(54.04,110.91) v4(54.04,110.52) v4(54.03,110.16) v4(54.05,22.13) v4(54.05,20.08) v4(54.11,112.98) v4(54.11,112.59) v4(54.11,112.2) v4(54.17,57.31) v4(54.12,54.68) v4(54.28,86.65) v4(54.25,27.57) v4(54.25,27.01) v4(54.25,26.41) v4(54.28,19.92) v4(54.24,10.9) v4(54.28,8.88) v4(54.36,109.05) v4(54.36,108.66) v4(54.37,108.27) v4(54.35,107.9) v4(54.32,103.49) v4(54.34,40.26) v4(54.34,39.95) v4(54.47,57.31) v4(54.55,54.73) v4(54.61,101.15) v4(54.65,52.57) v4(54.63,40.26) v4(54.63,39.95) v4(54.78,103.49) v4(54.8,57.31) v4(54.72,10.9) v4(54.76,6.09) v4(54.76,5.75) v4(54.85,111.31) v4(54.85,110.91) v4(54.85,110.52) v4(54.84,110.16) v4(54.82,27.57) v4(54.82,27.01) v4(54.82,26.41) v4(54.83,20.08) v4(54.89,8.27) v4(54.89,6.54) v4(54.92,112.96) v4(54.92,112.56) v4(54.92,112.17) v4(54.91,111.8) v4(54.93,52.36) v4(55.09,19.92) v4(55.18,109.03) v4(55.18,108.64) v4(55.18,108.24) v4(55.17,107.88) v4(55.14,61.05) v4(55.14,60.28) v4(55.14,59.57) v4(55.11,57.31) v4(55.26,103.5) v4(55.32,17.18) v4(55.32,12.61) v4(55.32,3.75) v4(55.43,52.56) v4(55.42,27.57) v4(55.42,27.01) v4(55.42,26.41) v4(55.47,12.38) v4(55.56,111.28) v4(55.56,110.89) v4(55.56,110.5) v4(55.55,110.13) v4(55.54,30.39) v4(55.54,30.08) v4(55.67,17.18) v4(55.66,3.29) v4(55.73,112.96) v4(55.73,112.56) v4(55.74,112.17) v4(55.73,111.8) v4(55.77,103.48) v4(55.72,52.35) v4(55.8,6.56) v4(55.83,30.08) v4(55.85,25.78) v4(55.82,20.33) v4(55.9,13.73) v4(55.9,13.42) v4(55.9,13.14) v4(55.82,3.75) v4(55.99,109.03) v4(55.99,108.64) v4(55.99,108.24) v4(55.98,107.88) v4(56.08,20.15) v4(56.03,17.18) v4(56.12,101.16) v4(56.29,6.54) v4(56.45,112.93) v4(56.45,112.54) v4(56.45,112.14) v4(56.44,111.78) v4(56.56,6.09) v4(56.56,5.75) v4(56.7,109) v4(56.7,108.61) v4(56.7,108.22) v4(56.69,107.85) v4(56.67,6.54) v4(56.76,54.7) v4(56.74,20.08) v4(56.71,17.66) v4(56.72,10.9) v4(56.85,101.16) v4(56.97,19.9) v4(56.97,17.51) v4(57,6.54) v4(57.09,8.14) v4(57.2,59.33) v4(57.24,58.93) v4(57.25,54.7) v4(57.26,10.9) v4(57.25,3.88) v4(57.38,99.63) v4(57.4,98.89) v4(57.38,98.08) v4(57.4,8.83) v4(57.38,6.51) v4(57.49,111.21) v4(57.49,110.81) v4(57.49,110.42) v4(57.48,110.06) v4(57.44,61.02) v4(57.46,60.31) v4(57.45,13.14) v4(57.45,5.4) v4(57.61,112.94) v4(57.61,112.54) v4(57.62,112.15) v4(57.61,111.79) v4(57.63,101.94) v4(57.61,57.29) v4(57.63,12.91) v4(57.65,3.85) v4(57.73,54.7) v4(57.74,10.9) v4(57.79,6.54) v4(57.92,57.29) v4(58.09,54.7) v4(58.09,8.14) v4(58.17,60.21) v4(58.14,20.69) v4(58.3,111.18) v4(58.3,110.79) v4(58.3,110.4) v4(58.29,110.03) v4(58.22,103.5) v4(58.25,25.78) v4(58.25,25.47) v4(58.25,25.18) v4(58.25,24.64) v4(58.25,24.33) v4(58.25,24.04) v4(58.23,22.22) v4(58.22,21.89) v4(58.22,10.9) v4(58.36,6.09) v4(58.36,5.75) v4(58.43,112.91) v4(58.43,112.52) v4(58.43,112.13) v4(58.42,111.76) v4(58.43,23.21) v4(58.45,22.88) v4(58.47,4.97) v4(58.62,8.73) v4(58.7,6.82) v4(58.76,103.5) v4(58.8,16.57) v4(58.92,20.08) v4(59.1,110.03) v4(59.11,111.18) v4(59.11,110.79) v4(59.11,110.4) v4(59.11,101.1) v4(59.21,40.6) v4(59.21,40.31) v4(59.11,24.41) v4(59.11,24.12) v4(59.15,16.57) v4(59.24,112.91) v4(59.24,112.52) v4(59.24,112.13) v4(59.23,111.76) v4(59.25,6.82) v4(59.31,103.52) v4(59.33,8.17) v4(59.42,24.41) v4(59.42,24.12) v4(59.56,84.97) v4(59.69,60.89) v4(59.64,57.3) v4(59.66,20.08) v4(59.8,103.52) v4(59.72,60.18) v4(59.77,20.69) v4(59.82,111.16) v4(59.82,110.76) v4(59.83,110.37) v4(59.82,110.01) v4(59.85,101.11) v4(59.84,16.09) v4(59.95,112.89) v4(59.95,112.49) v4(59.95,112.1) v4(59.94,111.74) v4(59.94,57.3) v4(60.1,50.49) v4(60.1,50.16) v4(60.1,49.83) v4(60.09,15.94) v4(60.15,108.93) v4(60.15,108.53) v4(60.15,108.14) v4(60.14,107.78) v4(60.13,49.37) v4(60.13,49.04) v4(60.13,48.71) v4(60.13,48.29) v4(60.13,47.96) v4(60.13,47.63) v4(60.13,47.16) v4(60.13,46.83) v4(60.13,46.5) v4(60.22,10.9) v4(60.36,25.31) v4(60.36,25.02) v4(60.36,24.74) v4(60.39,24.36) v4(60.39,24.06) v4(60.39,23.78) v4(60.42,54.81) v4(60.42,20.08) v4(60.59,101.95) v4(60.54,26.44) v4(60.54,26.16) v4(60.55,16.87) v4(60.76,10.9) v4(60.86,28.74) v4(60.86,28.46) v4(60.86,28.13) v4(60.85,27.56) v4(60.84,27.28) v4(60.84,26.97) v4(60.85,26.44) v4(60.85,16.87) v4(60.96,108.9) v4(60.96,108.51) v4(60.96,108.12) v4(60.95,107.75) v4(60.96,85.38) v4(60.95,54.81) v4(61.08,112.98) v4(61.08,112.59) v4(61.08,112.2) v4(61.07,111.83) v4(61.03,111.33) v4(61.03,110.94) v4(61.04,110.55) v4(61.03,110.18) v4(61.05,50.48) v4(61.05,50.15) v4(61.05,49.82) v4(61.07,49.31) v4(61.07,48.98) v4(61.07,48.65) v4(61.05,48.19) v4(61.05,47.86) v4(61.05,47.53) v4(61.05,47.13) v4(61.05,46.8) v4(61.05,46.47) v4(61.24,10.9) v4(61.35,101.95) v4(61.34,96.46) v4(61.31,95.52) v4(61.36,93.98) v4(61.38,92.48) v4(61.36,91.98) v4(61.36,90.98) v4(61.34,90.48) v4(61.44,54.81) v4(61.77,108.9) v4(61.77,108.51) v4(61.77,108.12) v4(61.76,107.75) v4(61.72,103.5) v4(61.72,10.9) v4(61.76,3.51) v4(61.76,3.12) v4(61.89,112.96) v4(61.89,112.56) v4(61.89,112.17) v4(61.88,111.8) v4(61.85,111.31) v4(61.85,110.91) v4(61.85,110.52) v4(61.84,110.16) v4(61.86,90.98) v4(61.88,57.25) v4(61.92,54.81) v4(62.04,41.31) v4(62.04,41.01) v4(62.04,40.7) v4(62.04,40.12) v4(62.04,39.81) v4(62.26,103.5) v4(62.33,90.46) v4(62.31,51.99) v4(62.31,51.23) v4(62.48,108.88) v4(62.48,108.48) v4(62.49,108.09) v4(62.48,107.73) v4(62.55,57.3) v4(62.54,52.5) v4(62.55,51.7) v4(62.54,50.96) v4(62.6,15.78) v4(62.51,9.69) v4(62.7,112.96) v4(62.7,112.56) v4(62.7,112.17) v4(62.69,111.8) v4(62.66,111.31) v4(62.66,110.91) v4(62.66,110.52) v4(62.65,110.16) v4(62.87,103.5) v4(62.86,97.98) v4(62.86,57.3) v4(62.87,9.69) v4(62.9,4.87) v4(62.92,91.48) v4(62.93,22.44) v4(63.05,53.23) v4(63.04,22.13) v4(63.03,2.57) v4(63.15,32.13) v4(63.25,53.8) v4(63.22,22.44) v4(63.4,111.78) v4(63.37,111.28) v4(63.37,110.89) v4(63.37,110.5) v4(63.36,110.13) v4(63.35,103.5) v4(63.36,91.98) v4(63.32,89.98) v4(63.38,82.34) v4(63.35,57.29) v4(63.41,112.93) v4(63.41,112.54) v4(63.41,112.14) v4(63.45,58.81) v4(63.45,31.83) v4(63.52,53.46) v4(63.6,35.91) v4(63.63,30.54) v4(63.8,92.98) v4(63.73,57.16) v4(63.75,31.83) v4(63.72,10.9) v4(63.86,97.98) v4(63.86,94.48) v4(63.85,27.6) v4(63.86,26.94) v4(63.89,13.93) v4(63.88,13.57) v4(63.96,89.98) v4(63.95,54.78) v4(63.97,52.36) v4(63.95,44.19) v4(63.95,43.56) v4(63.91,35.91) v4(64.18,52.11) v4(64.19,30.54) v4(64.21,35.91) v4(64.24,31.82) v4(64.26,10.9) v4(64.36,95.98) v4(64.36,92.48) v4(64.38,52.36) v4(64.31,18.12) v4(64.49,54.78) v4(64.44,20.43) v4(64.57,52.11) v4(64.54,31.82) v4(64.57,27.6) v4(64.57,26.94) v4(64.54,17.97) v4(64.67,57.28) v4(64.79,44.19) v4(64.79,43.56) v4(64.77,30.18) v4(64.74,10.9) v4(64.86,95.98) v4(64.85,61.35) v4(64.85,31.83) v4(64.99,66.16) v4(64.97,54.78) v4(64.97,22.87) v4(65.06,58.79) v4(65.09,52.39) v4(65.15,86.85) v4(65.22,103.5) v4(65.3,52.1) v4(65.25,29.71) v4(65.25,29.08) v4(65.26,27.22) v4(65.26,26.92) v4(65.22,10.9) v4(65.36,89.98) v4(65.45,54.78) v4(65.56,71.35) v4(65.54,69.65) v4(65.58,68.91) v4(65.6,63.57) v4(65.58,62.82) v4(65.53,53.02) v4(65.51,52.38) v4(65.53,42.96) v4(65.55,27.22) v4(65.55,26.92) v4(65.64,44.19) v4(65.66,30.57) v4(65.76,103.5) v4(65.8,65.33) v4(65.71,62.19) v4(65.77,58.76) v4(65.71,52.11) v4(65.73,39.63) v4(65.73,39) v4(65.73,38.29) v4(65.71,13.09) v4(65.86,97.98) v4(65.86,92.48) v4(65.81,63.08) v4(65.89,40.7) v4(65.82,29.71) v4(65.82,29.08) v4(65.97,57.3) v4(66.29,85.33) v4(66.27,68.18) v4(66.31,103.52) v4(66.31,96) v4(66.36,90.48) v4(66.31,61.39) v4(66.33,57.3) v4(66.39,39.63) v4(66.39,39) v4(66.39,38.29) v4(66.35,29.71) v4(66.36,29.09) v4(66.35,28.37) v4(66.35,27.71) v4(66.46,44.19) v4(66.46,43.56) v4(66.47,24.17) v4(66.52,65.35) v4(66.52,21.75) v4(66.69,57.3) v4(66.68,30.59) v4(66.8,103.52) v4(66.8,92.54) v4(66.86,89.98) v4(66.92,29.71) v4(66.92,29.08) v4(66.92,28.37) v4(66.92,27.71) v4(67.05,68.92) v4(67.08,42.53) v4(67.13,39.63) v4(67.13,39) v4(67.13,38.29) v4(67.24,68.58) v4(67.26,63.84) v4(67.22,54.8) v4(67.22,11) v4(67.36,92.98) v4(67.36,68.93) v4(67.59,30.57) v4(67.51,29.71) v4(67.51,29.08) v4(67.51,28.37) v4(67.51,27.71) v4(67.7,39.63) v4(67.7,39) v4(67.7,38.29) v4(67.64,5.05) v4(67.62,4.28) v4(67.62,3.49) v4(67.79,62.81) v4(67.76,54.8) v4(67.76,11) v4(67.85,97.97) v4(67.86,89.98) v4(67.89,41.95) v4(67.95,63.05) v4(67.92,5.67) v4(68.02,71.54) v4(68.15,58.68) v4(68.22,116.76) v4(68.24,54.8) v4(68.3,39.63) v4(68.3,39) v4(68.3,38.29) v4(68.24,11) v4(68.36,97.98) v4(68.58,29.06) v4(68.58,28.76) v4(68.72,103.5) v4(68.78,71.54) v4(68.71,59.42) v4(68.72,54.8) v4(68.72,11) v4(68.86,96.98) v4(68.87,29.06) v4(68.87,28.76) v4(69.06,86.85) v4(69.05,59.42) v4(69.14,6.77) v4(69.26,103.5) v4(69.27,27.49) v4(69.35,101.1) v4(69.36,96.48) v4(69.36,95.48) v4(69.36,94.98) v4(69.36,92.48) v4(69.36,91.48) v4(69.39,59.42) v4(69.37,39.98) v4(69.55,113.14) v4(69.52,40.23) v4(69.59,9.57) v4(69.59,9.23) v4(69.79,103.52) v4(69.75,39.98) v4(69.72,29.06) v4(69.72,28.76) v4(69.84,61.46) v4(69.9,40.23) v4(69.89,9.57) v4(69.89,9.23) v4(69.98,50.58) v4(69.98,50.15) v4(69.98,49.49) v4(69.98,49.11) v4(69.98,48.34) v4(69.98,47.96) v4(69.98,47.2) v4(69.98,45.53) v4(69.98,44.97) v4(69.98,44.59) v4(70.09,101.95) v4(70.08,83.47) v4(70.01,29.06) v4(70.01,28.76) v4(70.14,23.02) v4(70.27,103.52) v4(70.23,50.3) v4(70.23,50) v4(70.23,49.34) v4(70.23,48.96) v4(70.23,48.19) v4(70.23,47.81) v4(70.23,47.05) v4(70.26,45.53) v4(70.23,44.82) v4(70.23,44.43) v4(70.24,38.21) v4(70.34,39.26) v4(70.34,38.88) v4(70.33,37.88) v4(70.33,37.56) v4(70.34,36.63) v4(70.34,35.94) v4(70.34,35.55) v4(70.59,39.11) v4(70.58,36.89) v4(70.59,36.48) v4(70.59,35.78) v4(70.72,11.03) v4(70.82,101.95) v4(70.83,54.8) v4(70.88,29.05) v4(70.88,28.75) v4(70.92,86.83) v4(70.94,50.48) v4(70.95,45.05) v4(70.95,44.67) v4(70.96,26.01) v4(71.07,60.7) v4(71.12,74.74) v4(71.15,35.5) v4(71.16,29.05) v4(71.16,28.75) v4(71.18,9.74) v4(71.26,54.8) v4(71.26,11.03) v4(71.41,60.7) v4(71.43,50.48) v4(71.55,101.1) v4(71.62,26.46) v4(71.76,60.7) v4(71.74,54.8) v4(71.74,11.03) v4(71.88,50.48) v4(71.96,33.54) v4(71.96,33.16) v4(71.99,29.08) v4(71.99,28.78) v4(71.99,26.45) v4(71.92,9.71) v4(72.1,116.11) v4(72.1,114.63) v4(72.18,27.29) v4(72.22,103.5) v4(72.29,101.1) v4(72.22,54.8) v4(72.24,42.49) v4(72.24,42.18) v4(72.21,33.39) v4(72.21,33.01) v4(72.28,29.08) v4(72.28,28.78) v4(72.22,11.03) v4(72.6,100.39) v4(72.6,98.84) v4(72.6,96.43) v4(72.56,72.9) v4(72.61,22.95) v4(72.76,103.5) v4(72.98,44.27) v4(73.03,101.1) v4(73.05,19.86) v4(73.2,46.44) v4(73.11,42.82) v4(73.24,103.5) v4(73.23,44.08) v4(73.26,42.59) v4(73.36,100.36) v4(73.31,62.85) v4(73.44,80.3) v4(73.51,87.84) v4(73.51,45.73) v4(73.59,33.06) v4(73.72,103.5) v4(73.76,101.1) v4(73.79,35.57) v4(73.74,34.48) v4(73.77,9.61) v4(73.8,8.87) v4(73.84,97.88) v4(73.84,97.13) v4(73.88,94.6) v4(74,98.09) v4(74,97.34) v4(73.91,95.72) v4(73.97,80.43) v4(73.94,46.44) v4(73.94,6.54) v4(73.94,6.2) v4(73.94,5.82) v4(74.09,35.57) v4(74.01,13.26) v4(74.18,12.99) v4(74.22,87.84) v4(74.22,54.8) v4(74.24,53.53) v4(74.22,11.03) v4(74.23,6.54) v4(74.23,6.2) v4(74.23,5.82) v4(74.38,83.28) v4(74.35,82.8) v4(74.47,36) v4(74.47,35.7) v4(74.42,33.15) v4(74.6,83.46) v4(74.55,82.64) v4(74.56,41.2) v4(74.58,29.78) v4(74.68,32.86) v4(74.65,30.9) v4(74.68,24.52) v4(74.8,62.85) v4(74.76,54.8) v4(74.78,41.02) v4(74.8,36) v4(74.8,35.7) v4(74.76,11.03) v4(74.84,80.19) v4(74.83,9.5) v4(74.98,45.77) v4(75.1,18.12) v4(75.1,17.23) v4(75.2,94.62) v4(75.2,94.09) v4(75.2,93.63) v4(75.17,93.18) v4(75.15,92.69) v4(75.15,92.24) v4(75.17,91.83) v4(75.17,91.37) v4(75.17,90.87) v4(75.18,85.13) v4(75.16,46.02) v4(75.13,36) v4(75.13,35.7) v4(75.19,34.61) v4(75.19,33.03) v4(75.24,54.8) v4(75.24,11.03) v4(75.21,10.26) v4(75.21,9.25) v4(75.22,6.69) v4(75.22,6.35) v4(75.22,5.98) v4(75.22,5.64) v4(75.36,45.77) v4(75.37,34.38) v4(75.34,9.76) v4(75.47,103.46) v4(75.5,42.72) v4(75.55,94.62) v4(75.55,94.09) v4(75.55,93.63) v4(75.55,93.18) v4(75.55,92.67) v4(75.51,92.24) v4(75.55,91.83) v4(75.53,91.32) v4(75.58,90.87) v4(75.54,81.19) v4(75.59,61.12) v4(75.51,46.02) v4(75.51,6.69) v4(75.51,6.35) v4(75.51,5.98) v4(75.51,5.64) v4(75.72,54.8) v4(75.77,42.72) v4(75.72,11.03) v4(75.85,10.26) v4(76,96.99) v4(75.91,94.62) v4(75.93,94.09) v4(75.93,93.63) v4(75.93,93.18) v4(75.93,92.64) v4(75.91,92.22) v4(75.92,91.83) v4(75.93,91.35) v4(75.96,90.87) v4(75.93,61.12) v4(75.99,14.82) v4(75.97,9.25) v4(76.1,45.76) v4(76.1,9.76) v4(76.14,77.81) v4(76.2,32.88) v4(76.28,96.99) v4(76.29,94.62) v4(76.29,94.09) v4(76.29,93.63) v4(76.3,93.2) v4(76.29,92.24) v4(76.25,61.12) v4(76.28,46.01) v4(76.34,103.46) v4(76.31,92.64) v4(76.33,91.81) v4(76.33,91.32) v4(76.35,90.87) v4(76.32,74.03) v4(76.33,24.57) v4(76.48,45.76) v4(76.48,10.26) v4(76.56,96.99) v4(76.51,87.74) v4(76.53,45.04) v4(76.67,94.62) v4(76.67,94.09) v4(76.67,93.63) v4(76.69,93.2) v4(76.69,92.64) v4(76.66,92.23) v4(76.63,46.01) v4(76.7,19.97) v4(76.7,7.58) v4(76.79,103.46) v4(76.71,91.81) v4(76.71,91.32) v4(76.71,90.87) v4(76.79,32.58) v4(76.84,96.99) v4(76.86,9.76) v4(76.86,9.25) v4(76.91,79.54) v4(76.96,78.42) v4(77.08,94.62) v4(77.04,94.09) v4(77.05,93.61) v4(77.07,93.2) v4(77.04,92.64) v4(77.06,92.24) v4(77.06,91.78) v4(77.09,91.32) v4(77.06,87.74) v4(77.12,90.87) v4(77.2,41.35) v4(77.2,41.05) v4(77.24,10.26) v4(77.32,103.46) v4(77.34,66.74) v4(77.42,94.62) v4(77.45,94.09) v4(77.45,93.58) v4(77.45,93.2) v4(77.41,92.64) v4(77.43,92.21) v4(77.43,91.81) v4(77.45,91.32) v4(77.47,90.84) v4(77.52,51.01) v4(77.52,50.68) v4(77.52,50.33) v4(77.54,28.67) v4(77.61,66.74) v4(77.8,93.58) v4(77.8,93.2) v4(77.79,92.64) v4(77.79,92.21) v4(77.79,91.81) v4(77.8,91.32) v4(77.8,90.84) v4(77.73,75.48) v4(77.72,11.03) v4(77.75,9.76) v4(77.83,94.62) v4(77.84,94.09) v4(77.87,74.66) v4(77.88,51.01) v4(77.88,50.68) v4(77.88,50.35) v4(77.86,41.35) v4(77.86,41.05) v4(78.09,90.84) v4(78.2,93.2) v4(78.19,92.64) v4(78.12,92.19) v4(78.12,91.81) v4(78.12,91.3) v4(78.18,83.25) v4(78.21,94.62) v4(78.21,94.07) v4(78.22,93.58) v4(78.24,79.42) v4(78.21,67.52) v4(78.26,11.03) v4(78.39,5.83) v4(78.49,41.35) v4(78.49,41.02) v4(78.51,83.25) v4(78.58,74.66) v4(78.58,74.38) v4(78.58,74.1) v4(78.59,21.4) v4(78.74,66.42) v4(78.74,11.03) v4(78.84,83.25) v4(78.82,14.61) v4(78.92,21.4) v4(79.02,9.53) v4(79.17,68.75) v4(79.2,65.67) v4(79.22,103.67) v4(79.27,27.86) v4(79.25,21.4) v4(79.22,11.03) v4(79.4,81.21) v4(79.35,68.96) v4(79.38,65.9) v4(79.32,63.46) v4(79.53,49.72) v4(79.53,49.39) v4(79.53,49.06) v4(79.64,85.85) v4(79.76,103.64) v4(79.76,7.11) v4(79.87,86.03) v4(79.89,77.92) v4(79.88,49.72) v4(79.88,49.39) v4(79.88,49.06) v4(79.96,12.4) v4(79.93,11.87) v4(80.06,43.55) v4(80.04,27.59) v4(80.04,22.62) v4(80.11,76.78) v4(80.29,43.39) v4(80.29,12.4) v4(80.26,11.87) v4(80.37,103.6) v4(80.32,98.38) v4(80.32,96.82) v4(80.39,84.08) v4(80.57,98.54) v4(80.56,96.98) v4(80.53,89.85) v4(80.56,84.32) v4(80.65,24.29) v4(80.75,90.01) v4(80.72,71.76) v4(80.85,103.6) v4(80.82,43.55) v4(80.87,25.29) v4(80.87,20.69) v4(80.85,20.15) v4(80.85,19.47) v4(81.05,43.39) v4(81.1,16.49) v4(81.08,15.96) v4(81.2,20.69) v4(81.18,20.15) v4(81.18,19.47) v4(81.28,13.12) v4(81.31,13.65) v4(81.43,56.75) v4(81.41,56.22) v4(81.43,16.49) v4(81.41,15.96) v4(81.53,20.69) v4(81.51,20.15) v4(81.51,19.47) v4(81.64,13.65) v4(81.61,13.12) v4(81.76,56.75) v4(81.74,56.22) v4(82.2,56.63) v4(82.17,56.09) v4(82.29,101.84) v4(82.29,101.01) v4(82.28,100.67) v4(82.29,80.75) v4(82.29,80.39) v4(82.28,80.01) v4(82.28,79.58) v4(82.28,73.96) v4(82.29,73.62) v4(82.3,73.26) v4(82.3,72.93) v4(82.24,52.2) v4(82.23,49.55) v4(82.31,101.39) v4(82.4,87.61) v4(82.39,86.5) v4(82.39,85.98) v4(82.34,84.27) v4(82.33,83.84) v4(82.32,83.48) v4(82.32,83) v4(82.38,77.04) v4(82.36,76.53) v4(82.38,76.16) v4(82.37,75.61) v4(82.4,70.42) v4(82.39,70.02) v4(82.4,48.52) v4(82.4,29.55) v4(82.33,24.37) v4(82.33,24.01) v4(82.33,23.28) v4(82.33,22.95) v4(82.4,17.1) v4(82.4,16.7) v4(82.37,14.61) v4(82.37,14.28) v4(82.4,12.81) v4(82.4,12.46) v4(82.44,98.37) v4(82.49,94.58) v4(82.49,94.2) v4(82.49,93.81) v4(82.46,91.39) v4(82.44,90.97) v4(82.44,90.48) v4(82.44,90.08) v4(82.42,86.94) v4(82.41,69.65) v4(82.41,69.25) v4(82.5,65.95) v4(82.5,65.58) v4(82.44,63.36) v4(82.46,62.96) v4(82.45,62.59) v4(82.43,62.25) v4(82.5,56.09) v4(82.41,48.12) v4(82.41,47.79) v4(82.43,45.77) v4(82.43,45.29) v4(82.43,44.8) v4(82.43,42.27) v4(82.43,41.79) v4(82.43,41.3) v4(82.43,40.77) v4(82.43,38.79) v4(82.43,38.31) v4(82.43,37.83) v4(82.43,37.29) v4(82.43,35.32) v4(82.43,34.89) v4(82.43,33.94) v4(82.43,33.61) v4(82.45,32.55) v4(82.43,31.72) v4(82.43,31.23) v4(82.43,30.75) v4(82.43,30.22) v4(82.43,28.29) v4(82.43,27.81) v4(82.43,27.33) v4(82.43,26.79) v4(82.46,21.27) v4(82.46,20.79) v4(82.46,20.3) v4(82.46,19.77) v4(82.42,18.12) v4(82.42,17.76) v4(82.52,96.93) v4(82.51,96.6) v4(82.52,96.27) v4(82.51,94.94) v4(82.53,65.17) v4(82.53,64.84) v4(82.53,56.63) v4(82.52,52.95) v4(82.52,52.62) v4(82.52,52.36) v4(82.63,7.65) v4(82.63,7.15) v4(83.08,42.4) v4(83.19,51.98) v4(83.16,51.44) v4(83.13,50.94) v4(83.11,50.4) v4(83.11,42.94) v4(83.16,41.51) v4(83.13,40.98) v4(83.16,40.17) v4(83.13,39.63) v4(83.16,26.48) v4(83.13,25.94) v4(83.24,53.07) v4(83.21,52.54) v4(83.26,47.23) v4(83.24,46.69) v4(83.29,46.19) v4(83.26,45.65) v4(83.24,24.17) v4(83.26,23.56) v4(83.29,22.93) v4(83.24,21.68) v4(83.26,20.89) v4(83.49,51.44) v4(83.47,50.94) v4(83.44,50.4) v4(83.44,42.94) v4(83.41,42.4) v4(83.49,41.51) v4(83.47,40.98) v4(83.49,40.17) v4(83.47,39.63) v4(83.49,26.48) v4(83.47,25.94) v4(83.57,53.07) v4(83.54,52.54) v4(83.52,51.98) v4(83.59,47.23) v4(83.57,46.69) v4(83.59,45.65) v4(83.62,46.19) v4(83.67,34.76) v4(83.64,34.22) v4(83.67,33.39) v4(83.64,32.85) v4(83.71,88.96) v4(83.77,31.81) v4(83.74,31.28) v4(83.8,30.57) v4(83.77,30.03) v4(83.88,89.15) v4(83.85,60.54) v4(83.82,60) v4(83.85,58.56) v4(83.82,58.02) v4(83.9,28.56) v4(83.87,28.03) v4(83.9,26.48) v4(83.85,25.92) v4(84,43.6) v4(83.97,43.06) v4(83.95,42.25) v4(83.92,41.72) v4(83.97,40.83) v4(83.95,40.29) v4(84,34.76) v4(83.97,34.22) v4(84,33.39) v4(83.97,32.85) v4(83.95,19.57) v4(83.95,19.03) v4(83.97,18.35) v4(84.1,31.81) v4(84.07,31.28) v4(84.1,30.03) v4(84.07,21.73) v4(84.1,20.89) v4(84.18,60.54) v4(84.15,60) v4(84.18,58.56) v4(84.15,58.02) v4(84.13,30.57) v4(84.2,28.03) v4(84.3,43.06) v4(84.28,42.25) v4(84.25,41.72) v4(84.3,40.83) v4(84.28,40.29) v4(84.23,28.56) v4(84.3,18.35) v4(84.33,43.6) v4(84.33,19.57) v4(84.33,19.03) v4(84.46,21.75) v4(84.51,20.89) v4(84.86,21.75) v4(84.96,59.67) v4(84.97,59.34) v4(84.96,59.01) v4(84.96,32.09) v4(84.91,20.89) v4(85.27,21.73) v4(85.29,20.89) v4(85.27,20.48) v4(85.24,19.95) v4(85.24,19.26) v4(85.28,11.26) v4(85.47,61) v4(85.55,99.92) v4(85.55,99.53) v4(85.55,90.27) v4(85.55,87.07) v4(85.53,86.17) v4(85.53,85.86) v4(85.6,19.95) v4(85.6,19.26) v4(85.62,20.48) v4(85.73,61.16) v4(85.85,99.92) v4(85.86,99.54) v4(85.83,86.19) v4(85.83,85.87) v4(85.9,82.71) v4(85.88,77.76) v4(86.21,82.71) v4(86.21,77.76) v4(86.27,57.19) v4(86.27,56.83) v4(86.21,26.35) v4(86.21,25.92) v4(86.4,66.39) v4(86.49,7.1) v4(86.56,82.71) v4(86.51,63.41) v4(86.53,32.04) v4(86.56,30.24) v4(86.59,25.94) v4(86.56,22.67) v4(86.56,21.73) v4(86.59,19.97) v4(86.62,66.54) v4(86.61,26.37) v4(86.64,20.91) v4(86.61,14.49) v4(86.61,11.44) v4(86.86,82.71) v4(86.94,22.67) v4(86.94,21.73) v4(86.97,20.91) v4(86.94,19.97) v4(87.2,82.71) v4(87.13,66.39) v4(87.2,17.26) v4(87.29,30.24) v4(87.28,22.67) v4(87.28,21.73) v4(87.35,99.88) v4(87.35,99.55) v4(87.38,86.14) v4(87.39,85.82) v4(87.36,66.54) v4(87.4,20.94) v4(87.33,19.97) v4(87.37,14.49) v4(87.37,11.44) v4(87.4,2.8) v4(87.68,99.88) v4(87.66,99.56) v4(87.65,95.47) v4(87.65,87.07) v4(87.68,85.84) v4(87.71,86.17) v4(87.76,26.4) v4(87.73,25.87) v4(87.73,20.94) v4(87.71,19.97) v4(87.76,2.8) v4(87.9,109.04) v4(87.86,66.39) v4(88.08,66.54) v4(88.09,2.8) v4(88.14,26.4) v4(88.11,25.87) v4(88.13,14.49) v4(88.13,11.44) v4(88.34,65.56) v4(88.48,112.11) v4(88.44,109.53) v4(88.48,108) v4(88.49,56.26) v4(88.6,66.38) v4(88.7,112.29) v4(88.66,109.7) v4(88.68,108.16) v4(88.62,65.56) v4(88.74,56.42) v4(88.9,100.37) v4(88.82,66.54) v4(88.99,98.94) v4(88.93,96.78) v4(88.95,95.39) v4(88.91,94.35) v4(88.93,93.81) v4(88.93,93.33) v4(89.02,97.89) v4(89.22,112.11) v4(89.21,108.01) v4(89.23,59.37) v4(89.23,56.97) v4(89.24,56.26) v4(89.33,66.38) v4(89.42,112.29) v4(89.42,108.18) v4(89.46,59.52) v4(89.47,57.13) v4(89.46,56.43) v4(89.45,35.85) v4(89.59,59.98) v4(89.61,60.51) v4(89.94,60.51) v4(89.92,59.98) v4(90.14,89.83) v4(90.14,88.99) v4(90.14,88.16) v4(90.19,84.93) v4(90.19,84.09) v4(90.26,87.49) v4(90.31,88.44) v4(90.47,85.21) v4(90.47,84.37) v4(90.58,61.68) v4(90.55,61.15) v4(90.6,60.26) v4(90.58,59.73) v4(90.88,61.15) v4(90.91,61.68) v4(90.93,60.26) v4(90.91,59.73) v4(92.79,62.27) v4(92.76,61.73) v4(92.76,60.06) v4(92.74,59.52) v4(92.84,90.03) v4(92.85,67.15) v4(92.99,82.56) v4(93.03,67.37) v4(93.09,61.73) v4(93.09,60.06) v4(93.07,59.52) v4(93.12,62.27) v4(93.37,82.56) v4(93.47,64.02) v4(93.45,63.48) v4(93.68,82.56) v4(93.8,64.02) v4(93.78,63.48) v4(94.9,65.21) v4(94.87,64.68) v4(95.2,64.68) v4(95.23,65.21) v4(95.86,66.38) v4(95.83,65.85) v4(96.09,95.61) v4(96.19,92.67) v4(96.19,66.38) v4(96.17,65.85) v4(96.36,92.87) v4(96.42,95.61) v4(97.77,82.86) v4(97.75,82.21) v4(97.76,68.95) v4(97.77,68.26) v4(98.03,82.54) v4(98.3,82.85) v4(98.32,82.18) v4(98.31,68.95) v4(98.31,68.26) v5(42.26,61.16) v5(42.56,72.8) v5(42.8,72.83) v5(43.49,66.86) v5(45.41,76.67) v5(45.42,63.64) v5(45.7,65.05) v5(45.79,63.38) v5(46.33,78.18) v5(46.35,76.36) v5(46.36,70.74) v5(46.36,69.61) v5(46.36,67.34) v5(46.36,65.07) v5(46.33,63.32) v5(46.41,68.5) v5(46.41,66.21) v5(46.63,77.25) v5(46.63,63.03) v5(46.86,78.72) v5(46.9,71.3) v5(46.91,64.49) v5(46.92,75.83) v5(46.94,73.64) v5(46.95,70.16) v5(47.14,77.25) v5(47.2,74.98) v5(47.18,71.03) v5(47.2,67.64) v5(47.23,72.13) v5(47.21,70.48) v5(47.28,69.33) v5(47.28,68.75) v5(47.48,73.57) v5(47.5,71.9) v5(47.46,70.78) v5(47.47,70.16) v5(47.48,69.04) v5(47.48,67.91) v5(47.5,65.08) v5(47.49,64.51) v5(47.72,71.04) v5(47.75,64.8) v5(47.98,81.77) v5(47.97,75.81) v5(48.3,62.99) v5(48.4,72.18) v5(48.32,65.95) v5(48.59,78.09) v5(48.59,76.93) v5(48.61,73) v5(48.63,71.3) v5(48.63,66.22) v5(48.8,73.29) v5(48.9,81.77) v5(48.9,77.25) v5(49.1,67.58) v5(49.18,78.66) v5(49.13,73.63) v5(49.14,73.08) v5(49.12,70.89) v5(49.11,70.33) v5(49.11,69.79) v5(49.13,69.24) v5(49.15,68.66) v5(49.11,68.11) v5(49.23,72) v5(49.21,64.51) v5(49.45,78.39) v5(49.47,63.02) v5(49.6,67.87) v5(49.8,66.22) v5(49.73,65.07) v5(50.03,76.68) v5(50.06,72.51) v5(50.06,71.97) v5(50.07,70.88) v5(50.09,69.23) v5(50.02,65.39) v5(50.15,67.53) v5(50.27,66.54) v5(50.28,65.65) v5(50.34,81.77) v5(50.6,77.25) v5(50.56,72.82) v5(50.58,71.72) v5(50.6,71.21) v5(50.56,70.05) v5(50.54,69.53) v5(50.56,67.87) v5(50.56,67.32) v5(50.56,66.76) v5(50.54,63.05) v5(50.89,78.08) v5(50.88,64.51) v5(51.04,75.22) v5(51.04,67.59) v5(51.16,65.98) v5(51.16,64.22) v5(51.26,81.77) v5(51.41,66.2) v5(51.52,75.01) v5(51.52,73.91) v5(51.52,73.36) v5(51.53,72.84) v5(51.53,72.23) v5(51.53,71.77) v5(51.53,69.52) v5(51.52,67.88) v5(51.52,67.3) v5(51.73,77.25) v5(51.71,65.39) v5(51.73,64.81) v5(52,74.19) v5(52,73.63) v5(52,69.78) v5(51.98,67.02) v5(51.98,64.51) v5(52.01,77.53) v5(52.03,66.25) v5(52.03,65.62) v5(52.15,81.77) v5(52.24,66.47) v5(52.3,65.35) v5(52.47,73.91) v5(52.47,73.35) v5(52.47,69.51) v5(52.5,66.78) v5(52.52,77.57) v5(52.59,65.07) v5(52.86,81.76) v5(52.86,77.25) v5(52.95,74.74) v5(52.96,74.18) v5(52.94,71.98) v5(52.94,70.31) v5(52.95,69.22) v5(52.94,67.6) v5(53.1,76.96) v5(53.14,78.72) v5(53.16,77.53) v5(53.12,64.46) v5(53.42,79.02) v5(53.43,71.71) v5(53.42,67.83) v5(53.42,67.3) v5(53.46,65.94) v5(53.43,64.23) v5(53.59,81.77) v5(53.71,77.53) v5(53.8,67.09) v5(53.9,67.57) v5(53.99,77.25) v5(53.91,70.89) v5(54.03,66.47) v5(54.26,77.53) v5(54.24,66.24) v5(54.21,64.51) v5(54.38,74.46) v5(54.38,70.6) v5(54.39,69.5) v5(54.34,67.79) v5(54.54,65.93) v5(54.89,77.53) v5(54.87,74.19) v5(54.86,73.64) v5(55.12,77.25) v5(55.12,63.03) v5(55.33,73.95) v5(55.33,73.36) v5(55.33,70.61) v5(55.32,69.5) v5(55.43,66.74) v5(55.47,66.23) v5(55.8,73.62) v5(55.81,74.15) v5(55.81,70.33) v5(55.81,69.23) v5(55.96,78.01) v5(55.97,63.35) v5(56.25,77.25) v5(56.25,76.11) v5(56.28,73.91) v5(56.28,71.7) v5(56.28,70.06) v5(56.3,67.79) v5(56.29,67.31) v5(56.29,66.76) v5(56.48,63.37) v5(56.59,77.53) v5(56.54,76.96) v5(56.72,81.67) v5(56.77,77.25) v5(56.74,75.37) v5(56.76,74.74) v5(56.76,74.19) v5(56.76,73.09) v5(56.75,71.98) v5(56.79,68.07) v5(56.77,67.03) v5(56.85,79.09) v5(56.82,76.68) v5(56.85,65.94) v5(57.24,74.46) v5(57.24,73.91) v5(57.24,70.61) v5(57.24,70.06) v5(57.24,69.51) v5(57.24,68.96) v5(57.23,67.3) v5(57.4,78.94) v5(57.68,64.53) v5(57.73,73.06) v5(57.93,77.34) v5(58.09,81.75) v5(58.18,71.3) v5(58.24,78.05) v5(58.22,73.07) v5(58.21,69.59) v5(58.22,67.92) v5(58.23,67.37) v5(58.23,66.11) v5(58.23,64.51) v5(58.32,33.74) v5(58.32,33.34) v5(58.49,73.83) v5(58.48,64.77) v5(58.47,64.23) v5(58.47,63.02) v5(58.51,73.32) v5(58.52,69.31) v5(58.52,67.62) v5(58.51,67.07) v5(58.8,76.4) v5(58.79,69.59) v5(58.79,65.59) v5(58.83,78.66) v5(58.88,77.58) v5(59.03,71) v5(59.11,81.77) v5(59.36,69.04) v5(59.36,67.9) v5(59.36,67.35) v5(59.65,77.25) v5(59.65,74.98) v5(59.65,73.85) v5(59.62,70.97) v5(59.67,68.77) v5(59.64,67.62) v5(59.9,73.64) v5(59.9,67.9) v5(59.93,75.83) v5(59.91,71.31) v5(59.93,65.65) v5(59.92,65.03) v5(59.91,63.37) v5(60.16,73.87) v5(60.22,79.02) v5(60.22,77.25) v5(60.48,76.42) v5(60.5,75.27) v5(60.46,74.17) v5(60.45,71.86) v5(60.5,67.35) v5(60.49,66.19) v5(60.48,65.11) v5(60.55,78.1) v5(60.51,77.49) v5(60.59,72.98) v5(60.52,70.68) v5(60.79,73.86) v5(60.82,63.03) v5(61.04,78.66) v5(61.06,63.38) v5(61.11,71.27) v5(61.13,68.46) v5(61.28,62.84) v5(61.28,62.59) v5(61.4,64.75) v5(61.42,77.25) v5(61.45,73.33) v5(61.47,70.6) v5(61.48,67.03) v5(61.44,66.05) v5(61.42,64.22) v5(63.2,73.64) v5(63.27,69.65) v5(63.36,71.33) v5(63.48,73.64) v5(64.02,69.64) v5(64.06,68.15) v5(64.06,67.39) v5(64.06,66.63) v5(64.05,64.36) v5(64.11,71.36) v5(64.17,65.97) v5(64.19,63.83) v5(64.17,62.92) v5(64.25,69.11) v5(64.26,65.3) v5(64.79,69.64) v6(42.26,61.16) v6(42.56,72.8) v6(42.8,72.83) v6(43.49,66.86) v6(45.41,76.67) v6(45.42,63.64) v6(45.7,65.05) v6(45.79,63.38) v6(46.33,78.18) v6(46.35,76.36) v6(46.36,70.74) v6(46.36,69.61) v6(46.36,67.34) v6(46.36,65.07) v6(46.33,63.32) v6(46.41,68.5) v6(46.41,66.21) v6(46.63,77.25) v6(46.63,63.03) v6(46.86,78.72) v6(46.9,71.3) v6(46.91,64.49) v6(46.92,75.83) v6(46.94,73.64) v6(46.95,70.16) v6(47.14,77.25) v6(47.2,74.98) v6(47.18,71.03) v6(47.2,67.64) v6(47.23,72.13) v6(47.21,70.48) v6(47.28,69.33) v6(47.28,68.75) v6(47.48,73.57) v6(47.5,71.9) v6(47.46,70.78) v6(47.47,70.16) v6(47.48,69.04) v6(47.48,67.91) v6(47.5,65.08) v6(47.49,64.51) v6(47.72,71.04) v6(47.75,64.8) v6(47.98,81.77) v6(47.97,75.81) v6(48.3,62.99) v6(48.4,72.18) v6(48.32,65.95) v6(48.59,78.09) v6(48.59,76.93) v6(48.61,73) v6(48.63,71.3) v6(48.63,66.22) v6(48.8,73.29) v6(48.9,81.77) v6(48.9,77.25) v6(49.1,67.58) v6(49.18,78.66) v6(49.13,73.63) v6(49.14,73.08) v6(49.12,70.89) v6(49.11,70.33) v6(49.11,69.79) v6(49.13,69.24) v6(49.15,68.66) v6(49.11,68.11) v6(49.23,72) v6(49.21,64.51) v6(49.45,78.39) v6(49.47,63.02) v6(49.6,67.87) v6(49.8,66.22) v6(49.73,65.07) v6(50.03,76.68) v6(50.06,72.51) v6(50.06,71.97) v6(50.07,70.88) v6(50.09,69.23) v6(50.02,65.39) v6(50.05,64.83) v6(50.15,67.53) v6(50.27,66.54) v6(50.28,65.65) v6(50.3,64.49) v6(50.34,81.77) v6(50.6,77.25) v6(50.56,72.82) v6(50.58,71.72) v6(50.6,71.21) v6(50.56,70.05) v6(50.54,69.53) v6(50.56,67.87) v6(50.56,67.32) v6(50.56,66.76) v6(50.54,63.05) v6(50.89,78.08) v6(50.88,64.51) v6(51.04,75.22) v6(51.04,67.59) v6(51.16,65.98) v6(51.16,64.22) v6(51.26,81.77) v6(51.41,66.2) v6(51.52,75.01) v6(51.52,73.91) v6(51.52,73.36) v6(51.53,72.84) v6(51.53,72.23) v6(51.53,71.77) v6(51.53,69.52) v6(51.52,67.88) v6(51.52,67.3) v6(51.73,77.25) v6(51.71,65.39) v6(51.73,64.81) v6(52,74.19) v6(52,73.63) v6(52,69.78) v6(51.98,67.02) v6(51.98,64.51) v6(52.01,77.53) v6(52.03,66.25) v6(52.03,65.62) v6(52.15,81.77) v6(52.24,66.47) v6(52.3,65.35) v6(52.47,73.91) v6(52.47,73.35) v6(52.47,69.51) v6(52.5,66.78) v6(52.52,77.57) v6(52.59,65.07) v6(52.86,81.76) v6(52.86,77.25) v6(52.95,74.74) v6(52.96,74.18) v6(52.94,71.98) v6(52.94,70.31) v6(52.95,69.22) v6(52.94,67.6) v6(53.1,76.96) v6(53.14,78.72) v6(53.16,77.53) v6(53.12,64.46) v6(53.42,79.02) v6(53.43,71.71) v6(53.42,67.83) v6(53.42,67.3) v6(53.46,65.94) v6(53.43,64.23) v6(53.59,81.77) v6(53.71,77.53) v6(53.8,67.09) v6(53.9,67.57) v6(53.99,77.25) v6(53.91,70.89) v6(54.03,66.47) v6(54.26,77.53) v6(54.24,66.24) v6(54.21,64.51) v6(54.38,74.46) v6(54.37,72.81) v6(54.38,70.6) v6(54.39,69.5) v6(54.34,67.79) v6(54.54,65.93) v6(54.89,77.53) v6(54.87,74.19) v6(54.86,73.64) v6(55.12,77.25) v6(55.12,63.03) v6(55.33,73.95) v6(55.33,73.36) v6(55.33,70.61) v6(55.32,69.5) v6(55.43,66.74) v6(55.47,66.23) v6(55.8,73.62) v6(55.81,74.15) v6(55.81,70.33) v6(55.81,69.23) v6(55.96,78.01) v6(55.97,63.35) v6(55.92,35.74) v6(55.92,35.34) v6(55.92,32.94) v6(55.92,32.14) v6(56.25,77.25) v6(56.25,76.11) v6(56.28,73.91) v6(56.28,71.7) v6(56.28,70.06) v6(56.3,67.79) v6(56.29,67.31) v6(56.29,66.76) v6(56.32,37.34) v6(56.32,36.94) v6(56.32,32.94) v6(56.32,32.54) v6(56.32,32.14) v6(56.48,63.37) v6(56.59,77.53) v6(56.54,76.96) v6(56.72,81.67) v6(56.77,77.25) v6(56.74,75.37) v6(56.76,74.74) v6(56.76,74.19) v6(56.76,73.09) v6(56.75,71.98) v6(56.79,68.07) v6(56.77,67.03) v6(56.72,37.34) v6(56.72,36.94) v6(56.72,32.94) v6(56.85,79.09) v6(56.82,76.68) v6(56.85,65.94) v6(57.24,74.46) v6(57.24,73.91) v6(57.24,70.61) v6(57.24,70.06) v6(57.24,69.51) v6(57.24,68.96) v6(57.23,67.3) v6(57.4,78.94) v6(57.68,64.53) v6(57.73,73.06) v6(57.93,77.34) v6(58.09,81.75) v6(58.18,71.3) v6(58.24,78.05) v6(58.22,73.07) v6(58.21,69.59) v6(58.22,67.92) v6(58.23,67.37) v6(58.23,66.11) v6(58.23,64.51) v6(58.32,33.74) v6(58.32,33.34) v6(58.49,73.83) v6(58.48,64.77) v6(58.47,64.23) v6(58.47,63.02) v6(58.51,73.32) v6(58.52,69.31) v6(58.52,67.62) v6(58.51,67.07) v6(58.8,76.4) v6(58.79,69.59) v6(58.79,65.59) v6(58.83,78.66) v6(58.88,77.58) v6(59.03,71) v6(59.11,81.77) v6(59.12,37.74) v6(59.36,69.04) v6(59.36,67.9) v6(59.36,67.35) v6(59.52,37.74) v6(59.65,77.25) v6(59.65,74.98) v6(59.65,73.85) v6(59.62,70.97) v6(59.67,68.77) v6(59.64,67.62) v6(59.9,73.64) v6(59.9,67.9) v6(59.93,75.83) v6(59.91,71.31) v6(59.93,65.65) v6(59.92,65.03) v6(59.91,63.37) v6(60.16,73.87) v6(60.22,79.02) v6(60.22,77.25) v6(60.48,76.42) v6(60.5,75.27) v6(60.46,74.17) v6(60.45,71.86) v6(60.5,67.35) v6(60.49,66.19) v6(60.48,65.11) v6(60.55,78.1) v6(60.51,77.49) v6(60.59,72.98) v6(60.52,70.68) v6(60.79,73.86) v6(60.72,37.34) v6(60.72,36.94) v6(60.72,32.14) v6(60.82,63.03) v6(61.04,78.66) v6(61.06,63.38) v6(61.11,71.27) v6(61.13,68.46) v6(61.12,37.34) v6(61.12,36.94) v6(61.12,35.74) v6(61.12,32.14) v6(61.28,62.84) v6(61.28,62.59) v6(61.4,64.75) v6(61.42,77.25) v6(61.45,73.33) v6(61.47,70.6) v6(61.48,67.03) v6(61.44,66.05) v6(61.42,64.22) v6(61.52,35.74) v6(61.52,34.54) v6(61.52,32.14) v6(63.2,73.64) v6(63.27,69.65) v6(63.36,71.33) v6(63.48,73.64) v6(64.02,69.64) v6(64.06,68.15) v6(64.06,67.39) v6(64.06,66.63) v6(64.05,64.36) v6(64.11,71.36) v6(64.17,65.97) v6(64.19,63.83) v6(64.17,62.92) v6(64.25,69.11) v6(64.26,65.3) v6(64.79,69.64) v7(4.2,72.46) v7(4.2,72.03) v7(4.2,71.6) v7(4.2,71.19) v7(4.63,72.46) v7(4.63,72.06) v7(4.63,71.62) v7(4.63,71.19) v7(4.79,112.06) v7(4.79,111.63) v7(4.79,111.2) v7(4.79,110.79) v7(4.87,117.09) v7(4.87,116.65) v7(4.87,116.22) v7(4.87,115.82) v7(4.83,114.55) v7(4.83,114.12) v7(4.83,113.69) v7(4.83,113.28) v7(4.85,109.38) v7(4.85,108.98) v7(5.03,72.46) v7(5.03,72.03) v7(5.03,71.6) v7(5.03,71.19) v7(5.3,117.09) v7(5.3,116.68) v7(5.3,116.25) v7(5.3,115.82) v7(5.26,114.55) v7(5.26,114.15) v7(5.26,113.72) v7(5.26,113.28) v7(5.22,112.06) v7(5.22,111.66) v7(5.22,111.22) v7(5.22,110.79) v7(5.26,109.41) v7(5.26,108.98) v7(5.21,76.9) v7(5.21,76.46) v7(5.21,76.03) v7(5.21,75.63) v7(5.47,72.46) v7(5.47,72.06) v7(5.47,71.62) v7(5.47,71.19) v7(5.67,114.55) v7(5.67,114.12) v7(5.67,113.69) v7(5.67,113.28) v7(5.63,112.06) v7(5.63,111.63) v7(5.63,111.2) v7(5.63,110.79) v7(5.69,109.41) v7(5.69,108.98) v7(5.64,76.9) v7(5.64,76.49) v7(5.64,76.06) v7(5.64,75.63) v7(5.71,117.09) v7(5.71,116.65) v7(5.71,116.22) v7(5.71,115.82) v7(6.1,114.55) v7(6.1,114.15) v7(6.1,113.72) v7(6.1,113.28) v7(6.06,112.06) v7(6.06,111.66) v7(6.06,111.22) v7(6.06,110.79) v7(6.09,109.38) v7(6.09,108.98) v7(6.1,82.93) v7(6.1,82.5) v7(6.1,82.07) v7(6.1,81.66) v7(6.05,76.9) v7(6.05,76.46) v7(6.05,76.03) v7(6.05,75.63) v7(6.14,117.09) v7(6.14,116.68) v7(6.14,116.25) v7(6.14,115.82) v7(6.18,84.79) v7(6.18,84.36) v7(6.18,83.93) v7(6.18,83.52) v7(6.48,76.9) v7(6.48,76.49) v7(6.48,76.06) v7(6.48,75.63) v7(6.53,82.93) v7(6.53,82.53) v7(6.53,82.09) v7(6.53,81.66) v7(6.61,84.79) v7(6.61,84.38) v7(6.61,83.95) v7(6.61,83.52) v7(6.71,116.65) v7(6.71,116.27) v7(6.71,115.86) v7(6.93,82.93) v7(6.93,82.5) v7(6.93,82.07) v7(6.93,81.66) v7(7.02,84.79) v7(7.02,84.36) v7(7.02,83.93) v7(7.02,83.52) v7(7.37,82.93) v7(7.37,82.53) v7(7.37,82.09) v7(7.37,81.66) v7(7.32,75.59) v7(7.32,75.16) v7(7.32,74.72) v7(7.32,74.32) v7(7.36,72.51) v7(7.36,72.07) v7(7.36,71.64) v7(7.36,71.24) v7(7.49,115.43) v7(7.49,115.05) v7(7.45,111.77) v7(7.45,111.34) v7(7.45,110.9) v7(7.45,110.5) v7(7.45,84.79) v7(7.45,84.38) v7(7.45,83.95) v7(7.45,83.52) v7(7.53,114.3) v7(7.53,113.87) v7(7.53,113.44) v7(7.53,113.03) v7(7.75,75.59) v7(7.75,75.18) v7(7.75,74.75) v7(7.75,74.32) v7(7.79,72.51) v7(7.79,72.1) v7(7.79,71.67) v7(7.79,71.24) v7(7.9,115.45) v7(7.88,111.77) v7(7.88,111.36) v7(7.88,110.93) v7(7.88,110.5) v7(7.83,108.73) v7(7.83,108.3) v7(7.83,107.86) v7(7.83,107.46) v7(7.93,115.02) v7(7.96,114.3) v7(7.96,113.89) v7(7.96,113.46) v7(7.96,113.03) v7(8,84.75) v7(8,84.32) v7(8,83.88) v7(8,83.48) v7(7.95,82.85) v7(7.95,82.42) v7(7.95,81.99) v7(7.95,81.58) v7(8.16,75.59) v7(8.16,75.16) v7(8.16,74.72) v7(8.16,74.32) v7(8.2,72.51) v7(8.2,72.07) v7(8.2,71.64) v7(8.2,71.24) v7(8.29,111.77) v7(8.29,111.34) v7(8.29,110.9) v7(8.29,110.5) v7(8.26,108.73) v7(8.26,108.32) v7(8.26,107.89) v7(8.26,107.46) v7(8.36,115.02) v7(8.37,114.3) v7(8.37,113.87) v7(8.37,113.44) v7(8.37,113.03) v7(8.39,82.85) v7(8.39,82.44) v7(8.39,82.01) v7(8.39,81.58) v7(8.43,84.75) v7(8.43,84.34) v7(8.43,83.91) v7(8.43,83.48) v7(8.59,75.59) v7(8.59,75.18) v7(8.59,74.75) v7(8.59,74.32) v7(8.67,108.73) v7(8.67,108.3) v7(8.67,107.86) v7(8.67,107.46) v7(8.63,72.51) v7(8.63,72.1) v7(8.63,71.67) v7(8.63,71.24) v7(8.8,114.3) v7(8.8,113.89) v7(8.8,113.46) v7(8.8,113.03) v7(8.72,111.77) v7(8.72,111.36) v7(8.72,110.93) v7(8.72,110.5) v7(8.79,82.85) v7(8.79,82.42) v7(8.79,81.99) v7(8.79,81.58) v7(8.83,84.75) v7(8.83,84.32) v7(8.83,83.88) v7(8.83,83.48) v7(9.1,108.73) v7(9.1,108.32) v7(9.1,107.89) v7(9.1,107.46) v7(9.27,84.75) v7(9.27,84.34) v7(9.27,83.91) v7(9.27,83.48) v7(9.22,82.85) v7(9.22,82.44) v7(9.22,82.01) v7(9.22,81.58) v7(9.77,82.93) v7(9.77,82.5) v7(9.77,82.07) v7(9.77,81.66) v7(9.81,84.79) v7(9.81,84.36) v7(9.81,83.93) v7(9.81,83.52) v7(10.2,82.93) v7(10.2,82.53) v7(10.2,82.09) v7(10.2,81.66) v7(10.24,84.79) v7(10.24,84.38) v7(10.24,83.95) v7(10.24,83.52) v7(10.32,75.54) v7(10.32,75.11) v7(10.32,74.68) v7(10.32,74.27) v7(10.41,116.7) v7(10.41,116.39) v7(10.41,116.06) v7(10.41,115.73) v7(10.47,115.12) v7(10.47,114.77) v7(10.47,114.41) v7(10.47,114.08) v7(10.65,84.79) v7(10.65,84.36) v7(10.65,83.93) v7(10.65,83.52) v7(10.61,82.93) v7(10.61,82.5) v7(10.61,82.07) v7(10.61,81.66) v7(10.75,75.54) v7(10.75,75.14) v7(10.75,74.71) v7(10.75,74.27) v7(10.97,116.7) v7(10.97,116.37) v7(10.97,116.04) v7(10.97,115.71) v7(10.95,115.12) v7(10.96,114.79) v7(10.96,114.38) v7(10.95,114.06) v7(11.08,84.79) v7(11.08,84.38) v7(11.08,83.95) v7(11.08,83.52) v7(11.04,82.93) v7(11.04,82.53) v7(11.04,82.09) v7(11.04,81.66) v7(11.16,75.54) v7(11.16,75.11) v7(11.16,74.68) v7(11.16,74.27) v7(11.54,84.79) v7(11.54,84.36) v7(11.54,83.93) v7(11.54,83.52) v7(11.59,75.54) v7(11.59,75.14) v7(11.59,74.71) v7(11.59,74.27) v7(11.67,82.89) v7(11.67,82.46) v7(11.67,82.03) v7(11.67,81.62) v7(11.97,84.79) v7(11.97,84.38) v7(11.97,83.95) v7(11.97,83.52) v7(12.1,82.89) v7(12.1,82.48) v7(12.1,82.05) v7(12.1,81.62) v7(12.38,84.79) v7(12.38,84.36) v7(12.38,83.93) v7(12.38,83.52) v7(12.51,82.89) v7(12.51,82.46) v7(12.51,82.03) v7(12.51,81.62) v7(12.81,84.79) v7(12.81,84.38) v7(12.81,83.95) v7(12.81,83.52) v7(12.94,82.89) v7(12.94,82.48) v7(12.94,82.05) v7(12.94,81.62) v7(12.98,75.59) v7(12.98,75.16) v7(12.98,74.72) v7(12.98,74.32) v7(13.26,101.11) v7(13.26,100.67) v7(13.26,100.24) v7(13.26,99.84) v7(13.41,75.59) v7(13.41,75.18) v7(13.41,74.75) v7(13.41,74.32) v7(13.69,101.11) v7(13.69,100.7) v7(13.69,100.27) v7(13.69,99.84) v7(13.7,79.72) v7(13.7,79.29) v7(13.7,78.86) v7(13.7,78.45) v7(13.82,75.59) v7(13.82,75.16) v7(13.82,74.72) v7(13.82,74.32) v7(14.1,101.11) v7(14.1,100.67) v7(14.1,100.24) v7(14.1,99.84) v7(14.13,79.72) v7(14.13,79.32) v7(14.13,78.89) v7(14.13,78.45) v7(14.25,75.59) v7(14.25,75.18) v7(14.25,74.75) v7(14.25,74.32) v7(14.53,101.11) v7(14.53,100.7) v7(14.53,100.27) v7(14.53,99.84) v7(14.53,79.72) v7(14.53,79.29) v7(14.53,78.86) v7(14.53,78.45) v7(14.97,79.72) v7(14.97,79.32) v7(14.97,78.89) v7(14.97,78.45) v7(14.96,75.71) v7(14.96,75.28) v7(14.96,74.85) v7(14.96,74.44) v7(15.22,89.31) v7(15.22,88.88) v7(15.22,88.44) v7(15.22,88.04) v7(15.39,75.71) v7(15.39,75.31) v7(15.39,74.88) v7(15.39,74.44) v7(15.65,89.31) v7(15.65,88.9) v7(15.65,88.47) v7(15.65,88.04) v7(15.68,79.77) v7(15.68,79.33) v7(15.68,78.9) v7(15.68,78.5) v7(15.8,75.71) v7(15.8,75.28) v7(15.8,74.85) v7(15.8,74.44) v7(15.98,94.8) v7(15.98,94.36) v7(15.98,93.93) v7(15.98,93.53) v7(15.93,92.98) v7(15.93,92.55) v7(15.93,92.12) v7(15.93,91.71) v7(16.05,89.31) v7(16.05,88.88) v7(16.05,88.44) v7(16.05,88.04) v7(16.11,79.77) v7(16.11,79.36) v7(16.11,78.93) v7(16.11,78.5) v7(16.23,75.71) v7(16.23,75.31) v7(16.23,74.88) v7(16.23,74.44) v7(16.36,92.98) v7(16.36,92.57) v7(16.36,92.14) v7(16.36,91.71) v7(16.41,94.8) v7(16.41,94.39) v7(16.41,93.96) v7(16.41,93.53) v7(16.49,89.31) v7(16.49,88.9) v7(16.49,88.47) v7(16.49,88.04) v7(16.52,79.77) v7(16.52,79.33) v7(16.52,78.9) v7(16.52,78.5) v7(16.77,92.98) v7(16.77,92.55) v7(16.77,92.12) v7(16.77,91.71) v7(16.81,94.8) v7(16.81,94.36) v7(16.81,93.93) v7(16.81,93.53) v7(16.86,76.01) v7(16.86,75.58) v7(16.86,75.15) v7(16.86,74.74) v7(16.95,79.77) v7(16.95,79.36) v7(16.95,78.93) v7(16.95,78.5) v7(17.2,92.98) v7(17.2,92.57) v7(17.2,92.14) v7(17.2,91.71) v7(17.25,94.8) v7(17.25,94.39) v7(17.25,93.96) v7(17.25,93.53) v7(17.29,76.01) v7(17.29,75.6) v7(17.29,75.17) v7(17.29,74.74) v7(17.7,76.01) v7(17.7,75.58) v7(17.7,75.15) v7(17.7,74.74) v7(17.75,94.8) v7(17.75,94.36) v7(17.75,93.93) v7(17.75,93.53) v7(17.71,93.02) v7(17.71,92.59) v7(17.71,92.16) v7(17.71,91.75) v7(18,83.48) v7(18,83.05) v7(18,82.62) v7(18,82.21) v7(17.96,81.37) v7(17.96,80.94) v7(17.96,80.51) v7(17.96,80.1) v7(18.04,85.89) v7(18.04,85.46) v7(18.04,85.02) v7(18.04,84.62) v7(18.18,94.8) v7(18.18,94.39) v7(18.18,93.96) v7(18.18,93.53) v7(18.14,93.02) v7(18.14,92.62) v7(18.14,92.18) v7(18.14,91.75) v7(18.13,76.01) v7(18.13,75.6) v7(18.13,75.17) v7(18.13,74.74) v7(18.39,81.37) v7(18.39,80.96) v7(18.39,80.53) v7(18.39,80.1) v7(18.48,85.89) v7(18.48,85.48) v7(18.48,85.05) v7(18.48,84.62) v7(18.43,83.48) v7(18.43,83.08) v7(18.43,82.64) v7(18.43,82.21) v7(18.59,94.8) v7(18.59,94.36) v7(18.59,93.93) v7(18.59,93.53) v7(18.54,93.02) v7(18.54,92.59) v7(18.54,92.16) v7(18.54,91.75) v7(18.7,3.41) v7(18.7,2.98) v7(18.7,2.55) v7(18.7,2.14) v7(18.8,81.37) v7(18.8,80.94) v7(18.8,80.51) v7(18.8,80.1) v7(18.88,85.89) v7(18.88,85.46) v7(18.88,85.02) v7(18.88,84.62) v7(18.84,83.48) v7(18.84,83.05) v7(18.84,82.62) v7(18.84,82.21) v7(18.98,93.02) v7(18.98,92.62) v7(18.98,92.18) v7(18.98,91.75) v7(19.02,94.8) v7(19.02,94.39) v7(19.02,93.96) v7(19.02,93.53) v7(19.01,78.88) v7(19.01,78.45) v7(19.01,78.02) v7(19.01,77.61) v7(19.13,3.41) v7(19.13,3.01) v7(19.13,2.58) v7(19.13,2.14) v7(19.27,83.48) v7(19.27,83.08) v7(19.27,82.64) v7(19.27,82.21) v7(19.23,81.37) v7(19.23,80.96) v7(19.23,80.53) v7(19.23,80.1) v7(19.31,85.89) v7(19.31,85.48) v7(19.31,85.05) v7(19.31,84.62) v7(19.45,78.88) v7(19.45,78.47) v7(19.45,78.04) v7(19.45,77.61) v7(19.53,3.41) v7(19.53,2.98) v7(19.53,2.55) v7(19.53,2.14) v7(19.9,85.93) v7(19.9,85.5) v7(19.9,85.07) v7(19.9,84.66) v7(19.82,83.44) v7(19.82,83.01) v7(19.82,82.58) v7(19.82,82.17) v7(19.85,78.88) v7(19.85,78.45) v7(19.85,78.02) v7(19.85,77.61) v7(19.94,81.2) v7(19.94,80.77) v7(19.94,80.34) v7(19.94,79.93) v7(19.97,3.41) v7(19.97,3.01) v7(19.97,2.58) v7(19.97,2.14) v7(20.25,83.44) v7(20.25,83.03) v7(20.25,82.6) v7(20.25,82.17) v7(20.28,78.88) v7(20.28,78.47) v7(20.28,78.04) v7(20.28,77.61) v7(20.37,102.18) v7(20.37,101.75) v7(20.37,101.32) v7(20.37,100.91) v7(20.33,85.93) v7(20.33,85.52) v7(20.33,85.09) v7(20.33,84.66) v7(20.38,81.2) v7(20.38,80.8) v7(20.38,80.36) v7(20.38,79.93) v7(20.66,83.44) v7(20.66,83.01) v7(20.66,82.58) v7(20.66,82.17) v7(20.8,102.18) v7(20.8,101.78) v7(20.8,101.35) v7(20.8,100.91) v7(20.74,85.93) v7(20.74,85.5) v7(20.74,85.07) v7(20.74,84.66) v7(20.78,81.2) v7(20.78,80.77) v7(20.78,80.34) v7(20.78,79.93) v7(21.08,89.52) v7(21.08,89.09) v7(21.08,88.66) v7(21.08,88.25) v7(21.09,83.44) v7(21.09,83.03) v7(21.09,82.6) v7(21.09,82.17) v7(21.2,102.18) v7(21.2,101.75) v7(21.2,101.32) v7(21.2,100.91) v7(21.17,85.93) v7(21.17,85.52) v7(21.17,85.09) v7(21.17,84.66) v7(21.21,81.2) v7(21.21,80.8) v7(21.21,80.36) v7(21.21,79.93) v7(21.52,89.52) v7(21.52,89.11) v7(21.52,88.68) v7(21.52,88.25) v7(21.57,3.41) v7(21.57,2.98) v7(21.57,2.55) v7(21.57,2.14) v7(21.64,102.18) v7(21.64,101.78) v7(21.64,101.35) v7(21.64,100.91) v7(21.89,94.25) v7(21.89,93.82) v7(21.89,93.38) v7(21.89,92.98) v7(21.92,91.75) v7(21.93,91.36) v7(21.93,90.98) v7(21.93,90.57) v7(21.92,89.52) v7(21.92,89.09) v7(21.92,88.66) v7(21.92,88.25) v7(22,3.41) v7(22,3.01) v7(22,2.58) v7(22,2.14) v7(22.23,49.13) v7(22.23,48.7) v7(22.23,47.36) v7(22.23,46.92) v7(22.23,46.49) v7(22.23,46.09) v7(22.32,94.25) v7(22.32,93.84) v7(22.32,93.41) v7(22.32,92.98) v7(22.35,91.75) v7(22.36,91.38) v7(22.36,91) v7(22.36,90.57) v7(22.35,89.52) v7(22.35,89.11) v7(22.35,88.68) v7(22.35,88.25) v7(22.4,29.42) v7(22.4,28.99) v7(22.4,28.56) v7(22.4,28.15) v7(22.4,3.41) v7(22.4,2.98) v7(22.4,2.55) v7(22.4,2.14) v7(22.48,34.12) v7(22.48,33.69) v7(22.48,20.13) v7(22.48,19.69) v7(22.48,19.26) v7(22.48,18.86) v7(22.48,18.2) v7(22.48,17.76) v7(22.48,17.33) v7(22.48,16.93) v7(22.48,16.11) v7(22.48,15.68) v7(22.48,15.25) v7(22.48,14.84) v7(22.48,14.06) v7(22.48,13.62) v7(22.48,13.19) v7(22.48,12.79) v7(22.53,26.17) v7(22.53,25.74) v7(22.53,25.31) v7(22.53,24.9) v7(22.53,24.04) v7(22.53,23.61) v7(22.53,23.17) v7(22.53,22.77) v7(22.53,22.03) v7(22.53,21.6) v7(22.53,21.17) v7(22.53,20.76) v7(22.63,49.11) v7(22.63,48.68) v7(22.66,47.36) v7(22.66,46.95) v7(22.66,46.52) v7(22.66,46.09) v7(22.72,94.25) v7(22.72,93.82) v7(22.72,93.38) v7(22.72,92.98) v7(22.77,91.76) v7(22.77,91.36) v7(22.77,90.98) v7(22.77,90.57) v7(22.89,34.1) v7(22.89,33.66) v7(22.84,29.42) v7(22.84,29.02) v7(22.84,28.58) v7(22.84,28.15) v7(22.84,3.41) v7(22.84,3.01) v7(22.84,2.58) v7(22.84,2.14) v7(22.96,26.17) v7(22.96,25.77) v7(22.96,25.33) v7(22.96,24.9) v7(22.96,24.04) v7(22.96,23.63) v7(22.96,23.2) v7(22.96,22.77) v7(22.96,22.03) v7(22.96,21.63) v7(22.96,21.19) v7(22.91,20.13) v7(22.91,19.72) v7(22.91,19.29) v7(22.91,18.86) v7(22.91,18.2) v7(22.91,17.79) v7(22.91,17.36) v7(22.91,16.93) v7(22.91,16.11) v7(22.91,15.71) v7(22.91,15.28) v7(22.91,14.84) v7(22.91,14.06) v7(22.91,13.65) v7(22.91,13.22) v7(22.91,12.79) v7(23.06,49.13) v7(23.06,48.7) v7(23.06,47.36) v7(23.06,46.92) v7(23.06,46.49) v7(23.06,46.09) v7(23.16,94.25) v7(23.16,93.84) v7(23.16,93.41) v7(23.16,92.98) v7(23.2,91.76) v7(23.2,91.38) v7(23.2,91) v7(23.2,90.57) v7(23.24,29.42) v7(23.24,28.99) v7(23.24,28.56) v7(23.24,28.15) v7(23.32,34.12) v7(23.32,33.69) v7(23.34,33.13) v7(23.34,32.7) v7(23.37,26.17) v7(23.37,25.74) v7(23.37,25.31) v7(23.37,24.9) v7(23.37,24.04) v7(23.37,23.61) v7(23.37,23.17) v7(23.37,22.77) v7(23.37,22.03) v7(23.37,21.6) v7(23.37,21.17) v7(23.37,20.76) v7(23.32,20.13) v7(23.32,19.69) v7(23.32,19.26) v7(23.32,18.86) v7(23.32,18.2) v7(23.32,17.76) v7(23.32,17.33) v7(23.32,16.93) v7(23.32,16.11) v7(23.32,15.68) v7(23.32,15.25) v7(23.32,14.84) v7(23.32,14.06) v7(23.32,13.62) v7(23.32,13.19) v7(23.32,12.79) v7(23.45,102.06) v7(23.45,101.63) v7(23.45,101.19) v7(23.45,100.79) v7(23.5,47.36) v7(23.5,46.95) v7(23.5,46.52) v7(23.5,46.09) v7(23.62,96.44) v7(23.62,96.01) v7(23.62,95.58) v7(23.62,95.17) v7(23.67,29.42) v7(23.67,29.02) v7(23.67,28.58) v7(23.67,28.15) v7(23.74,94.25) v7(23.74,93.82) v7(23.74,93.38) v7(23.74,92.98) v7(23.75,33.11) v7(23.75,32.67) v7(23.8,26.17) v7(23.8,25.77) v7(23.8,25.33) v7(23.8,24.9) v7(23.8,24.04) v7(23.8,23.63) v7(23.8,23.2) v7(23.8,22.77) v7(23.8,22.03) v7(23.8,21.63) v7(23.8,21.19) v7(23.8,20.76) v7(23.75,20.13) v7(23.75,19.72) v7(23.75,19.29) v7(23.75,18.86) v7(23.75,18.2) v7(23.75,17.79) v7(23.75,17.36) v7(23.75,16.93) v7(23.75,16.11) v7(23.75,15.71) v7(23.75,15.28) v7(23.75,14.84) v7(23.75,14.06) v7(23.75,13.65) v7(23.75,13.22) v7(23.75,12.79) v7(23.88,102.06) v7(23.88,101.65) v7(23.88,101.22) v7(23.88,100.79) v7(24,91.88) v7(24,91.45) v7(24,91.02) v7(24,90.61) v7(23.93,49.57) v7(23.93,49.13) v7(23.93,48.7) v7(23.93,48.3) v7(24.05,96.44) v7(24.05,96.04) v7(24.05,95.6) v7(24.05,95.17) v7(24.17,94.25) v7(24.17,93.84) v7(24.17,93.41) v7(24.17,92.98) v7(24.13,47.3) v7(24.13,46.87) v7(24.13,46.44) v7(24.13,46.03) v7(24.18,33.13) v7(24.18,32.7) v7(24.29,102.06) v7(24.29,101.63) v7(24.29,101.19) v7(24.29,100.79) v7(24.36,49.57) v7(24.36,49.16) v7(24.36,48.73) v7(24.36,48.3) v7(24.45,96.44) v7(24.45,96.01) v7(24.45,95.58) v7(24.45,95.17) v7(24.43,91.88) v7(24.43,91.48) v7(24.43,91.04) v7(24.43,90.61) v7(24.46,19.03) v7(24.46,18.6) v7(24.46,18.17) v7(24.46,17.76) v7(24.49,17.21) v7(24.49,16.77) v7(24.49,16.34) v7(24.49,15.94) v7(24.49,15.43) v7(24.49,15) v7(24.49,14.56) v7(24.49,14.16) v7(24.49,13.6) v7(24.49,13.17) v7(24.49,12.74) v7(24.49,12.33) v7(24.46,11.69) v7(24.46,11.26) v7(24.46,10.83) v7(24.46,10.42) v7(24.41,5.5) v7(24.41,5.06) v7(24.41,4.63) v7(24.41,4.23) v7(24.58,94.25) v7(24.58,93.82) v7(24.58,93.38) v7(24.58,92.98) v7(24.56,47.3) v7(24.56,46.9) v7(24.56,46.47) v7(24.56,46.03) v7(24.59,9.69) v7(24.59,9.26) v7(24.59,8.82) v7(24.59,8.42) v7(24.64,31.53) v7(24.64,31.1) v7(24.64,30.67) v7(24.64,30.26) v7(24.64,25.1) v7(24.64,24.67) v7(24.64,24.24) v7(24.64,23.83) v7(24.64,23.15) v7(24.64,22.72) v7(24.64,22.29) v7(24.64,21.88) v7(24.72,102.06) v7(24.72,101.65) v7(24.72,101.22) v7(24.72,100.79) v7(24.77,49.57) v7(24.77,49.13) v7(24.77,48.7) v7(24.77,48.3) v7(24.89,96.44) v7(24.89,96.04) v7(24.89,95.6) v7(24.89,95.17) v7(24.83,91.88) v7(24.83,91.45) v7(24.83,91.02) v7(24.83,90.61) v7(24.89,19.03) v7(24.89,18.63) v7(24.89,18.2) v7(24.89,17.76) v7(24.89,11.69) v7(24.89,11.29) v7(24.89,10.86) v7(24.89,10.42) v7(24.84,5.5) v7(24.84,5.09) v7(24.84,4.66) v7(24.84,4.23) v7(24.97,47.3) v7(24.97,46.87) v7(24.97,46.44) v7(24.97,46.03) v7(24.99,44.99) v7(24.99,44.56) v7(24.92,17.21) v7(24.92,16.8) v7(24.92,16.37) v7(24.92,15.94) v7(24.92,15.43) v7(24.92,15.02) v7(24.92,14.59) v7(24.92,14.16) v7(24.92,13.6) v7(24.92,13.19) v7(24.92,12.76) v7(24.92,12.33) v7(25.01,94.25) v7(25.01,93.84) v7(25.01,93.41) v7(25.01,92.98) v7(25.07,31.53) v7(25.07,31.12) v7(25.07,30.69) v7(25.07,30.26) v7(25.02,26.5) v7(25.02,26.07) v7(25.07,25.1) v7(25.07,24.7) v7(25.07,24.27) v7(25.07,23.83) v7(25.07,23.15) v7(25.07,22.74) v7(25.07,22.31) v7(25.07,21.88) v7(25.02,9.69) v7(25.02,9.28) v7(25.02,8.85) v7(25.02,8.42) v7(25.2,49.57) v7(25.2,49.16) v7(25.2,48.73) v7(25.2,48.3) v7(25.27,91.88) v7(25.27,91.48) v7(25.27,91.04) v7(25.27,90.61) v7(25.3,19.03) v7(25.3,18.6) v7(25.3,18.17) v7(25.3,17.76) v7(25.3,11.69) v7(25.3,11.26) v7(25.3,10.83) v7(25.3,10.42) v7(25.25,5.5) v7(25.25,5.06) v7(25.25,4.63) v7(25.25,4.23) v7(25.4,47.3) v7(25.4,46.9) v7(25.4,46.47) v7(25.4,46.03) v7(25.4,44.97) v7(25.4,44.54) v7(25.32,17.21) v7(25.32,16.77) v7(25.32,16.34) v7(25.32,15.94) v7(25.32,15.43) v7(25.32,15) v7(25.32,14.56) v7(25.32,14.16) v7(25.32,13.6) v7(25.32,13.17) v7(25.32,12.74) v7(25.32,12.33) v7(25.38,3.31) v7(25.38,2.88) v7(25.38,2.45) v7(25.38,2.04) v7(25.48,31.53) v7(25.48,31.1) v7(25.48,30.67) v7(25.48,30.26) v7(25.43,26.48) v7(25.43,26.04) v7(25.48,25.1) v7(25.48,24.67) v7(25.48,24.24) v7(25.48,23.83) v7(25.48,23.15) v7(25.48,22.72) v7(25.48,22.29) v7(25.48,21.88) v7(25.43,9.69) v7(25.43,9.26) v7(25.43,8.82) v7(25.43,8.42) v7(25.68,5.5) v7(25.68,5.09) v7(25.68,4.66) v7(25.68,4.23) v7(25.73,19.03) v7(25.73,18.63) v7(25.73,18.2) v7(25.73,17.76) v7(25.76,17.21) v7(25.76,16.8) v7(25.76,16.37) v7(25.76,15.94) v7(25.76,15.43) v7(25.76,15.02) v7(25.76,14.59) v7(25.76,14.16) v7(25.76,13.6) v7(25.76,13.19) v7(25.76,12.76) v7(25.76,12.33) v7(25.73,11.69) v7(25.73,11.29) v7(25.73,10.86) v7(25.83,44.99) v7(25.83,44.56) v7(25.86,26.5) v7(25.86,26.07) v7(25.86,9.69) v7(25.86,9.28) v7(25.86,8.85) v7(25.86,8.42) v7(25.81,3.31) v7(25.81,2.91) v7(25.81,2.47) v7(25.81,2.04) v7(25.98,94.59) v7(25.98,94.15) v7(25.98,93.72) v7(25.98,93.32) v7(25.91,31.53) v7(25.91,31.12) v7(25.91,30.69) v7(25.91,30.26) v7(25.91,25.1) v7(25.91,24.7) v7(25.91,24.27) v7(25.91,23.83) v7(25.91,23.15) v7(25.91,22.74) v7(25.91,22.31) v7(25.91,21.88) v7(26.11,102.27) v7(26.11,101.84) v7(26.11,101.4) v7(26.11,101) v7(26.11,99.74) v7(26.11,99.3) v7(26.11,98.87) v7(26.11,98.47) v7(26.15,97.03) v7(26.15,96.6) v7(26.15,96.17) v7(26.15,95.76) v7(26.21,3.31) v7(26.21,2.88) v7(26.21,2.45) v7(26.21,2.04) v7(26.41,94.59) v7(26.41,94.18) v7(26.41,93.75) v7(26.41,93.32) v7(26.54,102.27) v7(26.54,101.86) v7(26.54,101.43) v7(26.54,101) v7(26.54,99.74) v7(26.54,99.33) v7(26.54,98.9) v7(26.54,98.47) v7(26.58,97.03) v7(26.58,96.63) v7(26.58,96.2) v7(26.58,95.76) v7(26.59,23.1) v7(26.59,22.67) v7(26.59,22.23) v7(26.59,21.83) v7(26.59,17.18) v7(26.59,16.75) v7(26.59,16.32) v7(26.59,15.91) v7(26.54,9.61) v7(26.54,9.18) v7(26.54,8.75) v7(26.54,8.34) v7(26.65,25.03) v7(26.65,24.6) v7(26.65,24.17) v7(26.65,23.76) v7(26.65,21.19) v7(26.65,20.76) v7(26.65,20.33) v7(26.65,19.92) v7(26.67,19.21) v7(26.67,18.78) v7(26.67,18.35) v7(26.67,17.94) v7(26.62,11.69) v7(26.62,11.26) v7(26.62,10.83) v7(26.62,10.42) v7(26.65,3.31) v7(26.65,2.91) v7(26.65,2.47) v7(26.65,2.04) v7(26.82,94.59) v7(26.82,94.15) v7(26.82,93.72) v7(26.82,93.32) v7(26.85,27.75) v7(26.85,27.31) v7(26.85,26.88) v7(26.85,26.48) v7(26.95,102.27) v7(26.95,101.84) v7(26.95,101.4) v7(26.95,101) v7(26.95,99.74) v7(26.95,99.3) v7(26.95,98.87) v7(26.95,98.47) v7(26.99,97.03) v7(26.99,96.6) v7(26.99,96.17) v7(26.99,95.76) v7(26.98,9.61) v7(26.98,9.2) v7(26.98,8.77) v7(26.98,8.34) v7(27.08,25.03) v7(27.08,24.62) v7(27.08,24.19) v7(27.08,23.76) v7(27.03,23.1) v7(27.03,22.69) v7(27.03,22.26) v7(27.03,21.83) v7(27.08,21.19) v7(27.08,20.79) v7(27.08,20.36) v7(27.08,19.92) v7(27.1,19.21) v7(27.1,18.81) v7(27.1,18.37) v7(27.1,17.94) v7(27.03,17.18) v7(27.03,16.77) v7(27.03,16.34) v7(27.03,15.91) v7(27.05,11.69) v7(27.05,11.29) v7(27.05,10.86) v7(27.05,10.42) v7(27.25,94.59) v7(27.25,94.18) v7(27.25,93.75) v7(27.25,93.32) v7(27.28,27.75) v7(27.28,27.34) v7(27.28,26.91) v7(27.28,26.48) v7(27.38,102.27) v7(27.38,101.86) v7(27.38,101.43) v7(27.38,101) v7(27.38,99.74) v7(27.38,99.33) v7(27.38,98.9) v7(27.38,98.47) v7(27.38,9.61) v7(27.38,9.18) v7(27.38,8.75) v7(27.38,8.34) v7(27.42,97.03) v7(27.42,96.63) v7(27.42,96.2) v7(27.42,95.76) v7(27.48,25.03) v7(27.48,24.6) v7(27.48,24.17) v7(27.48,23.76) v7(27.43,23.1) v7(27.43,22.67) v7(27.43,22.23) v7(27.43,21.83) v7(27.48,21.19) v7(27.48,20.76) v7(27.48,20.33) v7(27.48,19.92) v7(27.43,17.18) v7(27.43,16.75) v7(27.43,16.32) v7(27.43,15.91) v7(27.46,11.69) v7(27.46,11.26) v7(27.46,10.83) v7(27.46,10.42) v7(27.53,49.34) v7(27.53,48.9) v7(27.53,48.47) v7(27.56,47.58) v7(27.56,47.15) v7(27.56,46.72) v7(27.51,19.21) v7(27.51,18.78) v7(27.51,18.35) v7(27.51,17.94) v7(27.69,27.75) v7(27.69,27.31) v7(27.69,26.88) v7(27.69,26.48) v7(27.61,3.36) v7(27.61,2.93) v7(27.61,2.5) v7(27.61,2.09) v7(27.86,23.1) v7(27.86,22.69) v7(27.86,22.26) v7(27.86,21.83) v7(27.86,17.18) v7(27.86,16.77) v7(27.86,16.34) v7(27.86,15.91) v7(27.89,11.69) v7(27.89,11.29) v7(27.89,10.86) v7(27.89,10.42) v7(27.81,9.61) v7(27.81,9.2) v7(27.81,8.77) v7(27.94,49.31) v7(27.94,48.88) v7(27.94,48.47) v7(27.97,47.56) v7(27.97,47.13) v7(27.97,46.72) v7(27.92,25.03) v7(27.92,24.62) v7(27.92,24.19) v7(27.92,23.76) v7(27.92,21.19) v7(27.92,20.79) v7(27.92,20.36) v7(27.92,19.92) v7(27.94,19.21) v7(27.94,18.81) v7(27.94,18.37) v7(27.94,17.94) v7(28.04,3.36) v7(28.04,2.96) v7(28.04,2.52) v7(28.04,2.09) v7(28.12,27.75) v7(28.12,27.34) v7(28.12,26.91) v7(28.12,26.48) v7(28.37,49.34) v7(28.37,48.9) v7(28.37,48.47) v7(28.4,47.58) v7(28.4,47.15) v7(28.4,46.72) v7(28.45,3.36) v7(28.45,2.93) v7(28.45,2.5) v7(28.45,2.09) v7(28.68,13.34) v7(28.68,12.91) v7(28.78,21.75) v7(28.78,21.32) v7(28.78,20.89) v7(28.78,20.48) v7(28.88,3.36) v7(28.88,2.96) v7(28.88,2.52) v7(28.88,2.09) v7(28.91,18.91) v7(28.91,18.48) v7(29.08,13.32) v7(29.08,12.89) v7(29.21,21.75) v7(29.21,21.35) v7(29.21,20.91) v7(29.21,20.48) v7(29.31,18.88) v7(29.31,18.45) v7(29.52,13.34) v7(29.52,12.91) v7(29.62,21.75) v7(29.62,21.32) v7(29.62,20.89) v7(29.62,20.48) v7(29.79,40.8) v7(29.79,40.37) v7(29.79,39.94) v7(29.74,18.91) v7(29.74,18.48) v7(29.87,49.41) v7(29.87,48.98) v7(29.87,48.55) v7(29.97,28) v7(29.97,27.57) v7(29.97,27.14) v7(29.97,26.73) v7(30.05,47.33) v7(30.05,46.9) v7(30.05,46.47) v7(30.05,21.75) v7(30.05,21.35) v7(30.05,20.91) v7(30.05,20.48) v7(30.2,40.78) v7(30.2,40.34) v7(30.2,39.94) v7(30.28,49.39) v7(30.28,48.96) v7(30.28,48.55) v7(30.25,25.23) v7(30.25,24.8) v7(30.25,24.37) v7(30.25,23.96) v7(30.4,28) v7(30.4,27.59) v7(30.4,27.16) v7(30.4,26.73) v7(30.46,47.3) v7(30.46,46.87) v7(30.46,46.47) v7(30.51,45.32) v7(30.51,44.89) v7(30.51,44.46) v7(30.56,16.47) v7(30.56,16.04) v7(30.56,15.61) v7(30.56,15.2) v7(30.51,12.76) v7(30.51,12.33) v7(30.63,40.8) v7(30.63,40.37) v7(30.63,39.94) v7(30.68,25.23) v7(30.68,24.83) v7(30.68,24.39) v7(30.68,23.96) v7(30.71,49.41) v7(30.71,48.98) v7(30.71,48.55) v7(30.79,22.62) v7(30.79,22.18) v7(30.79,21.75) v7(30.79,21.35) v7(30.79,18.65) v7(30.79,18.22) v7(30.89,47.33) v7(30.89,46.9) v7(30.89,46.47) v7(30.81,28) v7(30.81,27.57) v7(30.81,27.14) v7(30.81,26.73) v7(30.86,20.61) v7(30.86,20.18) v7(30.91,45.3) v7(30.91,44.87) v7(30.91,44.46) v7(30.99,16.47) v7(30.99,16.06) v7(30.99,15.63) v7(30.99,15.2) v7(30.91,12.74) v7(30.91,12.3) v7(31.09,25.23) v7(31.09,24.8) v7(31.09,24.37) v7(31.09,23.96) v7(31.19,18.63) v7(31.19,18.2) v7(31.24,28) v7(31.24,27.59) v7(31.24,27.16) v7(31.24,26.73) v7(31.22,22.62) v7(31.22,22.21) v7(31.22,21.78) v7(31.22,21.35) v7(31.27,20.58) v7(31.27,20.15) v7(31.34,45.32) v7(31.34,44.89) v7(31.34,44.46) v7(31.4,16.47) v7(31.4,16.04) v7(31.4,15.61) v7(31.4,15.2) v7(31.34,12.76) v7(31.34,12.33) v7(31.52,25.23) v7(31.52,24.83) v7(31.52,24.39) v7(31.52,23.96) v7(31.62,22.62) v7(31.62,22.18) v7(31.62,21.75) v7(31.62,21.35) v7(31.7,20.61) v7(31.7,20.18) v7(31.62,18.65) v7(31.62,18.22) v7(31.83,16.47) v7(31.83,16.06) v7(31.83,15.63) v7(31.83,15.2) v7(32.06,22.62) v7(32.06,22.21) v7(32.06,21.78) v7(32.06,21.35) v7(32.28,40.5) v7(32.28,40.07) v7(32.28,39.63) v7(32.21,38.47) v7(32.21,38.06) v7(32.39,27.42) v7(32.39,26.98) v7(32.39,26.55) v7(32.39,26.15) v7(32.69,40.47) v7(32.69,40.04) v7(32.69,39.63) v7(32.64,38.49) v7(32.64,38.06) v7(32.82,27.42) v7(32.82,27.01) v7(32.82,26.58) v7(32.82,26.15) v7(33.05,20.79) v7(33.05,20.36) v7(33.05,19.92) v7(33.05,19.52) v7(33.1,18.5) v7(33.1,18.07) v7(33.1,17.64) v7(33.1,17.23) v7(33.12,40.5) v7(33.12,40.07) v7(33.12,39.63) v7(33.22,27.42) v7(33.22,26.98) v7(33.22,26.55) v7(33.22,26.15) v7(33.38,46.8) v7(33.38,46.36) v7(33.38,45.93) v7(33.43,37.55) v7(33.43,37.12) v7(33.43,36.69) v7(33.48,20.79) v7(33.48,20.38) v7(33.48,19.95) v7(33.48,19.52) v7(33.55,23.73) v7(33.55,23.3) v7(33.53,18.5) v7(33.53,18.09) v7(33.53,17.66) v7(33.53,17.23) v7(33.66,27.42) v7(33.66,27.01) v7(33.66,26.58) v7(33.66,26.15) v7(33.78,46.77) v7(33.78,46.34) v7(33.78,45.93) v7(33.71,39.38) v7(33.71,38.97) v7(33.83,37.53) v7(33.83,37.09) v7(33.83,36.69) v7(33.88,20.79) v7(33.88,20.36) v7(33.88,19.92) v7(33.88,19.52) v7(33.96,23.71) v7(33.96,23.28) v7(33.94,18.5) v7(33.94,18.07) v7(33.94,17.64) v7(33.94,17.23) v7(34.14,39.41) v7(34.14,38.97) v7(34.21,46.8) v7(34.21,46.36) v7(34.21,45.93) v7(34.27,37.55) v7(34.27,37.12) v7(34.27,36.69) v7(34.39,23.73) v7(34.39,23.3) v7(34.32,20.79) v7(34.32,20.38) v7(34.32,19.95) v7(34.32,19.52) v7(34.37,18.5) v7(34.37,18.09) v7(34.37,17.66) v7(34.37,17.23) v7(34.47,16.11) v7(34.47,15.68) v7(34.47,15.25) v7(34.47,14.84) v7(34.8,40.24) v7(34.8,39.81) v7(34.8,39.38) v7(34.9,30.79) v7(34.9,30.36) v7(34.9,29.93) v7(34.9,16.11) v7(34.9,15.71) v7(34.9,15.28) v7(34.9,14.84) v7(34.93,42.3) v7(34.93,41.89) v7(35.21,40.22) v7(35.21,39.79) v7(35.21,39.38) v7(35.15,38.14) v7(35.15,37.73) v7(35.21,20.51) v7(35.21,20.08) v7(35.36,42.33) v7(35.36,41.89) v7(35.31,30.77) v7(35.31,30.34) v7(35.31,29.93) v7(35.31,16.11) v7(35.31,15.68) v7(35.31,15.25) v7(35.31,14.84) v7(35.33,13.95) v7(35.33,13.52) v7(35.33,13.09) v7(35.33,12.68) v7(35.46,50.99) v7(35.46,50.58) v7(35.41,49.77) v7(35.41,49.36) v7(35.43,48.35) v7(35.43,47.94) v7(35.59,38.16) v7(35.59,37.73) v7(35.69,41.49) v7(35.69,41.08) v7(35.64,40.24) v7(35.64,39.81) v7(35.64,39.38) v7(35.61,20.48) v7(35.61,20.05) v7(35.74,30.79) v7(35.74,30.36) v7(35.74,29.93) v7(35.74,16.11) v7(35.74,15.71) v7(35.74,15.28) v7(35.74,14.84) v7(35.76,13.95) v7(35.76,13.55) v7(35.76,13.12) v7(35.76,12.68) v7(35.89,51.01) v7(35.89,50.58) v7(35.84,49.79) v7(35.84,49.36) v7(35.87,48.37) v7(35.87,47.94) v7(36.07,29.27) v7(36.07,28.86) v7(36.04,20.51) v7(36.04,20.08) v7(36.12,41.51) v7(36.12,41.08) v7(36.2,25.1) v7(36.2,24.67) v7(36.2,24.24) v7(36.2,23.83) v7(36.17,13.95) v7(36.17,13.52) v7(36.17,13.09) v7(36.17,12.68) v7(36.32,110.63) v7(36.32,110.2) v7(36.32,109.76) v7(36.32,109.36) v7(36.4,22.92) v7(36.4,22.49) v7(36.4,22.06) v7(36.4,21.65) v7(36.5,29.3) v7(36.5,28.86) v7(36.6,13.95) v7(36.6,13.55) v7(36.6,13.12) v7(36.6,12.68) v7(36.63,25.1) v7(36.63,24.7) v7(36.63,24.27) v7(36.63,23.83) v7(36.76,110.63) v7(36.76,110.22) v7(36.76,109.79) v7(36.76,109.36) v7(36.83,22.92) v7(36.83,22.51) v7(36.83,22.08) v7(36.83,21.65) v7(36.98,28.33) v7(36.98,27.92) v7(37.03,25.1) v7(37.03,24.67) v7(37.03,24.24) v7(37.03,23.83) v7(37.16,110.63) v7(37.16,110.2) v7(37.16,109.76) v7(37.16,109.36) v7(37.24,22.92) v7(37.24,22.49) v7(37.24,22.06) v7(37.24,21.65) v7(37.41,28.36) v7(37.41,27.92) v7(37.47,25.1) v7(37.47,24.7) v7(37.47,24.27) v7(37.47,23.83) v7(37.59,110.63) v7(37.59,110.22) v7(37.59,109.79) v7(37.59,109.36) v7(37.67,22.92) v7(37.67,22.51) v7(37.67,22.08) v7(37.67,21.65) v7(37.8,49.74) v7(37.8,49.34) v7(37.77,18.65) v7(37.77,18.22) v7(37.77,17.79) v7(37.77,17.38) v7(38,27.44) v7(38,27.04) v7(37.92,20.66) v7(37.92,20.23) v7(37.92,19.8) v7(37.92,19.39) v7(38.05,16.19) v7(38.05,15.76) v7(38.05,15.33) v7(38.05,14.92) v7(38.2,18.65) v7(38.2,18.25) v7(38.2,17.82) v7(38.2,17.38) v7(38.22,109.19) v7(38.22,108.76) v7(38.22,108.33) v7(38.22,107.92) v7(38.23,49.77) v7(38.23,49.34) v7(38.35,20.66) v7(38.35,20.25) v7(38.35,19.82) v7(38.35,19.39) v7(38.48,33.23) v7(38.48,32.8) v7(38.48,32.37) v7(38.43,27.47) v7(38.43,27.04) v7(38.48,16.19) v7(38.48,15.78) v7(38.48,15.35) v7(38.48,14.92) v7(38.51,34.58) v7(38.51,34.15) v7(38.51,33.72) v7(38.66,109.19) v7(38.66,108.79) v7(38.66,108.35) v7(38.66,107.92) v7(38.66,39.66) v7(38.66,39.23) v7(38.66,38.8) v7(38.66,38.29) v7(38.66,37.86) v7(38.66,37.42) v7(38.61,31.89) v7(38.61,31.45) v7(38.61,31.02) v7(38.61,18.65) v7(38.61,18.22) v7(38.61,17.79) v7(38.61,17.38) v7(38.76,20.66) v7(38.76,20.23) v7(38.76,19.8) v7(38.76,19.39) v7(38.86,111.56) v7(38.86,111.12) v7(38.86,110.69) v7(38.86,110.29) v7(38.86,26.32) v7(38.86,25.92) v7(38.84,24.93) v7(38.84,24.52) v7(38.89,16.19) v7(38.89,15.76) v7(38.89,15.33) v7(38.89,14.92) v7(39.06,109.19) v7(39.06,108.76) v7(39.06,108.33) v7(39.06,107.92) v7(39.04,18.65) v7(39.04,18.25) v7(39.04,17.82) v7(39.04,17.38) v7(39.19,20.66) v7(39.19,20.25) v7(39.19,19.82) v7(39.19,19.39) v7(39.29,111.56) v7(39.29,111.15) v7(39.29,110.72) v7(39.29,110.29) v7(39.29,26.35) v7(39.29,25.92) v7(39.27,24.95) v7(39.27,24.52) v7(39.27,23.73) v7(39.27,23.33) v7(39.32,16.19) v7(39.32,15.78) v7(39.32,15.35) v7(39.32,14.92) v7(39.49,109.19) v7(39.49,108.79) v7(39.49,108.35) v7(39.49,107.92) v7(39.69,111.56) v7(39.69,111.12) v7(39.69,110.69) v7(39.69,110.29) v7(39.7,23.76) v7(39.7,23.33) v7(39.88,17.89) v7(39.88,17.46) v7(39.88,17.03) v7(39.88,16.62) v7(40.01,31.58) v7(40.01,31.15) v7(40.01,30.72) v7(40.13,111.56) v7(40.13,111.15) v7(40.13,110.72) v7(40.13,110.29) v7(40.31,17.89) v7(40.31,17.48) v7(40.31,17.05) v7(40.31,16.62) v7(40.46,31.1) v7(40.46,30.67) v7(40.46,30.24) v7(40.67,14.28) v7(40.67,13.85) v7(40.67,13.42) v7(40.67,13.01) v7(40.72,17.89) v7(40.72,17.46) v7(40.72,17.03) v7(40.72,16.62) v7(40.72,11.21) v7(40.72,10.78) v7(40.72,10.35) v7(40.72,9.94) v7(40.92,30.62) v7(40.92,30.18) v7(40.92,29.75) v7(41.07,15.73) v7(41.07,15.3) v7(41.1,14.28) v7(41.1,13.88) v7(41.1,13.45) v7(41.1,13.01) v7(41.07,12.38) v7(41.07,11.95) v7(41.18,113.2) v7(41.18,112.77) v7(41.18,112.34) v7(41.18,111.93) v7(41.15,17.89) v7(41.15,17.48) v7(41.15,17.05) v7(41.15,16.62) v7(41.15,11.21) v7(41.15,10.8) v7(41.15,10.37) v7(41.15,9.94) v7(41.43,30.13) v7(41.43,29.7) v7(41.43,29.27) v7(41.48,15.71) v7(41.48,15.28) v7(41.5,14.28) v7(41.5,13.85) v7(41.5,13.42) v7(41.5,13.01) v7(41.48,12.35) v7(41.48,11.92) v7(41.56,11.21) v7(41.56,10.78) v7(41.56,10.35) v7(41.56,9.94) v7(41.61,113.2) v7(41.61,112.8) v7(41.61,112.36) v7(41.61,111.93) v7(41.71,26.32) v7(41.71,25.89) v7(41.71,25.46) v7(41.71,25.05) v7(41.96,29.6) v7(41.96,29.17) v7(41.96,28.74) v7(41.91,15.73) v7(41.91,15.3) v7(41.94,14.28) v7(41.94,13.88) v7(41.94,13.45) v7(41.94,13.01) v7(41.91,12.38) v7(41.91,11.95) v7(41.99,11.21) v7(41.99,10.8) v7(41.99,10.37) v7(41.99,9.94) v7(42.02,113.2) v7(42.02,112.77) v7(42.02,112.34) v7(42.02,111.93) v7(42.14,26.32) v7(42.14,25.92) v7(42.14,25.49) v7(42.14,25.05) v7(42.45,113.2) v7(42.45,112.8) v7(42.45,112.36) v7(42.45,111.93) v7(42.42,29.09) v7(42.42,28.66) v7(42.42,28.23) v7(42.55,26.32) v7(42.55,25.89) v7(42.55,25.46) v7(42.55,25.05) v7(42.67,4.4) v7(42.67,3.97) v7(42.85,15.22) v7(42.85,14.79) v7(42.85,14.36) v7(42.85,13.95) v7(42.98,26.32) v7(42.98,25.92) v7(42.98,25.49) v7(42.98,25.05) v7(43.03,12.91) v7(43.03,12.48) v7(43.08,4.38) v7(43.08,3.95) v7(43.28,15.22) v7(43.28,14.82) v7(43.28,14.39) v7(43.28,13.95) v7(43.43,12.89) v7(43.43,12.46) v7(43.51,4.4) v7(43.51,3.97) v7(43.69,15.22) v7(43.69,14.79) v7(43.69,14.36) v7(43.69,13.95) v7(43.74,11.52) v7(43.74,11.08) v7(43.74,10.65) v7(43.74,10.25) v7(43.87,12.91) v7(43.87,12.48) v7(43.97,6.74) v7(43.97,6.31) v7(43.97,5.88) v7(43.97,5.47) v7(44.1,69.48) v7(44.1,69.1) v7(44.1,8.87) v7(44.1,8.44) v7(44.1,8.01) v7(44.1,7.6) v7(44.18,113.2) v7(44.18,112.77) v7(44.18,112.34) v7(44.18,111.93) v7(44.13,75.73) v7(44.13,75.34) v7(44.12,15.22) v7(44.12,14.82) v7(44.12,14.39) v7(44.12,13.95) v7(44.17,11.52) v7(44.17,11.11) v7(44.17,10.68) v7(44.17,10.25) v7(44.27,37.8) v7(44.27,37.37) v7(44.4,6.74) v7(44.4,6.33) v7(44.4,5.9) v7(44.4,5.47) v7(44.48,74.2) v7(44.48,69.48) v7(44.48,69.1) v7(44.51,75.73) v7(44.51,75.34) v7(44.51,74.58) v7(44.58,11.52) v7(44.58,11.08) v7(44.58,10.65) v7(44.58,10.25) v7(44.53,8.87) v7(44.53,8.47) v7(44.53,8.04) v7(44.53,7.6) v7(44.61,113.2) v7(44.61,112.8) v7(44.61,112.36) v7(44.61,111.93) v7(44.64,72.17) v7(44.68,37.78) v7(44.68,37.35) v7(44.65,4.35) v7(44.65,3.92) v7(44.89,74.58) v7(44.85,74.21) v7(44.81,6.74) v7(44.81,6.31) v7(44.81,5.88) v7(44.81,5.47) v7(44.93,8.87) v7(44.93,8.44) v7(44.93,8.01) v7(44.93,7.6) v7(45.01,113.2) v7(45.01,112.77) v7(45.01,112.34) v7(45.01,111.93) v7(45.02,72.17) v7(45.09,41.51) v7(45.09,41.08) v7(45.01,11.52) v7(45.01,11.11) v7(45.01,10.68) v7(45.01,10.25) v7(45.06,4.33) v7(45.06,3.9) v7(45.11,37.8) v7(45.11,37.37) v7(45.22,76.13) v7(45.22,75.75) v7(45.21,12.91) v7(45.21,12.48) v7(45.24,6.74) v7(45.24,6.33) v7(45.24,5.9) v7(45.24,5.47) v7(45.37,8.87) v7(45.37,8.47) v7(45.37,8.04) v7(45.37,7.6) v7(45.45,113.2) v7(45.45,112.8) v7(45.45,112.36) v7(45.45,111.93) v7(45.49,41.49) v7(45.49,41.06) v7(45.49,4.35) v7(45.49,3.92) v7(45.6,76.13) v7(45.6,75.75) v7(45.52,26.17) v7(45.52,25.74) v7(45.52,25.31) v7(45.52,24.9) v7(45.67,35.82) v7(45.67,35.39) v7(45.62,12.89) v7(45.62,12.46) v7(45.91,75.09) v7(45.91,74.71) v7(45.91,73.57) v7(45.91,73.19) v7(45.92,41.51) v7(45.92,41.08) v7(45.92,37.55) v7(45.92,37.12) v7(45.95,26.17) v7(45.95,25.77) v7(45.95,25.33) v7(45.95,24.9) v7(46.08,40.09) v7(46.08,39.66) v7(46.08,35.8) v7(46.08,35.37) v7(46.03,34.71) v7(46.03,34.27) v7(46.05,12.91) v7(46.05,12.48) v7(46.29,75.09) v7(46.29,74.71) v7(46.29,73.57) v7(46.29,73.19) v7(46.33,37.53) v7(46.33,37.09) v7(46.36,26.17) v7(46.36,25.74) v7(46.36,25.31) v7(46.36,24.9) v7(46.38,4.33) v7(46.38,3.9) v7(46.48,40.07) v7(46.48,39.63) v7(46.43,34.68) v7(46.43,34.25) v7(46.51,35.82) v7(46.51,35.39) v7(46.76,37.55) v7(46.76,37.12) v7(46.79,26.17) v7(46.79,25.77) v7(46.79,25.33) v7(46.79,24.9) v7(46.76,24.27) v7(46.76,23.83) v7(46.76,23.4) v7(46.76,23) v7(46.79,4.3) v7(46.79,3.87) v7(46.86,34.71) v7(46.86,34.27) v7(46.92,113.2) v7(46.92,112.77) v7(46.92,112.34) v7(46.92,111.93) v7(46.95,71.56) v7(46.91,40.09) v7(46.91,39.66) v7(47.05,73.69) v7(47.05,73.31) v7(47.19,24.27) v7(47.19,23.86) v7(47.19,23.43) v7(47.19,23) v7(47.22,4.33) v7(47.22,3.9) v7(47.35,113.2) v7(47.35,112.8) v7(47.35,112.36) v7(47.35,111.93) v7(47.33,71.56) v7(47.47,73.72) v7(47.42,73.35) v7(47.56,74.96) v7(47.56,74.58) v7(47.56,72.04) v7(47.6,24.27) v7(47.6,23.83) v7(47.6,23.4) v7(47.6,23) v7(47.76,113.2) v7(47.76,112.77) v7(47.76,112.34) v7(47.76,111.93) v7(47.8,49.62) v7(47.8,49.18) v7(47.81,71.56) v7(47.94,74.96) v7(47.94,74.58) v7(47.94,72.04) v7(48.03,24.27) v7(48.03,23.86) v7(48.03,23.43) v7(48.03,23) v7(48.19,113.2) v7(48.19,112.8) v7(48.19,112.36) v7(48.19,111.93) v7(48.19,71.56) v7(48.21,49.59) v7(48.21,49.16) v7(48.21,46.29) v7(48.21,45.86) v7(48.64,49.62) v7(48.64,49.18) v7(48.62,46.26) v7(48.62,45.83) v7(48.9,72.81) v7(48.92,73.92) v7(49.05,46.29) v7(49.05,45.86) v7(49.33,39.81) v7(49.33,39.38) v7(49.46,73.95) v7(49.58,113.2) v7(49.58,112.77) v7(49.58,112.34) v7(49.58,111.93) v7(49.68,49.79) v7(49.68,49.36) v7(49.68,48.93) v7(49.68,48.52) v7(49.71,111.47) v7(49.71,111.04) v7(49.71,110.61) v7(49.71,110.2) v7(49.73,39.79) v7(49.73,39.35) v7(49.87,74.66) v7(49.92,74.13) v7(49.97,73.31) v7(49.96,47.53) v7(49.96,47.1) v7(49.96,46.67) v7(49.96,46.26) v7(49.91,44.36) v7(49.91,43.93) v7(49.91,43.49) v7(49.91,43.09) v7(50.01,113.2) v7(50.01,112.8) v7(50.01,112.36) v7(50.01,111.93) v7(50.01,41.74) v7(50.01,41.31) v7(50.01,40.88) v7(50.01,40.47) v7(50.14,111.47) v7(50.14,111.07) v7(50.14,110.63) v7(50.14,110.2) v7(50.11,49.79) v7(50.11,49.39) v7(50.11,48.96) v7(50.11,48.52) v7(50.17,39.81) v7(50.17,39.38) v7(50.39,47.53) v7(50.39,47.13) v7(50.39,46.69) v7(50.39,46.26) v7(50.34,44.36) v7(50.34,43.95) v7(50.34,43.52) v7(50.34,43.09) v7(50.39,36.08) v7(50.39,35.65) v7(50.42,113.2) v7(50.42,112.77) v7(50.42,112.34) v7(50.42,111.93) v7(50.45,41.74) v7(50.45,41.34) v7(50.45,40.9) v7(50.45,40.47) v7(50.54,111.47) v7(50.54,111.04) v7(50.54,110.61) v7(50.54,110.2) v7(50.53,73.21) v7(50.52,49.79) v7(50.52,49.36) v7(50.52,48.93) v7(50.52,48.52) v7(50.52,2.6) v7(50.52,2.17) v7(50.52,1.74) v7(50.52,1.33) v7(50.62,38.11) v7(50.62,37.68) v7(50.62,37.25) v7(50.62,36.84) v7(50.73,72.8) v7(50.73,72.42) v7(50.8,47.53) v7(50.8,47.1) v7(50.8,46.67) v7(50.8,46.26) v7(50.75,44.36) v7(50.75,43.93) v7(50.75,43.49) v7(50.75,43.09) v7(50.8,36.05) v7(50.8,35.62) v7(50.85,113.2) v7(50.85,112.8) v7(50.85,112.36) v7(50.85,111.93) v7(50.85,41.74) v7(50.85,41.31) v7(50.85,40.88) v7(50.85,40.47) v7(50.98,111.47) v7(50.98,111.07) v7(50.98,110.63) v7(50.98,110.2) v7(50.95,49.79) v7(50.95,49.39) v7(50.95,48.96) v7(50.95,48.52) v7(50.95,2.6) v7(50.95,2.19) v7(50.95,1.76) v7(50.95,1.33) v7(51.01,73.46) v7(51.05,38.11) v7(51.05,37.7) v7(51.05,37.27) v7(51.05,36.84) v7(51.18,73.97) v7(51.11,72.8) v7(51.11,72.42) v7(51.18,44.36) v7(51.18,43.95) v7(51.18,43.52) v7(51.18,43.09) v7(51.23,47.53) v7(51.23,47.13) v7(51.23,46.69) v7(51.23,46.26) v7(51.28,41.74) v7(51.28,41.34) v7(51.28,40.9) v7(51.28,40.47) v7(51.23,36.08) v7(51.23,35.65) v7(51.36,2.6) v7(51.36,2.17) v7(51.36,1.74) v7(51.36,1.33) v7(51.46,38.11) v7(51.46,37.68) v7(51.46,37.25) v7(51.46,36.84) v7(51.79,2.6) v7(51.79,2.19) v7(51.79,1.76) v7(51.79,1.33) v7(51.88,74.2) v7(51.82,42.28) v7(51.82,41.84) v7(51.89,38.11) v7(51.89,37.7) v7(51.89,37.27) v7(51.89,36.84) v7(51.99,45.22) v7(51.99,44.79) v7(52.07,113.24) v7(52.07,112.81) v7(52.07,112.38) v7(52.07,111.97) v7(52.1,9.33) v7(52.1,8.9) v7(52.1,8.47) v7(52.1,8.06) v7(52.15,17.97) v7(52.15,17.54) v7(52.17,16.62) v7(52.17,16.19) v7(52.26,74.2) v7(52.26,73.82) v7(52.22,42.25) v7(52.22,41.82) v7(52.27,15.1) v7(52.27,14.67) v7(52.27,14.23) v7(52.27,13.83) v7(52.3,13.09) v7(52.3,12.66) v7(52.4,45.2) v7(52.4,44.76) v7(52.5,113.24) v7(52.5,112.84) v7(52.5,112.41) v7(52.5,111.97) v7(52.45,111.39) v7(52.45,110.96) v7(52.45,110.52) v7(52.45,110.12) v7(52.43,2.6) v7(52.43,2.17) v7(52.43,1.74) v7(52.43,1.33) v7(52.54,109.49) v7(52.54,109.06) v7(52.54,108.62) v7(52.54,108.22) v7(52.55,17.94) v7(52.55,17.51) v7(52.58,16.6) v7(52.58,16.16) v7(52.53,9.33) v7(52.53,8.93) v7(52.53,8.49) v7(52.53,8.06) v7(52.65,42.28) v7(52.65,41.84) v7(52.63,37.6) v7(52.63,37.17) v7(52.76,49.44) v7(52.76,49.01) v7(52.71,15.1) v7(52.71,14.69) v7(52.71,14.26) v7(52.71,13.83) v7(52.71,13.07) v7(52.71,12.63) v7(52.88,111.39) v7(52.88,110.98) v7(52.88,110.55) v7(52.88,110.12) v7(52.83,45.22) v7(52.83,44.79) v7(52.86,2.6) v7(52.86,2.19) v7(52.86,1.76) v7(52.86,1.33) v7(52.91,113.24) v7(52.91,112.81) v7(52.91,112.38) v7(52.91,111.97) v7(52.97,109.49) v7(52.97,109.08) v7(52.97,108.65) v7(52.97,108.22) v7(52.93,47.18) v7(52.93,46.75) v7(52.93,46.31) v7(52.93,45.91) v7(52.99,17.97) v7(52.99,17.54) v7(52.93,9.33) v7(52.93,8.9) v7(52.93,8.47) v7(52.93,8.06) v7(53.01,43.16) v7(53.01,42.73) v7(53.04,37.58) v7(53.04,37.14) v7(53.01,16.62) v7(53.01,16.19) v7(53.16,49.41) v7(53.16,48.98) v7(53.11,15.1) v7(53.11,14.67) v7(53.11,14.23) v7(53.11,13.83) v7(53.14,13.09) v7(53.14,12.66) v7(53.29,111.39) v7(53.29,110.96) v7(53.29,110.52) v7(53.29,110.12) v7(53.26,2.6) v7(53.26,2.17) v7(53.26,1.74) v7(53.26,1.33) v7(53.34,113.24) v7(53.34,112.84) v7(53.34,112.41) v7(53.34,111.97) v7(53.37,109.49) v7(53.37,109.06) v7(53.37,108.62) v7(53.37,108.22) v7(53.37,47.18) v7(53.37,46.77) v7(53.37,46.34) v7(53.37,45.91) v7(53.37,9.33) v7(53.37,8.93) v7(53.37,8.49) v7(53.37,8.06) v7(53.42,43.14) v7(53.42,42.71) v7(53.47,37.6) v7(53.47,37.17) v7(53.59,49.44) v7(53.59,49.01) v7(53.54,15.1) v7(53.54,14.69) v7(53.54,14.26) v7(53.54,13.83) v7(53.7,2.6) v7(53.7,2.19) v7(53.7,1.76) v7(53.7,1.33) v7(53.72,111.39) v7(53.72,110.98) v7(53.72,110.55) v7(53.72,110.12) v7(53.81,109.49) v7(53.81,109.08) v7(53.81,108.65) v7(53.81,108.22) v7(53.77,47.18) v7(53.77,46.75) v7(53.77,46.31) v7(53.77,45.91) v7(53.85,43.16) v7(53.85,42.73) v7(54.2,47.18) v7(54.2,46.77) v7(54.2,46.34) v7(54.2,45.91) v7(54.2,26.1) v7(54.2,25.66) v7(54.2,2.58) v7(54.2,2.14) v7(54.2,1.71) v7(54.2,1.31) v7(54.3,29.29) v7(54.26,27.14) v7(54.26,26.71) v7(54.28,14.51) v7(54.28,14.08) v7(54.28,13.65) v7(54.28,13.24) v7(54.31,29.64) v7(54.33,25.1) v7(54.33,24.67) v7(54.43,113.24) v7(54.43,112.81) v7(54.43,112.38) v7(54.43,111.97) v7(54.51,28.36) v7(54.51,27.92) v7(54.51,16.01) v7(54.51,15.58) v7(54.67,29.63) v7(54.66,27.11) v7(54.66,26.68) v7(54.61,26.07) v7(54.61,25.64) v7(54.64,2.58) v7(54.64,2.17) v7(54.64,1.74) v7(54.64,1.31) v7(54.74,25.08) v7(54.74,24.65) v7(54.79,22.11) v7(54.79,21.7) v7(54.79,21.27) v7(54.71,14.51) v7(54.71,14.11) v7(54.71,13.67) v7(54.71,13.24) v7(54.87,113.24) v7(54.87,112.84) v7(54.87,112.41) v7(54.87,111.97) v7(54.86,45.37) v7(54.86,44.94) v7(54.86,44.51) v7(54.86,44.1) v7(54.92,28.33) v7(54.92,27.9) v7(54.92,15.99) v7(54.92,15.55) v7(55.02,29.63) v7(55.09,27.14) v7(55.09,26.71) v7(55.04,26.1) v7(55.04,25.66) v7(55.04,2.58) v7(55.04,2.14) v7(55.04,1.71) v7(55.04,1.31) v7(55.17,25.1) v7(55.17,24.67) v7(55.19,22.11) v7(55.19,21.68) v7(55.19,21.24) v7(55.12,14.51) v7(55.12,14.08) v7(55.12,13.65) v7(55.12,13.24) v7(55.27,113.24) v7(55.27,112.81) v7(55.27,112.38) v7(55.27,111.97) v7(55.3,45.37) v7(55.3,44.97) v7(55.3,44.54) v7(55.3,44.1) v7(55.35,47.18) v7(55.35,46.75) v7(55.35,28.36) v7(55.35,27.92) v7(55.35,16.01) v7(55.35,15.58) v7(55.47,2.58) v7(55.47,2.17) v7(55.47,1.74) v7(55.47,1.31) v7(55.53,111.47) v7(55.53,111.04) v7(55.53,110.61) v7(55.53,110.2) v7(55.53,20.71) v7(55.53,20.3) v7(55.53,19.87) v7(55.55,14.51) v7(55.55,14.11) v7(55.55,13.67) v7(55.55,13.24) v7(55.7,113.24) v7(55.7,112.84) v7(55.7,112.41) v7(55.7,111.97) v7(55.7,45.37) v7(55.7,44.94) v7(55.7,44.51) v7(55.7,44.1) v7(55.63,22.11) v7(55.63,21.7) v7(55.63,21.27) v7(55.75,47.15) v7(55.75,46.72) v7(55.83,12.25) v7(55.83,11.82) v7(55.83,11.39) v7(55.83,10.98) v7(55.96,111.47) v7(55.96,111.07) v7(55.96,110.63) v7(55.96,110.2) v7(55.93,20.71) v7(55.93,20.28) v7(55.93,19.85) v7(55.91,2.58) v7(55.91,2.14) v7(55.91,1.71) v7(55.91,1.31) v7(56.08,28.4) v7(56.08,28.05) v7(56.08,27.62) v7(56.19,47.18) v7(56.19,46.75) v7(56.13,45.37) v7(56.13,44.97) v7(56.13,44.54) v7(56.13,44.1) v7(56.21,39.38) v7(56.21,38.95) v7(56.21,38.52) v7(56.21,38.11) v7(56.29,14.03) v7(56.29,13.6) v7(56.29,13.17) v7(56.29,12.76) v7(56.26,12.25) v7(56.26,11.85) v7(56.26,11.41) v7(56.26,10.98) v7(56.37,111.47) v7(56.37,111.04) v7(56.37,110.61) v7(56.37,110.2) v7(56.36,20.71) v7(56.36,20.3) v7(56.36,19.87) v7(56.34,2.58) v7(56.34,2.17) v7(56.34,1.74) v7(56.34,1.31) v7(56.5,28.4) v7(56.49,28.03) v7(56.49,27.59) v7(56.59,113.24) v7(56.59,112.81) v7(56.59,112.38) v7(56.59,111.97) v7(56.59,35.37) v7(56.59,34.93) v7(56.59,34.5) v7(56.59,34.1) v7(56.64,39.38) v7(56.64,38.97) v7(56.64,38.54) v7(56.64,38.11) v7(56.67,12.25) v7(56.67,11.82) v7(56.67,11.39) v7(56.67,10.98) v7(56.8,111.47) v7(56.8,111.07) v7(56.8,110.63) v7(56.8,110.2) v7(56.77,43.34) v7(56.77,42.91) v7(56.72,14.03) v7(56.72,13.62) v7(56.72,13.19) v7(56.72,12.76) v7(56.74,2.58) v7(56.74,2.14) v7(56.74,1.71) v7(56.74,1.31) v7(56.92,28.05) v7(56.92,27.62) v7(57,26.88) v7(57,26.45) v7(57.02,113.24) v7(57.02,112.84) v7(57.02,112.41) v7(57.02,111.97) v7(57.05,39.38) v7(57.05,38.95) v7(57.05,38.52) v7(57.05,38.11) v7(57.02,35.37) v7(57.02,34.96) v7(57.02,34.53) v7(57.02,34.1) v7(57.1,12.25) v7(57.1,11.85) v7(57.1,11.41) v7(57.1,10.98) v7(57.18,43.32) v7(57.18,42.88) v7(57.13,14.03) v7(57.13,13.6) v7(57.13,13.17) v7(57.13,12.76) v7(57.18,2.58) v7(57.18,2.17) v7(57.18,1.74) v7(57.18,1.31) v7(57.23,49.49) v7(57.23,49.06) v7(57.23,48.63) v7(57.23,48.22) v7(57.4,26.86) v7(57.4,26.43) v7(57.43,113.24) v7(57.43,112.81) v7(57.43,112.38) v7(57.43,111.97) v7(57.48,39.38) v7(57.48,38.97) v7(57.48,38.54) v7(57.48,38.11) v7(57.43,35.37) v7(57.43,34.93) v7(57.43,34.5) v7(57.43,34.1) v7(57.53,25.64) v7(57.53,25.21) v7(57.53,21.8) v7(57.53,21.4) v7(57.53,20.96) v7(57.56,14.03) v7(57.56,13.62) v7(57.56,13.19) v7(57.56,12.76) v7(57.66,49.49) v7(57.66,49.08) v7(57.66,48.65) v7(57.66,48.22) v7(57.61,43.34) v7(57.61,42.91) v7(57.66,2.63) v7(57.66,2.19) v7(57.66,1.76) v7(57.66,1.36) v7(57.86,113.24) v7(57.86,112.84) v7(57.86,112.41) v7(57.86,111.97) v7(57.81,111.47) v7(57.81,111.04) v7(57.81,110.61) v7(57.81,110.2) v7(57.86,35.37) v7(57.86,34.96) v7(57.86,34.53) v7(57.86,34.1) v7(57.84,26.88) v7(57.84,26.45) v7(57.94,25.61) v7(57.94,25.18) v7(57.94,21.8) v7(57.94,21.37) v7(57.94,20.94) v7(58.07,49.49) v7(58.07,49.06) v7(58.07,48.63) v7(58.07,48.22) v7(58.09,2.63) v7(58.09,2.22) v7(58.09,1.79) v7(58.09,1.36) v7(58.14,18.96) v7(58.14,18.53) v7(58.14,18.09) v7(58.24,111.47) v7(58.24,111.07) v7(58.24,110.63) v7(58.24,110.2) v7(58.37,25.64) v7(58.37,25.21) v7(58.37,21.8) v7(58.37,21.4) v7(58.37,20.96) v7(58.5,49.49) v7(58.5,49.08) v7(58.5,48.65) v7(58.5,48.22) v7(58.5,2.63) v7(58.5,2.19) v7(58.5,1.76) v7(58.5,1.36) v7(58.6,33.13) v7(58.6,32.7) v7(58.6,32.27) v7(58.6,31.86) v7(58.57,18.96) v7(58.57,18.55) v7(58.57,18.12) v7(58.7,113.24) v7(58.7,112.81) v7(58.7,112.38) v7(58.7,111.97) v7(58.65,111.47) v7(58.65,111.04) v7(58.65,110.61) v7(58.65,110.2) v7(58.78,36.56) v7(58.78,36.13) v7(58.78,35.7) v7(58.78,35.29) v7(58.9,41.82) v7(58.9,41.39) v7(58.95,46.77) v7(58.95,46.34) v7(58.95,45.91) v7(58.95,45.5) v7(58.95,43.57) v7(58.95,43.14) v7(58.93,2.63) v7(58.93,2.22) v7(58.93,1.79) v7(58.93,1.36) v7(59.08,111.47) v7(59.08,111.07) v7(59.08,110.63) v7(59.08,110.2) v7(59.03,33.13) v7(59.03,32.72) v7(59.03,32.29) v7(59.03,31.86) v7(59.13,113.24) v7(59.13,112.84) v7(59.13,112.41) v7(59.13,111.97) v7(59.21,36.56) v7(59.21,36.15) v7(59.21,35.72) v7(59.21,35.29) v7(59.31,49.44) v7(59.31,49.01) v7(59.39,46.77) v7(59.39,46.36) v7(59.39,45.93) v7(59.39,45.5) v7(59.36,43.55) v7(59.36,43.11) v7(59.31,41.79) v7(59.31,41.36) v7(59.39,2.63) v7(59.39,2.19) v7(59.39,1.76) v7(59.39,1.36) v7(59.44,33.13) v7(59.44,32.7) v7(59.44,32.27) v7(59.44,31.86) v7(59.54,113.24) v7(59.54,112.81) v7(59.54,112.38) v7(59.54,111.97) v7(59.61,36.56) v7(59.61,36.13) v7(59.61,35.7) v7(59.61,35.29) v7(59.72,49.41) v7(59.72,48.98) v7(59.79,46.77) v7(59.79,46.34) v7(59.79,45.91) v7(59.79,45.5) v7(59.79,43.57) v7(59.79,43.14) v7(59.74,41.82) v7(59.74,41.39) v7(59.72,16.57) v7(59.72,16.16) v7(59.72,15.73) v7(59.87,33.13) v7(59.87,32.72) v7(59.87,32.29) v7(59.87,31.86) v7(59.82,22.54) v7(59.82,22.13) v7(59.82,21.7) v7(59.87,18.96) v7(59.87,18.55) v7(59.87,18.12) v7(59.82,2.63) v7(59.82,2.22) v7(59.82,1.79) v7(59.82,1.36) v7(59.97,113.24) v7(59.97,112.84) v7(59.97,112.41) v7(59.97,111.97) v7(60.05,111.47) v7(60.05,111.04) v7(60.05,110.61) v7(60.05,110.2) v7(60.05,36.56) v7(60.05,36.15) v7(60.05,35.72) v7(60.05,35.29) v7(60.15,49.44) v7(60.15,49.01) v7(60.15,25.08) v7(60.15,24.65) v7(60.12,16.57) v7(60.12,16.14) v7(60.12,15.71) v7(60.22,46.77) v7(60.22,46.36) v7(60.22,45.93) v7(60.22,45.5) v7(60.22,22.54) v7(60.22,22.11) v7(60.22,21.68) v7(60.27,18.96) v7(60.27,18.53) v7(60.27,18.09) v7(60.22,2.63) v7(60.22,2.19) v7(60.22,1.76) v7(60.22,1.36) v7(60.48,111.47) v7(60.48,111.07) v7(60.48,110.63) v7(60.48,110.2) v7(60.43,37.32) v7(60.43,36.89) v7(60.5,33.23) v7(60.5,32.8) v7(60.5,31.18) v7(60.5,30.74) v7(60.55,25.05) v7(60.55,24.62) v7(60.55,16.57) v7(60.55,16.16) v7(60.55,15.73) v7(60.68,38.92) v7(60.68,38.49) v7(60.63,34.88) v7(60.63,34.45) v7(60.66,22.54) v7(60.66,22.13) v7(60.66,21.7) v7(60.66,2.63) v7(60.66,2.22) v7(60.66,1.79) v7(60.66,1.36) v7(60.71,18.96) v7(60.71,18.55) v7(60.71,18.12) v7(60.89,111.47) v7(60.89,111.04) v7(60.89,110.61) v7(60.89,110.2) v7(60.83,37.3) v7(60.83,36.87) v7(60.99,47.43) v7(60.99,47) v7(60.91,33.21) v7(60.91,32.78) v7(60.91,31.15) v7(60.91,30.72) v7(60.99,25.08) v7(60.99,24.65) v7(61.02,113.2) v7(61.02,112.77) v7(61.02,112.34) v7(61.02,111.93) v7(61.07,75.6) v7(61.07,75.22) v7(61.09,38.9) v7(61.09,38.47) v7(61.04,34.86) v7(61.04,34.43) v7(61.09,2.6) v7(61.09,2.17) v7(61.09,1.74) v7(61.09,1.33) v7(61.19,49.57) v7(61.19,49.13) v7(61.19,48.7) v7(61.19,48.3) v7(61.29,43.42) v7(61.29,42.99) v7(61.29,42.55) v7(61.29,42.15) v7(61.27,37.32) v7(61.27,36.89) v7(61.32,111.47) v7(61.32,111.07) v7(61.32,110.63) v7(61.32,110.2) v7(61.39,47.41) v7(61.39,46.97) v7(61.34,33.23) v7(61.34,32.8) v7(61.34,31.18) v7(61.34,30.74) v7(61.32,19.14) v7(61.32,18.7) v7(61.45,113.2) v7(61.45,112.8) v7(61.45,112.36) v7(61.45,111.93) v7(61.44,51.27) v7(61.44,50.84) v7(61.47,34.88) v7(61.47,34.45) v7(61.52,38.92) v7(61.52,38.49) v7(61.52,2.6) v7(61.52,2.19) v7(61.52,1.76) v7(61.52,1.33) v7(61.62,49.57) v7(61.62,49.16) v7(61.62,48.73) v7(61.62,48.3) v7(61.7,25.13) v7(61.7,24.7) v7(61.72,43.42) v7(61.72,43.01) v7(61.72,42.58) v7(61.72,42.15) v7(61.72,19.11) v7(61.72,18.68) v7(61.86,113.2) v7(61.86,112.77) v7(61.86,112.34) v7(61.86,111.93) v7(61.85,51.24) v7(61.85,50.81) v7(61.82,47.43) v7(61.82,47) v7(61.85,22.67) v7(61.85,22.26) v7(61.85,21.83) v7(61.95,18.27) v7(61.95,17.84) v7(61.95,17.41) v7(61.95,17) v7(61.98,16.16) v7(61.98,15.73) v7(61.98,15.3) v7(61.98,14.89) v7(61.93,2.6) v7(61.93,2.17) v7(61.93,1.74) v7(61.93,1.33) v7(62.03,49.57) v7(62.03,49.13) v7(62.03,48.7) v7(62.03,48.3) v7(62.1,25.1) v7(62.1,24.67) v7(62.16,111.47) v7(62.16,111.04) v7(62.16,110.61) v7(62.16,110.2) v7(62.13,43.42) v7(62.13,42.99) v7(62.13,42.55) v7(62.13,42.15) v7(62.15,19.14) v7(62.15,18.7) v7(62.29,113.2) v7(62.29,112.8) v7(62.29,112.36) v7(62.29,111.93) v7(62.28,51.27) v7(62.28,50.84) v7(62.26,22.67) v7(62.26,22.23) v7(62.26,21.8) v7(62.36,29.12) v7(62.36,28.69) v7(62.36,28.25) v7(62.36,27.85) v7(62.38,18.27) v7(62.38,17.87) v7(62.38,17.43) v7(62.38,17) v7(62.36,2.6) v7(62.36,2.19) v7(62.36,1.76) v7(62.36,1.33) v7(62.46,49.57) v7(62.46,49.16) v7(62.46,48.73) v7(62.46,48.3) v7(62.41,16.16) v7(62.41,15.76) v7(62.41,15.33) v7(62.41,14.89) v7(62.59,111.47) v7(62.59,111.07) v7(62.59,110.63) v7(62.59,110.2) v7(62.54,46.42) v7(62.54,45.98) v7(62.54,45.55) v7(62.54,45.15) v7(62.56,43.42) v7(62.56,43.01) v7(62.56,42.58) v7(62.56,42.15) v7(62.56,30.77) v7(62.56,30.34) v7(62.54,25.13) v7(62.54,24.7) v7(62.69,22.67) v7(62.69,22.26) v7(62.69,21.83) v7(62.79,29.12) v7(62.79,28.71) v7(62.79,28.28) v7(62.79,27.85) v7(62.79,18.27) v7(62.79,17.84) v7(62.79,17.41) v7(62.79,17) v7(62.81,16.16) v7(62.81,15.73) v7(62.81,15.3) v7(62.81,14.89) v7(62.87,2.6) v7(62.87,2.17) v7(62.87,1.74) v7(62.87,1.33) v7(63,111.47) v7(63,111.04) v7(63,110.61) v7(63,110.2) v7(62.97,46.42) v7(62.97,46.01) v7(62.97,45.58) v7(62.97,45.15) v7(62.97,30.74) v7(62.97,30.31) v7(63.2,29.12) v7(63.2,28.69) v7(63.2,28.25) v7(63.2,27.85) v7(63.22,18.27) v7(63.22,17.87) v7(63.22,17.43) v7(63.22,17) v7(63.25,16.16) v7(63.25,15.76) v7(63.25,15.33) v7(63.25,14.89) v7(63.3,1.76) v7(63.3,1.33) v7(63.37,46.42) v7(63.37,45.98) v7(63.37,45.55) v7(63.37,45.15) v7(63.4,30.77) v7(63.4,30.34) v7(63.32,25.1) v7(63.32,24.67) v7(63.47,113.29) v7(63.47,112.86) v7(63.47,112.42) v7(63.47,112.02) v7(63.43,111.47) v7(63.43,111.07) v7(63.43,110.63) v7(63.43,110.2) v7(63.5,37.93) v7(63.5,37.5) v7(63.5,37.07) v7(63.5,36.66) v7(63.58,32.9) v7(63.58,32.47) v7(63.68,43.88) v7(63.68,43.44) v7(63.63,29.12) v7(63.63,28.71) v7(63.63,28.28) v7(63.63,27.85) v7(63.68,22.67) v7(63.68,22.26) v7(63.68,21.83) v7(63.7,16.21) v7(63.7,15.81) v7(63.7,15.38) v7(63.7,1.74) v7(63.7,1.33) v7(63.75,51.37) v7(63.75,50.94) v7(63.73,25.08) v7(63.73,24.65) v7(63.73,18.27) v7(63.73,17.84) v7(63.73,17.41) v7(63.73,17) v7(63.9,113.29) v7(63.9,112.88) v7(63.9,112.45) v7(63.9,112.02) v7(63.81,46.42) v7(63.81,46.01) v7(63.81,45.58) v7(63.81,45.15) v7(63.93,37.93) v7(63.93,37.53) v7(63.93,37.09) v7(63.93,36.66) v7(63.98,32.88) v7(63.98,32.45) v7(64.08,43.85) v7(64.08,43.42) v7(64.08,22.67) v7(64.08,22.23) v7(64.08,21.8) v7(64.16,51.34) v7(64.16,50.91) v7(64.19,49.54) v7(64.19,49.11) v7(64.19,48.68) v7(64.19,48.27) v7(64.16,25.1) v7(64.16,24.67) v7(64.16,18.27) v7(64.16,17.87) v7(64.16,17.43) v7(64.16,17) v7(64.11,16.21) v7(64.11,15.78) v7(64.11,15.35) v7(64.14,2.6) v7(64.14,2.19) v7(64.14,1.76) v7(64.14,1.33) v7(64.29,47.41) v7(64.29,46.97) v7(64.24,19.39) v7(64.24,18.96) v7(64.31,113.29) v7(64.31,112.86) v7(64.31,112.42) v7(64.31,112.02) v7(64.34,37.93) v7(64.34,37.5) v7(64.34,37.07) v7(64.34,36.66) v7(64.31,31.48) v7(64.31,31.05) v7(64.31,30.62) v7(64.31,30.21) v7(64.49,41.77) v7(64.49,41.34) v7(64.49,40.9) v7(64.49,40.5) v7(64.42,32.9) v7(64.42,32.47) v7(64.59,51.37) v7(64.59,50.94) v7(64.52,43.88) v7(64.52,43.44) v7(64.52,22.67) v7(64.52,22.26) v7(64.52,21.83) v7(64.57,18.27) v7(64.57,17.84) v7(64.57,17.41) v7(64.57,17) v7(64.54,16.21) v7(64.54,15.81) v7(64.54,15.38) v7(64.62,49.54) v7(64.62,49.13) v7(64.62,48.7) v7(64.62,48.27) v7(64.69,47.38) v7(64.69,46.95) v7(64.64,19.36) v7(64.64,18.93) v7(64.74,113.29) v7(64.74,112.88) v7(64.74,112.45) v7(64.74,112.02) v7(64.77,37.93) v7(64.77,37.53) v7(64.77,37.09) v7(64.77,36.66) v7(64.75,31.48) v7(64.75,31.07) v7(64.75,30.64) v7(64.75,30.21) v7(64.8,25.1) v7(64.8,24.67) v7(64.72,1.33) v7(64.92,41.77) v7(64.92,41.36) v7(64.92,40.93) v7(64.92,40.5) v7(65,18.27) v7(65,17.87) v7(65,17.43) v7(65,17) v7(65.02,49.54) v7(65.02,49.11) v7(65.02,48.68) v7(65.02,48.27) v7(65.1,22.59) v7(65.1,22.16) v7(65.08,19.39) v7(65.08,18.96) v7(65.13,47.41) v7(65.13,46.97) v7(65.15,31.48) v7(65.15,31.05) v7(65.15,30.62) v7(65.15,30.21) v7(65.2,25.08) v7(65.2,24.65) v7(65.15,1.33) v7(65.33,41.77) v7(65.33,41.34) v7(65.33,40.9) v7(65.33,40.5) v7(65.46,49.54) v7(65.46,49.13) v7(65.46,48.7) v7(65.46,48.27) v7(65.58,32.83) v7(65.58,32.39) v7(65.58,31.48) v7(65.58,31.07) v7(65.58,30.64) v7(65.58,30.21) v7(65.51,22.56) v7(65.51,22.13) v7(65.56,1.33) v7(65.69,46.42) v7(65.69,45.98) v7(65.69,45.55) v7(65.69,45.15) v7(65.69,37.78) v7(65.69,37.35) v7(65.63,25.1) v7(65.63,24.67) v7(65.76,41.77) v7(65.76,41.36) v7(65.76,40.93) v7(65.76,40.5) v7(65.81,35.67) v7(65.81,35.24) v7(65.99,51.27) v7(65.99,50.84) v7(65.99,49.41) v7(65.99,48.98) v7(65.99,32.8) v7(65.99,32.37) v7(65.94,22.59) v7(65.94,22.16) v7(65.99,1.33) v7(66.09,37.75) v7(66.09,37.32) v7(66.12,46.42) v7(66.12,46.01) v7(66.12,45.58) v7(66.12,45.15) v7(66.22,39.38) v7(66.22,38.95) v7(66.22,35.65) v7(66.22,35.21) v7(66.34,111.6) v7(66.34,111.17) v7(66.34,110.73) v7(66.34,110.33) v7(66.4,51.24) v7(66.4,50.81) v7(66.4,49.39) v7(66.4,48.96) v7(66.4,43.93) v7(66.4,43.49) v7(66.4,43.06) v7(66.4,42.66) v7(66.4,29.12) v7(66.4,28.69) v7(66.4,28.25) v7(66.4,27.85) v7(66.42,32.83) v7(66.42,32.39) v7(66.5,25.1) v7(66.5,24.67) v7(66.42,19.44) v7(66.42,19.03) v7(66.42,18.6) v7(66.42,18.02) v7(66.42,17.59) v7(66.52,46.42) v7(66.52,45.98) v7(66.52,45.55) v7(66.52,45.15) v7(66.52,37.78) v7(66.52,37.35) v7(66.55,2.63) v7(66.55,2.19) v7(66.55,1.76) v7(66.55,1.36) v7(66.7,41.92) v7(66.7,41.49) v7(66.62,39.35) v7(66.62,38.92) v7(66.65,35.67) v7(66.65,35.24) v7(66.65,22.67) v7(66.65,22.26) v7(66.65,21.83) v7(66.77,111.6) v7(66.77,111.19) v7(66.77,110.76) v7(66.77,110.33) v7(66.83,51.27) v7(66.83,50.84) v7(66.83,49.41) v7(66.83,48.98) v7(66.83,43.93) v7(66.83,43.52) v7(66.83,43.09) v7(66.83,42.66) v7(66.83,29.12) v7(66.83,28.71) v7(66.83,28.28) v7(66.83,27.85) v7(66.9,25.08) v7(66.9,24.65) v7(66.83,19.44) v7(66.83,19.01) v7(66.83,18.58) v7(66.83,17.99) v7(66.83,17.56) v7(66.96,46.42) v7(66.96,46.01) v7(66.96,45.58) v7(66.96,45.15) v7(66.98,2.63) v7(66.98,2.22) v7(66.98,1.79) v7(66.98,1.36) v7(67.06,39.38) v7(67.06,38.95) v7(67.06,22.67) v7(67.06,22.23) v7(67.06,21.8) v7(67.18,111.6) v7(67.18,111.17) v7(67.18,110.73) v7(67.18,110.33) v7(67.11,41.89) v7(67.11,41.46) v7(67.23,43.93) v7(67.23,43.49) v7(67.23,43.06) v7(67.23,42.66) v7(67.29,38.21) v7(67.29,37.78) v7(67.29,37.35) v7(67.29,36.94) v7(67.29,33.26) v7(67.29,32.83) v7(67.29,32.39) v7(67.29,31.99) v7(67.21,31.18) v7(67.21,30.74) v7(67.21,30.31) v7(67.21,29.91) v7(67.23,29.12) v7(67.23,28.69) v7(67.23,28.25) v7(67.23,27.85) v7(67.26,19.44) v7(67.26,19.03) v7(67.26,18.6) v7(67.26,18.02) v7(67.26,17.59) v7(67.34,35.75) v7(67.34,35.32) v7(67.34,34.88) v7(67.34,34.48) v7(67.34,25.1) v7(67.34,24.67) v7(67.39,2.63) v7(67.39,2.19) v7(67.39,1.76) v7(67.39,1.36) v7(67.44,49.54) v7(67.44,49.11) v7(67.44,48.68) v7(67.44,48.27) v7(67.49,22.67) v7(67.49,22.26) v7(67.49,21.83) v7(67.54,41.92) v7(67.54,41.49) v7(67.61,111.6) v7(67.61,111.19) v7(67.61,110.76) v7(67.61,110.33) v7(67.67,43.93) v7(67.67,43.52) v7(67.67,43.09) v7(67.67,42.66) v7(67.64,31.18) v7(67.64,30.77) v7(67.64,30.34) v7(67.64,29.91) v7(67.67,29.12) v7(67.67,28.71) v7(67.67,28.28) v7(67.67,27.85) v7(67.77,46.16) v7(67.77,45.73) v7(67.72,38.21) v7(67.72,37.8) v7(67.72,37.37) v7(67.72,36.94) v7(67.77,35.75) v7(67.77,35.34) v7(67.77,34.91) v7(67.77,34.48) v7(67.72,33.26) v7(67.72,32.85) v7(67.72,32.42) v7(67.72,31.99) v7(67.79,15.3) v7(67.79,14.89) v7(67.79,14.46) v7(67.87,49.54) v7(67.87,49.13) v7(67.87,48.7) v7(67.87,48.27) v7(67.82,2.63) v7(67.82,2.22) v7(67.82,1.79) v7(67.82,1.36) v7(68,44.82) v7(68,44.38) v7(68.05,31.18) v7(68.05,30.74) v7(68.05,30.31) v7(68.05,29.91) v7(68.12,47.43) v7(68.12,47) v7(68.17,46.14) v7(68.17,45.7) v7(68.12,38.21) v7(68.12,37.78) v7(68.12,37.35) v7(68.12,36.94) v7(68.17,35.75) v7(68.17,35.32) v7(68.17,34.88) v7(68.17,34.48) v7(68.12,33.26) v7(68.12,32.83) v7(68.12,32.39) v7(68.12,31.99) v7(68.15,22.67) v7(68.15,22.26) v7(68.15,21.83) v7(68.2,15.3) v7(68.2,14.87) v7(68.2,14.44) v7(68.28,49.54) v7(68.28,49.11) v7(68.28,48.68) v7(68.28,48.27) v7(68.4,44.79) v7(68.4,44.36) v7(68.48,43.52) v7(68.48,43.09) v7(68.48,31.18) v7(68.48,30.77) v7(68.48,30.34) v7(68.48,29.91) v7(68.43,2.52) v7(68.43,2.09) v7(68.43,1.66) v7(68.43,1.25) v7(68.53,47.41) v7(68.53,46.97) v7(68.56,38.21) v7(68.56,37.8) v7(68.56,37.37) v7(68.56,36.94) v7(68.56,33.26) v7(68.56,32.85) v7(68.56,32.42) v7(68.56,31.99) v7(68.56,22.67) v7(68.56,22.23) v7(68.56,21.8) v7(68.61,46.16) v7(68.61,45.73) v7(68.61,35.75) v7(68.61,35.34) v7(68.61,34.91) v7(68.61,34.48) v7(68.63,15.3) v7(68.63,14.89) v7(68.63,14.46) v7(68.71,49.54) v7(68.71,49.13) v7(68.71,48.7) v7(68.71,48.27) v7(68.83,44.82) v7(68.83,44.38) v7(68.89,43.49) v7(68.89,43.06) v7(68.86,2.52) v7(68.86,2.12) v7(68.86,1.69) v7(68.86,1.25) v7(68.96,47.43) v7(68.96,47) v7(68.99,22.67) v7(68.99,22.26) v7(68.99,21.83) v7(69.27,2.52) v7(69.27,2.09) v7(69.27,1.66) v7(69.27,1.25) v7(69.32,43.52) v7(69.32,43.09) v7(69.32,15.35) v7(69.32,14.94) v7(69.32,14.51) v7(69.42,51.24) v7(69.42,50.81) v7(69.6,49.08) v7(69.6,48.65) v7(69.67,22.64) v7(69.67,22.23) v7(69.67,21.8) v7(69.7,2.52) v7(69.7,2.12) v7(69.7,1.69) v7(69.7,1.25) v7(69.72,15.35) v7(69.72,14.92) v7(69.72,14.49) v7(69.83,51.22) v7(69.83,50.78) v7(70,49.06) v7(70,48.63) v7(69.93,46.19) v7(69.93,45.76) v7(69.93,45.32) v7(69.93,44.92) v7(70,30.34) v7(70,29.91) v7(70.08,22.64) v7(70.08,22.21) v7(70.08,21.78) v7(70.16,15.35) v7(70.16,14.94) v7(70.16,14.51) v7(70.26,51.24) v7(70.26,50.81) v7(70.28,43.7) v7(70.28,43.27) v7(70.28,42.83) v7(70.28,42.43) v7(70.36,46.19) v7(70.36,45.78) v7(70.36,45.35) v7(70.36,44.92) v7(70.33,35.49) v7(70.33,35.06) v7(70.33,34.63) v7(70.33,34.22) v7(70.43,49.08) v7(70.43,48.65) v7(70.41,30.31) v7(70.41,29.88) v7(70.51,22.64) v7(70.51,22.23) v7(70.51,21.8) v7(70.77,46.19) v7(70.77,45.76) v7(70.77,45.32) v7(70.77,44.92) v7(70.71,43.7) v7(70.71,43.29) v7(70.71,42.86) v7(70.71,42.43) v7(70.77,35.49) v7(70.77,35.09) v7(70.77,34.66) v7(70.77,34.22) v7(70.84,30.34) v7(70.84,29.91) v7(71.07,22.34) v7(71.07,21.9) v7(71.2,46.19) v7(71.2,45.78) v7(71.2,45.35) v7(71.2,44.92) v7(71.12,43.7) v7(71.12,43.27) v7(71.12,42.83) v7(71.12,42.43) v7(71.17,35.49) v7(71.17,35.06) v7(71.17,34.63) v7(71.17,34.22) v7(71.2,15.28) v7(71.2,14.87) v7(71.2,14.44) v7(71.48,22.31) v7(71.48,21.88) v7(71.55,43.7) v7(71.55,43.29) v7(71.55,42.86) v7(71.55,42.43) v7(71.6,35.49) v7(71.6,35.09) v7(71.6,34.66) v7(71.6,34.22) v7(71.6,15.28) v7(71.6,14.84) v7(71.6,14.41) v7(71.73,29.7) v7(71.73,29.27) v7(71.91,22.34) v7(71.91,21.9) v7(72.04,15.28) v7(72.04,14.87) v7(72.04,14.44) v7(72.14,29.68) v7(72.14,29.25) v7(72.57,29.7) v7(72.57,29.27) v7(72.64,22.31) v7(72.64,21.88) v7(73,2.85) v7(73,2.42) v7(73,1.99) v7(73,1.58) v7(73.05,22.29) v7(73.05,21.85) v7(73.13,48.88) v7(73.13,48.45) v7(73.18,38.8) v7(73.18,38.36) v7(73.28,43.75) v7(73.28,43.32) v7(73.28,42.88) v7(73.28,42.48) v7(73.48,22.31) v7(73.48,21.88) v7(73.43,2.85) v7(73.43,2.45) v7(73.43,2.02) v7(73.43,1.58) v7(73.53,48.85) v7(73.53,48.42) v7(73.58,38.77) v7(73.58,38.34) v7(73.64,40.93) v7(73.64,40.5) v7(73.64,40.07) v7(73.64,39.66) v7(73.71,43.75) v7(73.71,43.34) v7(73.71,42.91) v7(73.71,42.48) v7(73.86,4.89) v7(73.86,4.45) v7(73.86,4.02) v7(73.86,3.62) v7(73.84,2.85) v7(73.84,2.42) v7(73.84,1.99) v7(73.84,1.58) v7(73.97,48.88) v7(73.97,48.45) v7(74.07,40.93) v7(74.07,40.52) v7(74.07,40.09) v7(74.07,39.66) v7(74.02,38.8) v7(74.02,38.36) v7(74.07,31.1) v7(74.07,30.67) v7(74.12,43.75) v7(74.12,43.32) v7(74.12,42.88) v7(74.12,42.48) v7(74.24,19.36) v7(74.24,18.93) v7(74.24,18.5) v7(74.24,18.09) v7(74.22,17.38) v7(74.22,16.95) v7(74.22,16.52) v7(74.22,16.11) v7(74.3,4.89) v7(74.3,4.48) v7(74.3,4.05) v7(74.3,3.62) v7(74.27,2.85) v7(74.27,2.45) v7(74.27,2.02) v7(74.27,1.58) v7(74.47,40.93) v7(74.47,40.5) v7(74.47,40.07) v7(74.47,39.66) v7(74.47,31.07) v7(74.47,30.64) v7(74.42,22.9) v7(74.42,22.49) v7(74.42,22.06) v7(74.55,43.75) v7(74.55,43.34) v7(74.55,42.91) v7(74.55,42.48) v7(74.68,19.36) v7(74.68,18.96) v7(74.68,18.53) v7(74.68,18.09) v7(74.65,17.38) v7(74.65,16.98) v7(74.65,16.55) v7(74.65,16.11) v7(74.7,4.89) v7(74.7,4.45) v7(74.7,4.02) v7(74.7,3.62) v7(74.73,15.55) v7(74.73,15.12) v7(74.73,14.69) v7(74.73,14.28) v7(74.91,40.93) v7(74.91,40.52) v7(74.91,40.09) v7(74.91,39.66) v7(74.83,38.47) v7(74.83,38.03) v7(74.83,37.6) v7(74.83,37.2) v7(74.91,31.1) v7(74.91,30.67) v7(74.83,22.9) v7(74.83,22.46) v7(74.83,22.03) v7(75.03,47.05) v7(75.03,46.62) v7(75.08,19.36) v7(75.08,18.93) v7(75.08,18.5) v7(75.08,18.09) v7(75.06,17.38) v7(75.06,16.95) v7(75.06,16.52) v7(75.06,16.11) v7(75.16,36.48) v7(75.16,36.05) v7(75.16,15.55) v7(75.16,15.15) v7(75.16,14.72) v7(75.16,14.28) v7(75.13,4.89) v7(75.13,4.48) v7(75.13,4.05) v7(75.13,3.62) v7(75.26,38.47) v7(75.26,38.06) v7(75.26,37.63) v7(75.26,37.2) v7(75.26,22.9) v7(75.26,22.49) v7(75.26,22.06) v7(75.44,47.03) v7(75.44,46.59) v7(75.44,25.41) v7(75.44,25) v7(75.44,24.57) v7(75.49,17.38) v7(75.49,16.98) v7(75.49,16.55) v7(75.49,16.11) v7(75.59,65.41) v7(75.59,64.98) v7(75.59,64.55) v7(75.59,64.14) v7(75.54,41.03) v7(75.54,40.6) v7(75.57,36.46) v7(75.57,36.03) v7(75.51,19.36) v7(75.51,18.96) v7(75.51,18.53) v7(75.51,18.09) v7(75.57,15.55) v7(75.57,15.12) v7(75.57,14.69) v7(75.57,14.28) v7(75.67,38.47) v7(75.67,38.03) v7(75.67,37.6) v7(75.67,37.2) v7(75.72,103.87) v7(75.72,103.44) v7(75.72,103.01) v7(75.72,102.6) v7(75.72,30.77) v7(75.72,30.34) v7(75.9,93.96) v7(75.9,93.53) v7(75.9,93.1) v7(75.9,92.69) v7(75.85,91.53) v7(75.85,91.09) v7(75.85,90.66) v7(75.85,90.26) v7(75.87,47.05) v7(75.87,46.62) v7(75.85,25.41) v7(75.85,24.98) v7(75.85,24.55) v7(75.82,23.73) v7(75.82,23.33) v7(75.82,22.9) v7(75.95,41.01) v7(75.95,40.57) v7(76,36.48) v7(76,36.05) v7(76,15.55) v7(76,15.15) v7(76,14.72) v7(76,14.28) v7(76.02,65.41) v7(76.02,65.01) v7(76.02,64.58) v7(76.02,64.14) v7(76.1,38.47) v7(76.1,38.06) v7(76.1,37.63) v7(76.1,37.2) v7(76.07,5.27) v7(76.07,4.84) v7(76.07,4.43) v7(76.15,103.87) v7(76.15,103.46) v7(76.15,103.03) v7(76.15,102.6) v7(76.12,30.74) v7(76.12,30.31) v7(76.18,20.23) v7(76.18,19.82) v7(76.18,19.39) v7(76.28,91.53) v7(76.28,91.12) v7(76.28,90.69) v7(76.28,90.26) v7(76.28,45.76) v7(76.28,45.32) v7(76.28,25.41) v7(76.28,25) v7(76.28,24.57) v7(76.23,23.73) v7(76.23,23.3) v7(76.23,22.87) v7(76.23,18.07) v7(76.23,17.64) v7(76.23,17.21) v7(76.23,16.8) v7(76.33,93.96) v7(76.33,93.56) v7(76.33,93.13) v7(76.33,92.69) v7(76.38,41.03) v7(76.38,40.6) v7(76.56,103.87) v7(76.56,103.44) v7(76.56,103.01) v7(76.56,102.6) v7(76.56,84.92) v7(76.56,84.49) v7(76.56,84.06) v7(76.56,83.65) v7(76.56,30.77) v7(76.56,30.34) v7(76.58,20.23) v7(76.58,19.8) v7(76.58,19.36) v7(76.51,5.29) v7(76.51,4.86) v7(76.51,4.43) v7(76.56,2.8) v7(76.56,2.37) v7(76.56,1.94) v7(76.56,1.53) v7(76.66,60.97) v7(76.66,60.54) v7(76.66,60.11) v7(76.66,59.7) v7(76.68,45.73) v7(76.68,45.3) v7(76.66,23.73) v7(76.66,23.33) v7(76.66,22.9) v7(76.66,18.07) v7(76.66,17.66) v7(76.66,17.23) v7(76.66,16.8) v7(76.73,93.96) v7(76.73,93.53) v7(76.73,93.1) v7(76.73,92.69) v7(76.99,103.87) v7(76.99,103.46) v7(76.99,103.03) v7(76.99,102.6) v7(76.99,84.92) v7(76.99,84.52) v7(76.99,84.08) v7(76.99,83.65) v7(76.96,40.22) v7(76.96,39.79) v7(76.96,39.35) v7(76.96,38.95) v7(76.96,38.19) v7(76.96,37.75) v7(76.94,26.1) v7(76.94,25.69) v7(76.94,25.26) v7(76.91,5.7) v7(76.91,5.27) v7(76.91,4.84) v7(76.91,4.43) v7(76.99,2.8) v7(76.99,2.4) v7(76.99,1.97) v7(76.99,1.53) v7(77.09,60.97) v7(77.09,60.56) v7(77.09,60.13) v7(77.09,59.7) v7(77.01,37.04) v7(77.01,36.61) v7(77.01,36.18) v7(77.01,35.77) v7(77.01,20.23) v7(77.01,19.82) v7(77.01,19.39) v7(77.06,18.07) v7(77.06,17.64) v7(77.06,17.21) v7(77.06,16.8) v7(77.17,93.96) v7(77.17,93.56) v7(77.17,93.13) v7(77.17,92.69) v7(77.14,52.03) v7(77.14,51.6) v7(77.12,45.76) v7(77.12,45.32) v7(77.27,96.02) v7(77.27,95.59) v7(77.27,95.16) v7(77.27,94.75) v7(77.39,84.92) v7(77.39,84.49) v7(77.39,84.06) v7(77.39,83.65) v7(77.32,63.08) v7(77.32,62.65) v7(77.32,62.21) v7(77.32,61.81) v7(77.39,40.22) v7(77.39,39.81) v7(77.39,39.38) v7(77.39,38.95) v7(77.37,38.16) v7(77.37,37.73) v7(77.34,26.1) v7(77.34,25.66) v7(77.34,25.23) v7(77.34,5.7) v7(77.34,5.29) v7(77.34,4.86) v7(77.34,4.43) v7(77.39,2.8) v7(77.39,2.37) v7(77.39,1.94) v7(77.39,1.53) v7(77.45,37.04) v7(77.45,36.64) v7(77.45,36.2) v7(77.45,35.77) v7(77.47,34.33) v7(77.47,33.89) v7(77.47,33.46) v7(77.47,33.06) v7(77.5,18.07) v7(77.5,17.66) v7(77.5,17.23) v7(77.5,16.8) v7(77.5,7.91) v7(77.5,7.48) v7(77.5,7.05) v7(77.5,6.64) v7(77.52,91.55) v7(77.52,91.12) v7(77.52,90.69) v7(77.52,90.28) v7(77.55,52) v7(77.55,51.57) v7(77.7,96.02) v7(77.7,95.62) v7(77.7,95.18) v7(77.7,94.75) v7(77.75,63.08) v7(77.75,62.67) v7(77.75,62.24) v7(77.75,61.81) v7(77.78,53.88) v7(77.78,53.45) v7(77.8,40.22) v7(77.8,39.79) v7(77.8,39.35) v7(77.8,38.95) v7(77.8,38.19) v7(77.8,37.75) v7(77.78,26.1) v7(77.78,25.69) v7(77.78,25.26) v7(77.83,84.92) v7(77.83,84.52) v7(77.83,84.08) v7(77.83,83.65) v7(77.9,68.92) v7(77.9,68.49) v7(77.9,68.06) v7(77.9,67.65) v7(77.85,37.04) v7(77.85,36.61) v7(77.85,36.18) v7(77.85,35.77) v7(77.9,34.33) v7(77.9,33.92) v7(77.9,33.49) v7(77.9,33.06) v7(77.83,2.8) v7(77.83,2.4) v7(77.83,1.97) v7(77.83,1.53) v7(77.95,91.55) v7(77.95,91.14) v7(77.95,90.71) v7(77.95,90.28) v7(78,82.08) v7(78,81.65) v7(78,81.21) v7(78,80.81) v7(77.98,80.25) v7(77.98,79.82) v7(77.98,79.38) v7(77.98,78.98) v7(77.93,66.63) v7(77.93,66.2) v7(77.93,65.77) v7(77.93,65.36) v7(77.93,59.83) v7(77.93,59.39) v7(77.93,58.96) v7(77.93,58.56) v7(77.98,51.6) v7(77.98,21.8) v7(77.98,21.37) v7(77.98,20.94) v7(77.98,20.53) v7(77.93,7.91) v7(77.93,7.5) v7(77.93,7.07) v7(77.93,6.64) v7(78.16,63.08) v7(78.16,62.65) v7(78.16,62.21) v7(78.16,61.81) v7(78.18,53.86) v7(78.18,53.43) v7(78.18,51.11) v7(78.18,50.68) v7(78.16,19.92) v7(78.16,19.52) v7(78.16,19.09) v7(78.23,40.22) v7(78.23,39.81) v7(78.23,39.38) v7(78.23,38.95) v7(78.28,37.04) v7(78.28,36.64) v7(78.28,36.2) v7(78.28,35.77) v7(78.23,5.75) v7(78.23,5.32) v7(78.23,4.89) v7(78.23,4.48) v7(78.39,96.07) v7(78.39,95.64) v7(78.39,95.21) v7(78.39,94.8) v7(78.36,91.55) v7(78.36,91.12) v7(78.36,90.69) v7(78.36,90.28) v7(78.33,68.92) v7(78.33,68.51) v7(78.33,68.08) v7(78.33,67.65) v7(78.36,66.63) v7(78.36,66.23) v7(78.36,65.8) v7(78.36,65.36) v7(78.36,59.83) v7(78.36,59.42) v7(78.36,58.99) v7(78.36,58.56) v7(78.31,34.33) v7(78.31,33.89) v7(78.31,33.46) v7(78.31,33.06) v7(78.33,7.91) v7(78.33,7.48) v7(78.33,7.05) v7(78.33,6.64) v7(78.44,82.08) v7(78.44,81.67) v7(78.44,81.24) v7(78.44,80.81) v7(78.41,80.25) v7(78.41,79.84) v7(78.41,79.41) v7(78.41,78.98) v7(78.41,21.8) v7(78.41,21.4) v7(78.41,20.96) v7(78.41,20.53) v7(78.56,99.04) v7(78.56,98.61) v7(78.56,98.18) v7(78.56,97.77) v7(78.59,63.08) v7(78.59,62.67) v7(78.59,62.24) v7(78.59,61.81) v7(78.51,51.6) v7(78.59,51.09) v7(78.59,50.66) v7(78.56,19.92) v7(78.56,19.49) v7(78.56,19.06) v7(78.59,2.83) v7(78.59,2.4) v7(78.59,1.97) v7(78.59,1.56) v7(78.61,53.88) v7(78.61,53.45) v7(78.61,52.97) v7(78.61,52.54) v7(78.61,50.25) v7(78.61,49.82) v7(78.66,5.75) v7(78.66,5.34) v7(78.66,4.91) v7(78.66,4.48) v7(78.79,91.55) v7(78.79,91.14) v7(78.79,90.71) v7(78.79,90.28) v7(78.74,68.92) v7(78.74,68.49) v7(78.74,68.06) v7(78.74,67.65) v7(78.77,66.63) v7(78.77,66.2) v7(78.77,65.77) v7(78.77,65.36) v7(78.74,34.33) v7(78.74,33.92) v7(78.74,33.49) v7(78.74,33.06) v7(78.77,7.91) v7(78.77,7.5) v7(78.77,7.07) v7(78.77,6.64) v7(78.82,96.07) v7(78.82,95.67) v7(78.82,95.23) v7(78.82,94.8) v7(78.84,82.08) v7(78.84,81.65) v7(78.84,81.21) v7(78.84,80.81) v7(78.82,80.25) v7(78.82,79.82) v7(78.82,79.38) v7(78.82,78.98) v7(78.82,21.8) v7(78.82,21.37) v7(78.82,20.94) v7(78.82,20.53) v7(78.99,99.04) v7(78.99,98.64) v7(78.99,98.21) v7(78.99,97.77) v7(78.92,52) v7(78.92,51.57) v7(78.99,19.92) v7(78.99,19.52) v7(78.99,19.09) v7(79.05,103.18) v7(79.05,102.75) v7(79.05,102.32) v7(79.05,101.91) v7(79.04,53.44) v7(79.02,52.94) v7(79.02,52.51) v7(79.02,51.11) v7(79.02,50.68) v7(79.02,50.23) v7(79.02,49.79) v7(79.07,5.75) v7(79.07,5.32) v7(79.07,4.89) v7(79.07,4.48) v7(79.02,2.83) v7(79.02,2.42) v7(79.02,1.99) v7(79.02,1.56) v7(79.17,68.92) v7(79.17,68.51) v7(79.17,68.08) v7(79.17,67.65) v7(79.2,66.63) v7(79.2,66.23) v7(79.2,65.8) v7(79.2,65.36) v7(79.27,82.08) v7(79.27,81.67) v7(79.27,81.24) v7(79.27,80.81) v7(79.25,80.25) v7(79.25,79.84) v7(79.25,79.41) v7(79.25,78.98) v7(79.25,21.8) v7(79.25,21.4) v7(79.25,20.96) v7(79.25,20.53) v7(79.4,99.04) v7(79.4,98.61) v7(79.4,98.18) v7(79.4,97.77) v7(79.38,90.81) v7(79.38,90.38) v7(79.38,89.95) v7(79.38,89.54) v7(79.4,10.09) v7(79.4,9.66) v7(79.4,9.23) v7(79.4,8.82) v7(79.48,103.18) v7(79.48,102.78) v7(79.48,102.35) v7(79.48,101.91) v7(79.5,77.38) v7(79.5,76.95) v7(79.5,76.51) v7(79.5,76.11) v7(79.45,53.44) v7(79.45,52.97) v7(79.45,52.54) v7(79.45,50.25) v7(79.45,49.82) v7(79.5,5.75) v7(79.5,5.34) v7(79.5,4.91) v7(79.5,4.48) v7(79.43,2.83) v7(79.43,1.56) v7(79.66,23.05) v7(79.66,22.64) v7(79.66,22.21) v7(79.68,20.2) v7(79.68,19.77) v7(79.68,19.34) v7(79.68,18.93) v7(79.73,7.93) v7(79.73,7.5) v7(79.73,7.07) v7(79.73,6.66) v7(79.88,103.18) v7(79.88,102.75) v7(79.88,102.32) v7(79.88,101.91) v7(79.83,99.04) v7(79.83,98.64) v7(79.83,98.21) v7(79.83,97.77) v7(79.81,90.81) v7(79.81,90.41) v7(79.81,89.98) v7(79.81,89.54) v7(79.83,65.47) v7(79.83,65.03) v7(79.83,64.6) v7(79.83,64.2) v7(79.83,10.09) v7(79.83,9.69) v7(79.83,9.26) v7(79.83,8.82) v7(79.86,2.83) v7(79.86,1.56) v7(79.93,77.38) v7(79.93,76.97) v7(79.93,76.54) v7(79.93,76.11) v7(80.06,23.05) v7(80.06,22.62) v7(80.06,22.18) v7(80.11,20.2) v7(80.11,19.8) v7(80.11,19.36) v7(80.11,18.93) v7(80.16,7.93) v7(80.16,7.53) v7(80.16,7.1) v7(80.16,6.66) v7(80.24,68.62) v7(80.24,68.18) v7(80.24,67.75) v7(80.24,67.35) v7(80.26,65.47) v7(80.26,65.06) v7(80.26,64.63) v7(80.26,64.2) v7(80.24,10.09) v7(80.24,9.66) v7(80.24,9.23) v7(80.24,8.82) v7(80.32,103.18) v7(80.32,102.78) v7(80.32,102.35) v7(80.32,101.91) v7(80.49,23.05) v7(80.49,22.64) v7(80.49,22.21) v7(80.52,20.2) v7(80.52,19.77) v7(80.52,19.34) v7(80.52,18.93) v7(80.57,7.93) v7(80.57,7.5) v7(80.57,7.07) v7(80.57,6.66) v7(80.67,68.62) v7(80.67,68.21) v7(80.67,67.78) v7(80.67,67.35) v7(80.67,10.09) v7(80.67,9.69) v7(80.67,9.26) v7(80.67,8.82) v7(80.77,5.8) v7(80.77,5.37) v7(80.77,4.94) v7(80.77,4.53) v7(80.93,75.83) v7(80.93,75.4) v7(80.93,74.97) v7(80.93,74.56) v7(81,60.61) v7(81,60.18) v7(81,59.75) v7(81,59.34) v7(80.95,20.2) v7(80.95,19.8) v7(80.95,19.36) v7(80.95,18.93) v7(81,7.93) v7(81,7.53) v7(81,7.1) v7(81,6.66) v7(81.08,86.27) v7(81.08,85.84) v7(81.08,85.4) v7(81.08,85) v7(81.05,82.97) v7(81.05,82.53) v7(81.05,82.1) v7(81.05,81.7) v7(81.1,62.98) v7(81.1,62.54) v7(81.1,62.11) v7(81.1,61.71) v7(81.2,5.8) v7(81.2,5.39) v7(81.2,4.96) v7(81.2,4.53) v7(81.23,80.35) v7(81.23,79.92) v7(81.23,79.49) v7(81.23,79.08) v7(81.36,75.83) v7(81.36,75.42) v7(81.36,74.99) v7(81.36,74.56) v7(81.48,82.97) v7(81.48,82.56) v7(81.48,82.13) v7(81.48,81.7) v7(81.43,60.61) v7(81.43,60.21) v7(81.43,59.78) v7(81.43,59.34) v7(81.51,86.27) v7(81.51,85.86) v7(81.51,85.43) v7(81.51,85) v7(81.53,62.98) v7(81.53,62.57) v7(81.53,62.14) v7(81.53,61.71) v7(81.66,80.35) v7(81.66,79.94) v7(81.66,79.51) v7(81.66,79.08) v7(81.61,5.8) v7(81.61,5.37) v7(81.61,4.94) v7(81.61,4.53) v7(81.76,75.83) v7(81.76,75.4) v7(81.76,74.97) v7(81.76,74.56) v7(81.79,8.82) v7(81.79,8.39) v7(81.79,7.96) v7(81.79,7.55) v7(81.89,82.97) v7(81.89,82.53) v7(81.89,82.1) v7(81.89,81.7) v7(81.86,11.92) v7(81.86,11.49) v7(81.86,11.06) v7(81.86,10.65) v7(81.92,86.27) v7(81.92,85.84) v7(81.92,85.4) v7(81.92,85) v7(81.97,30.74) v7(81.97,30.34) v7(81.97,29.91) v7(82.07,80.35) v7(82.07,79.92) v7(82.07,79.49) v7(82.07,79.08) v7(82.04,5.39) v7(82.04,4.96) v7(82.04,4.53) v7(82.2,75.83) v7(82.2,75.42) v7(82.2,74.99) v7(82.2,74.56) v7(82.2,70.06) v7(82.2,69.63) v7(82.2,69.2) v7(82.2,68.79) v7(82.14,29.07) v7(82.14,28.66) v7(82.14,28.23) v7(82.14,27.8) v7(82.3,11.92) v7(82.3,11.52) v7(82.3,11.08) v7(82.3,10.65) v7(82.22,8.82) v7(82.22,8.42) v7(82.22,7.99) v7(82.22,7.55) v7(82.35,86.27) v7(82.35,85.86) v7(82.35,85.43) v7(82.35,85) v7(82.32,82.97) v7(82.32,82.56) v7(82.32,82.13) v7(82.32,81.7) v7(82.35,62.77) v7(82.35,62.34) v7(82.35,61.91) v7(82.35,61.5) v7(82.37,30.74) v7(82.37,30.31) v7(82.37,29.88) v7(82.32,26.37) v7(82.32,25.97) v7(82.32,25.54) v7(82.4,24.57) v7(82.4,24.17) v7(82.4,23.73) v7(82.37,17.92) v7(82.37,17.51) v7(82.37,17.08) v7(82.5,80.35) v7(82.5,79.94) v7(82.5,79.51) v7(82.5,79.08) v7(82.47,68.03) v7(82.47,67.6) v7(82.47,67.17) v7(82.47,66.76) v7(82.42,23.15) v7(82.42,22.74) v7(82.42,22.31) v7(82.42,21.6) v7(82.42,21.19) v7(82.42,20.76) v7(82.42,19.85) v7(82.42,19.44) v7(82.42,19.01) v7(82.63,70.06) v7(82.63,69.66) v7(82.63,69.22) v7(82.63,68.79) v7(82.7,29.27) v7(82.7,28.86) v7(82.7,28.43) v7(82.7,28) v7(82.7,11.92) v7(82.7,11.49) v7(82.7,11.06) v7(82.7,10.65) v7(82.63,8.82) v7(82.63,8.39) v7(82.63,7.96) v7(82.63,7.55) v7(82.78,62.77) v7(82.78,62.37) v7(82.78,61.93) v7(82.78,61.5) v7(82.78,56.63) v7(82.78,56.19) v7(82.78,55.76) v7(82.78,55.36) v7(82.8,30.74) v7(82.8,30.34) v7(82.8,29.91) v7(82.73,26.37) v7(82.73,25.94) v7(82.73,25.51) v7(82.8,24.57) v7(82.8,24.14) v7(82.8,23.71) v7(82.78,17.92) v7(82.78,17.48) v7(82.78,17.05) v7(82.88,44.26) v7(82.88,43.85) v7(82.88,43.42) v7(82.88,42.99) v7(82.88,41.95) v7(82.88,41.54) v7(82.88,41.11) v7(82.88,40.68) v7(82.88,38.59) v7(82.88,38.19) v7(82.88,37.75) v7(82.88,37.32) v7(82.88,33.72) v7(82.88,33.31) v7(82.88,32.88) v7(82.88,32.45) v7(82.83,23.15) v7(82.83,22.72) v7(82.83,22.29) v7(82.83,21.6) v7(82.83,21.17) v7(82.83,20.74) v7(82.83,19.85) v7(82.83,19.42) v7(82.83,18.98) v7(82.91,68.03) v7(82.91,67.62) v7(82.91,67.19) v7(82.91,66.76) v7(83.06,8.82) v7(83.06,8.42) v7(83.06,7.99) v7(83.06,7.55) v7(83.16,26.37) v7(83.16,25.97) v7(83.16,25.54) v7(83.13,11.92) v7(83.13,11.52) v7(83.13,11.08) v7(83.13,10.65) v7(83.21,56.63) v7(83.21,56.22) v7(83.21,55.79) v7(83.21,55.36) v7(83.24,48.12) v7(83.24,47.69) v7(83.24,24.57) v7(83.24,24.17) v7(83.24,23.73) v7(83.26,23.15) v7(83.26,22.74) v7(83.26,22.31) v7(83.26,21.6) v7(83.26,21.19) v7(83.26,20.76) v7(83.26,19.85) v7(83.26,19.44) v7(83.26,19.01) v7(83.21,17.92) v7(83.21,17.51) v7(83.21,17.08) v7(83.49,27.49) v7(83.49,27.09) v7(83.49,26.65) v7(83.49,26.22) v7(83.59,76.18) v7(83.59,75.75) v7(83.59,75.32) v7(83.59,74.91) v7(83.59,44.41) v7(83.59,44) v7(83.59,43.57) v7(83.59,43.14) v7(83.54,42.22) v7(83.54,41.82) v7(83.54,41.39) v7(83.54,40.95) v7(83.57,39.91) v7(83.57,39.51) v7(83.57,39.07) v7(83.57,38.64) v7(83.54,37.75) v7(83.54,37.35) v7(83.54,36.92) v7(83.54,36.48) v7(83.57,35.42) v7(83.57,35.01) v7(83.57,34.58) v7(83.57,34.15) v7(83.57,33.44) v7(83.57,33.03) v7(83.57,32.6) v7(83.57,32.17) v7(83.57,31.4) v7(83.57,31) v7(83.57,30.57) v7(83.57,30.13) v7(83.57,29.32) v7(83.57,28.91) v7(83.57,28.48) v7(83.57,28.05) v7(83.69,95.01) v7(83.69,94.57) v7(83.69,94.14) v7(83.69,93.74) v7(83.62,66.94) v7(83.62,66.51) v7(83.62,66.08) v7(83.62,65.67) v7(83.64,48.09) v7(83.64,47.66) v7(84.02,76.18) v7(84.02,75.78) v7(84.02,75.35) v7(84.02,74.91) v7(84.05,66.94) v7(84.05,66.53) v7(84.05,66.1) v7(84.05,65.67) v7(84.07,48.12) v7(84.07,47.69) v7(84.13,95.01) v7(84.13,94.6) v7(84.13,94.17) v7(84.13,93.74) v7(84.4,39.46) v7(84.4,39.05) v7(84.4,38.62) v7(84.4,38.19) v7(84.43,76.18) v7(84.43,75.75) v7(84.43,75.32) v7(84.43,74.91) v7(84.46,36.59) v7(84.46,36.18) v7(84.46,35.75) v7(84.46,35.32) v7(84.48,32.75) v7(84.48,32.34) v7(84.48,31.91) v7(84.48,31.48) v7(84.48,29.19) v7(84.48,28.79) v7(84.48,28.36) v7(84.48,27.92) v7(84.58,78.55) v7(84.58,78.11) v7(84.58,77.68) v7(84.58,77.28) v7(84.63,98.18) v7(84.63,97.75) v7(84.63,97.32) v7(84.63,96.91) v7(84.66,34.86) v7(84.66,34.45) v7(84.66,34.02) v7(84.66,33.59) v7(84.68,31.07) v7(84.68,30.67) v7(84.68,30.24) v7(84.68,29.8) v7(84.66,13.93) v7(84.66,13.5) v7(84.66,13.07) v7(84.66,12.66) v7(84.63,12.07) v7(84.63,11.64) v7(84.63,11.21) v7(84.63,10.8) v7(84.68,8.7) v7(84.68,8.26) v7(84.68,7.83) v7(84.68,7.43) v7(84.71,80.5) v7(84.71,80.07) v7(84.71,79.64) v7(84.71,79.23) v7(84.74,27.54) v7(84.74,27.14) v7(84.74,26.71) v7(84.74,26.27) v7(84.89,86.04) v7(84.89,85.61) v7(84.89,85.18) v7(84.89,84.77) v7(84.86,76.18) v7(84.86,75.78) v7(84.86,75.35) v7(84.86,74.91) v7(84.89,50.63) v7(84.89,50.23) v7(84.89,49.79) v7(84.89,49.39) v7(84.94,83.8) v7(84.94,83.37) v7(84.94,82.94) v7(84.94,82.53) v7(85.07,98.18) v7(85.07,97.77) v7(85.07,97.34) v7(85.07,96.91) v7(85.01,78.55) v7(85.01,78.14) v7(85.01,77.71) v7(85.01,77.28) v7(85.09,13.93) v7(85.09,13.52) v7(85.09,13.09) v7(85.09,12.66) v7(85.07,12.07) v7(85.07,11.67) v7(85.07,11.24) v7(85.07,10.8) v7(85.12,102.98) v7(85.12,102.55) v7(85.12,102.12) v7(85.12,101.71) v7(85.14,80.5) v7(85.14,80.1) v7(85.14,79.66) v7(85.14,79.23) v7(85.12,46.67) v7(85.12,46.26) v7(85.12,45.83) v7(85.12,8.7) v7(85.12,8.29) v7(85.12,7.86) v7(85.12,7.43) v7(85.24,45.4) v7(85.32,86.04) v7(85.32,85.63) v7(85.32,85.2) v7(85.32,84.77) v7(85.37,83.8) v7(85.37,83.4) v7(85.37,82.97) v7(85.37,82.53) v7(85.32,50.66) v7(85.32,50.25) v7(85.32,49.82) v7(85.32,49.39) v7(85.42,78.55) v7(85.42,78.11) v7(85.42,77.68) v7(85.42,77.28) v7(85.42,64.2) v7(85.42,63.76) v7(85.42,63.33) v7(85.42,62.93) v7(85.45,62.06) v7(85.45,61.63) v7(85.45,61.2) v7(85.45,60.79) v7(85.47,43.77) v7(85.47,43.34) v7(85.47,42.91) v7(85.47,42.5) v7(85.5,41.64) v7(85.5,41.21) v7(85.5,40.78) v7(85.5,40.37) v7(85.5,13.93) v7(85.5,13.5) v7(85.5,13.07) v7(85.5,12.66) v7(85.47,12.07) v7(85.47,11.64) v7(85.47,11.21) v7(85.47,10.8) v7(85.55,102.98) v7(85.55,102.57) v7(85.55,102.14) v7(85.55,101.71) v7(85.55,80.5) v7(85.55,80.07) v7(85.55,79.64) v7(85.55,79.23) v7(85.52,30.64) v7(85.52,30.24) v7(85.52,29.8) v7(85.52,29.37) v7(85.52,8.7) v7(85.52,8.26) v7(85.52,7.83) v7(85.52,7.43) v7(85.65,99.73) v7(85.65,99.3) v7(85.65,98.87) v7(85.65,98.46) v7(85.65,66.81) v7(85.65,66.38) v7(85.65,65.95) v7(85.65,65.54) v7(85.65,28.56) v7(85.65,28.15) v7(85.65,27.72) v7(85.65,27.29) v7(85.73,86.04) v7(85.73,85.61) v7(85.73,85.18) v7(85.73,84.77) v7(85.78,83.8) v7(85.78,83.37) v7(85.78,82.94) v7(85.78,82.53) v7(85.75,15.96) v7(85.75,15.53) v7(85.75,15.1) v7(85.75,14.69) v7(85.85,78.55) v7(85.85,78.14) v7(85.85,77.71) v7(85.85,77.28) v7(85.83,73.52) v7(85.83,73.09) v7(85.83,72.65) v7(85.83,72.25) v7(85.85,64.2) v7(85.85,63.79) v7(85.85,63.36) v7(85.85,62.93) v7(85.88,62.06) v7(85.88,61.66) v7(85.88,61.22) v7(85.88,60.79) v7(85.9,46.69) v7(85.9,46.29) v7(85.9,45.86) v7(85.9,45.42) v7(85.9,43.77) v7(85.9,43.37) v7(85.9,42.94) v7(85.9,42.5) v7(85.83,35.42) v7(85.83,34.99) v7(85.83,34.55) v7(85.83,34.15) v7(85.88,33.64) v7(85.88,33.21) v7(85.88,32.78) v7(85.88,32.37) v7(85.9,26.43) v7(85.9,25.99) v7(85.9,25.56) v7(85.85,24.37) v7(85.85,23.94) v7(85.85,23.5) v7(85.85,23.1) v7(85.85,20.1) v7(85.85,19.67) v7(85.85,19.24) v7(85.85,18.83) v7(85.85,18.48) v7(85.85,18.02) v7(85.83,16.6) v7(85.9,12.07) v7(85.9,11.67) v7(85.9,11.24) v7(85.9,10.8) v7(85.98,80.5) v7(85.98,80.1) v7(85.98,79.66) v7(85.98,79.23) v7(85.93,41.64) v7(85.93,41.23) v7(85.93,40.8) v7(85.93,40.37) v7(86.01,30.29) v7(86.01,29.88) v7(86.01,29.45) v7(86.01,29.02) v7(85.93,13.93) v7(85.93,13.52) v7(85.93,13.09) v7(85.93,12.66) v7(85.95,8.7) v7(85.95,8.29) v7(85.95,7.86) v7(85.95,7.43) v7(86.08,99.73) v7(86.08,99.32) v7(86.08,98.89) v7(86.08,98.46) v7(86.08,66.81) v7(86.08,66.41) v7(86.08,65.97) v7(86.08,65.54) v7(86.08,28.31) v7(86.08,27.9) v7(86.08,27.47) v7(86.08,27.04) v7(86.16,86.04) v7(86.16,85.63) v7(86.16,85.2) v7(86.16,84.77) v7(86.18,15.96) v7(86.18,15.55) v7(86.18,15.12) v7(86.18,14.69) v7(86.21,83.8) v7(86.21,83.4) v7(86.21,82.97) v7(86.21,82.53) v7(86.26,73.52) v7(86.26,73.11) v7(86.26,72.68) v7(86.26,72.25) v7(86.26,64.2) v7(86.26,63.76) v7(86.26,63.33) v7(86.26,62.93) v7(86.26,35.42) v7(86.26,35.01) v7(86.26,34.58) v7(86.26,34.15) v7(86.28,24.37) v7(86.28,23.96) v7(86.28,23.53) v7(86.28,23.1) v7(86.28,20.1) v7(86.28,19.69) v7(86.28,19.26) v7(86.28,18.83) v7(86.28,18.48) v7(86.28,18.04) v7(86.26,16.6) v7(86.31,33.64) v7(86.31,33.23) v7(86.31,32.8) v7(86.31,32.37) v7(86.34,26.43) v7(86.34,26.02) v7(86.34,25.59) v7(86.49,66.81) v7(86.49,66.38) v7(86.49,65.95) v7(86.49,65.54) v7(86.59,15.96) v7(86.59,15.53) v7(86.59,15.1) v7(86.59,14.69) v7(86.67,73.52) v7(86.67,73.09) v7(86.67,72.65) v7(86.67,72.25) v7(86.69,64.2) v7(86.69,63.79) v7(86.69,63.36) v7(86.69,62.93) v7(86.67,34.99) v7(86.67,34.55) v7(86.67,34.15) v7(86.69,24.37) v7(86.69,20.1) v7(86.69,19.67) v7(86.69,19.24) v7(86.69,18.83) v7(86.69,18.48) v7(86.67,17.05) v7(86.67,16.6) v7(86.77,101.61) v7(86.77,101.18) v7(86.77,100.75) v7(86.77,100.34) v7(86.72,83.68) v7(86.72,83.25) v7(86.72,82.81) v7(86.72,82.41) v7(86.77,58) v7(86.77,57.57) v7(86.77,57.13) v7(86.77,56.73) v7(86.72,33.64) v7(86.72,33.21) v7(86.72,32.78) v7(86.72,32.37) v7(86.74,26.43) v7(86.74,25.99) v7(86.74,25.56) v7(86.89,9.38) v7(86.89,8.95) v7(86.89,8.52) v7(86.89,8.11) v7(86.92,66.81) v7(86.92,66.41) v7(86.92,65.97) v7(86.92,65.54) v7(86.92,11.31) v7(86.92,10.88) v7(86.92,10.45) v7(86.92,10.04) v7(87.1,73.52) v7(87.1,73.11) v7(87.1,72.68) v7(87.1,72.25) v7(87.1,50.38) v7(87.1,49.95) v7(87.1,49.51) v7(87.1,49.11) v7(87.1,48.09) v7(87.1,47.66) v7(87.1,47.23) v7(87.1,46.82) v7(87.1,35.01) v7(87.1,34.58) v7(87.1,34.15) v7(87.1,17.08) v7(87.1,16.6) v7(87.02,15.96) v7(87.02,15.55) v7(87.02,15.12) v7(87.02,14.69) v7(87.2,101.61) v7(87.2,101.2) v7(87.2,100.77) v7(87.2,100.34) v7(87.15,83.68) v7(87.15,83.27) v7(87.15,82.84) v7(87.15,82.41) v7(87.2,58) v7(87.2,57.59) v7(87.2,57.16) v7(87.2,56.73) v7(87.17,45.91) v7(87.17,45.48) v7(87.17,45.04) v7(87.17,44.64) v7(87.12,43.7) v7(87.12,43.27) v7(87.12,42.83) v7(87.12,42.43) v7(87.15,41.54) v7(87.15,41.11) v7(87.15,40.68) v7(87.15,40.27) v7(87.17,39.48) v7(87.17,39.05) v7(87.17,38.62) v7(87.17,38.21) v7(87.15,33.64) v7(87.15,33.23) v7(87.15,32.8) v7(87.15,32.37) v7(87.17,26.43) v7(87.17,26.02) v7(87.17,25.59) v7(87.17,25.16) v7(87.12,24.37) v7(87.12,20.1) v7(87.12,19.69) v7(87.12,19.26) v7(87.12,18.83) v7(87.12,18.48) v7(87.3,94.73) v7(87.3,94.29) v7(87.3,93.86) v7(87.3,93.46) v7(87.35,86.17) v7(87.35,85.73) v7(87.35,85.3) v7(87.35,84.9) v7(87.35,11.31) v7(87.35,10.91) v7(87.35,10.47) v7(87.35,10.04) v7(87.33,9.38) v7(87.33,8.98) v7(87.33,8.54) v7(87.33,8.11) v7(87.53,50.38) v7(87.53,49.97) v7(87.53,49.54) v7(87.53,49.11) v7(87.53,48.09) v7(87.53,47.69) v7(87.53,47.25) v7(87.53,46.82) v7(87.61,45.91) v7(87.61,45.5) v7(87.61,45.07) v7(87.61,44.64) v7(87.55,43.7) v7(87.55,43.29) v7(87.55,42.86) v7(87.55,42.43) v7(87.58,41.54) v7(87.58,41.13) v7(87.58,40.7) v7(87.58,40.27) v7(87.61,39.48) v7(87.61,39.07) v7(87.61,38.64) v7(87.61,38.21) v7(87.53,29.25) v7(87.53,28.84) v7(87.53,28.41) v7(87.53,27.98) v7(87.68,20.41) v7(87.68,20) v7(87.68,19.57) v7(87.68,19.14) v7(87.66,18.78) v7(87.66,18.42) v7(87.71,107.96) v7(87.71,107.53) v7(87.71,107.1) v7(87.71,106.69) v7(87.78,105.65) v7(87.78,105.22) v7(87.78,104.78) v7(87.78,104.38) v7(87.73,94.73) v7(87.73,94.32) v7(87.73,93.89) v7(87.73,93.46) v7(87.78,86.17) v7(87.78,85.76) v7(87.78,85.33) v7(87.78,84.9) v7(87.76,36.76) v7(87.76,36.33) v7(87.76,35.9) v7(87.76,35.49) v7(87.78,33.82) v7(87.78,33.41) v7(87.78,26.63) v7(87.78,26.22) v7(87.78,25.79) v7(87.78,25.36) v7(87.76,11.31) v7(87.76,10.88) v7(87.76,10.45) v7(87.76,10.04) v7(87.73,9.38) v7(87.73,8.95) v7(87.73,8.52) v7(87.73,8.11) v7(87.94,50.38) v7(87.94,49.95) v7(87.94,49.51) v7(87.94,49.11) v7(87.94,48.09) v7(87.94,47.66) v7(87.94,47.23) v7(87.94,46.82) v7(87.96,43.7) v7(87.96,43.27) v7(87.96,42.83) v7(87.96,42.43) v7(87.99,41.54) v7(87.99,41.11) v7(87.99,40.68) v7(87.99,40.27) v7(88.01,45.91) v7(88.01,45.48) v7(88.01,45.04) v7(88.01,44.64) v7(88.01,39.48) v7(88.01,39.05) v7(88.01,38.62) v7(88.01,38.21) v7(88.14,107.96) v7(88.14,107.55) v7(88.14,107.12) v7(88.14,106.69) v7(88.11,100.97) v7(88.11,100.54) v7(88.11,100.11) v7(88.11,99.7) v7(88.19,36.76) v7(88.19,36.36) v7(88.19,35.93) v7(88.19,35.49) v7(88.19,11.31) v7(88.19,10.91) v7(88.19,10.47) v7(88.19,10.04) v7(88.16,9.38) v7(88.16,8.98) v7(88.16,8.54) v7(88.16,8.11) v7(88.21,105.65) v7(88.21,105.24) v7(88.21,104.81) v7(88.21,104.38) v7(88.27,59.52) v7(88.27,59.09) v7(88.27,58.66) v7(88.27,58.25) v7(88.21,33.84) v7(88.21,33.41) v7(88.32,94.7) v7(88.32,94.27) v7(88.32,93.84) v7(88.32,93.43) v7(88.37,50.38) v7(88.37,49.97) v7(88.37,49.54) v7(88.37,49.11) v7(88.37,48.09) v7(88.37,47.69) v7(88.37,47.25) v7(88.37,46.82) v7(88.39,43.7) v7(88.39,43.29) v7(88.39,42.86) v7(88.39,42.43) v7(88.32,29.27) v7(88.32,28.86) v7(88.32,28.43) v7(88.32,28) v7(88.44,52.82) v7(88.44,52.38) v7(88.44,51.95) v7(88.44,51.55) v7(88.44,45.91) v7(88.44,45.5) v7(88.44,45.07) v7(88.44,44.64) v7(88.42,41.54) v7(88.42,41.13) v7(88.42,40.7) v7(88.42,40.27) v7(88.44,39.48) v7(88.44,39.07) v7(88.44,38.64) v7(88.44,38.21) v7(88.47,20.43) v7(88.47,20.02) v7(88.47,19.59) v7(88.47,19.16) v7(88.47,18.75) v7(88.44,18.37) v7(88.55,100.97) v7(88.55,100.57) v7(88.55,100.14) v7(88.55,99.7) v7(88.55,87.06) v7(88.55,86.62) v7(88.55,86.19) v7(88.55,85.79) v7(88.55,84.74) v7(88.55,84.31) v7(88.55,83.88) v7(88.55,83.47) v7(88.6,36.76) v7(88.6,36.33) v7(88.6,35.9) v7(88.6,35.49) v7(88.57,26.65) v7(88.57,26.25) v7(88.57,25.82) v7(88.57,25.38) v7(88.7,59.52) v7(88.7,59.12) v7(88.7,58.68) v7(88.7,58.25) v7(88.62,33.82) v7(88.62,33.41) v7(88.75,94.7) v7(88.75,94.29) v7(88.75,93.86) v7(88.75,93.43) v7(88.85,67.95) v7(88.85,67.52) v7(88.85,67.09) v7(88.85,66.68) v7(88.88,52.82) v7(88.88,52.41) v7(88.88,51.98) v7(88.88,51.55) v7(88.98,87.06) v7(88.98,86.65) v7(88.98,86.22) v7(88.98,85.79) v7(88.98,84.74) v7(88.98,84.34) v7(88.98,83.91) v7(88.98,83.47) v7(88.95,70.67) v7(88.95,70.24) v7(88.95,69.81) v7(88.95,69.4) v7(88.95,65.41) v7(88.95,64.98) v7(88.95,64.55) v7(88.95,64.14) v7(89.03,36.76) v7(89.03,36.36) v7(89.03,35.93) v7(89.03,35.49) v7(89.05,34.68) v7(89.05,34.27) v7(89.05,33.84) v7(89.05,33.41) v7(89.28,67.95) v7(89.28,67.55) v7(89.28,67.12) v7(89.28,66.68) v7(89.23,60.44) v7(89.23,60) v7(89.23,59.57) v7(89.23,59.17) v7(89.28,52.82) v7(89.28,52.38) v7(89.28,51.95) v7(89.28,51.55) v7(89.38,70.67) v7(89.38,70.27) v7(89.38,69.83) v7(89.38,69.4) v7(89.38,65.41) v7(89.38,65.01) v7(89.38,64.58) v7(89.38,64.14) v7(89.66,60.44) v7(89.66,60.03) v7(89.66,59.6) v7(89.66,59.17) v7(89.71,52.82) v7(89.71,52.41) v7(89.71,51.98) v7(89.71,51.55) v7(90.5,100.03) v7(90.5,99.6) v7(90.5,99.17) v7(90.5,98.76) v7(90.93,100.03) v7(90.93,99.63) v7(90.93,99.2) v7(90.93,98.76) v7(91.31,55.56) v7(91.31,55.13) v7(91.31,54.7) v7(91.31,54.29) v7(91.67,95.34) v7(91.67,94.9) v7(91.67,94.47) v7(91.67,94.07) v7(91.75,55.56) v7(91.75,55.15) v7(91.75,54.72) v7(91.75,54.29) v7(91.9,88.17) v7(91.9,87.74) v7(91.9,87.31) v7(91.9,86.9) v7(92.1,95.34) v7(92.1,94.93) v7(92.1,94.5) v7(92.1,94.07) v7(92.1,91.91) v7(92.1,91.48) v7(92.1,91.04) v7(92.1,90.64) v7(92.15,55.56) v7(92.15,55.13) v7(92.15,54.7) v7(92.15,54.29) v7(92.33,88.17) v7(92.33,87.77) v7(92.33,87.33) v7(92.33,86.9) v7(92.43,97.09) v7(92.43,96.66) v7(92.43,96.22) v7(92.43,95.82) v7(92.53,91.91) v7(92.53,91.5) v7(92.53,91.07) v7(92.53,90.64) v7(92.58,55.56) v7(92.58,55.15) v7(92.58,54.72) v7(92.58,54.29) v7(92.58,40.84) v7(92.58,39.64) v7(92.86,97.09) v7(92.86,96.68) v7(92.86,96.25) v7(92.86,95.82) v7(92.96,66.25) v7(92.96,65.82) v7(92.96,65.39) v7(92.96,64.98) v7(93.02,72.76) v7(93.02,72.32) v7(93.02,71.89) v7(93.02,71.49) v7(93.04,69.38) v7(93.04,68.95) v7(93.04,68.51) v7(93.04,68.11) v7(93.04,63.66) v7(93.04,63.23) v7(93.04,62.8) v7(93.04,62.39) v7(93.19,90.89) v7(93.19,90.46) v7(93.19,90.03) v7(93.19,89.62) v7(93.4,87.89) v7(93.4,87.46) v7(93.4,87.03) v7(93.4,86.62) v7(93.4,66.25) v7(93.4,65.85) v7(93.4,65.41) v7(93.4,64.98) v7(93.45,72.76) v7(93.45,72.35) v7(93.45,71.92) v7(93.45,71.49) v7(93.47,69.38) v7(93.47,68.97) v7(93.47,68.54) v7(93.47,68.11) v7(93.47,63.66) v7(93.47,63.26) v7(93.47,62.82) v7(93.47,62.39) v7(93.63,90.89) v7(93.63,90.48) v7(93.63,90.05) v7(93.63,89.62) v7(93.75,116.85) v7(93.83,87.89) v7(93.83,87.49) v7(93.83,87.06) v7(93.83,86.62) v7(94.08,116.86) v7(94.7,81.49) v7(94.7,81.2) v7(94.7,80.91) v7(95.24,58.27) v7(96.11,104.84) v7(96.11,104.4) v7(96.11,103.97) v7(96.11,103.57) v7(96.49,113.13) v7(96.55,104.84) v7(96.55,104.43) v7(96.55,104) v7(96.55,103.57) v7(98.22,96.56) v7(98.22,96.12) v7(98.22,95.69) v7(98.22,95.29) v7(98.48,93.38) v7(98.48,92.95) v7(98.48,92.52) v7(98.48,92.11) v7(98.65,96.56) v7(98.65,96.15) v7(98.65,95.72) v7(98.65,95.29) v7(98.91,93.38) v7(98.91,92.97) v7(98.91,92.54) v7(98.91,92.11) v8(4.2,72.46) v8(4.2,72.03) v8(4.2,71.6) v8(4.2,71.19) v8(4.63,72.46) v8(4.63,72.06) v8(4.63,71.62) v8(4.63,71.19) v8(4.79,112.06) v8(4.79,111.63) v8(4.79,111.2) v8(4.79,110.79) v8(4.87,117.09) v8(4.87,116.65) v8(4.87,116.22) v8(4.87,115.82) v8(4.83,114.55) v8(4.83,114.12) v8(4.83,113.69) v8(4.83,113.28) v8(4.85,109.38) v8(4.85,108.98) v8(5.03,72.46) v8(5.03,72.03) v8(5.03,71.6) v8(5.03,71.19) v8(5.3,117.09) v8(5.3,116.68) v8(5.3,116.25) v8(5.3,115.82) v8(5.26,114.55) v8(5.26,114.15) v8(5.26,113.72) v8(5.26,113.28) v8(5.22,112.06) v8(5.22,111.66) v8(5.22,111.22) v8(5.22,110.79) v8(5.26,109.41) v8(5.26,108.98) v8(5.21,76.9) v8(5.21,76.46) v8(5.21,76.03) v8(5.21,75.63) v8(5.47,72.46) v8(5.47,72.06) v8(5.47,71.62) v8(5.47,71.19) v8(5.67,114.55) v8(5.67,114.12) v8(5.67,113.69) v8(5.67,113.28) v8(5.63,112.06) v8(5.63,111.63) v8(5.63,111.2) v8(5.63,110.79) v8(5.69,109.41) v8(5.69,108.98) v8(5.64,76.9) v8(5.64,76.49) v8(5.64,76.06) v8(5.64,75.63) v8(5.71,117.09) v8(5.71,116.65) v8(5.71,116.22) v8(5.71,115.82) v8(6.1,114.55) v8(6.1,114.15) v8(6.1,113.72) v8(6.1,113.28) v8(6.06,112.06) v8(6.06,111.66) v8(6.06,111.22) v8(6.06,110.79) v8(6.09,109.38) v8(6.09,108.98) v8(6.1,82.93) v8(6.1,82.5) v8(6.1,82.07) v8(6.1,81.66) v8(6.05,76.9) v8(6.05,76.46) v8(6.05,76.03) v8(6.05,75.63) v8(6.14,117.09) v8(6.14,116.68) v8(6.14,116.25) v8(6.14,115.82) v8(6.18,84.79) v8(6.18,84.36) v8(6.18,83.93) v8(6.18,83.52) v8(6.48,76.9) v8(6.48,76.49) v8(6.48,76.06) v8(6.48,75.63) v8(6.53,82.93) v8(6.53,82.53) v8(6.53,82.09) v8(6.53,81.66) v8(6.61,84.79) v8(6.61,84.38) v8(6.61,83.95) v8(6.61,83.52) v8(6.71,116.65) v8(6.71,116.27) v8(6.71,115.86) v8(6.93,82.93) v8(6.93,82.5) v8(6.93,82.07) v8(6.93,81.66) v8(7.02,84.79) v8(7.02,84.36) v8(7.02,83.93) v8(7.02,83.52) v8(7.37,82.93) v8(7.37,82.53) v8(7.37,82.09) v8(7.37,81.66) v8(7.32,75.59) v8(7.32,75.16) v8(7.32,74.72) v8(7.32,74.32) v8(7.36,72.51) v8(7.36,72.07) v8(7.36,71.64) v8(7.36,71.24) v8(7.49,115.43) v8(7.49,115.05) v8(7.45,111.77) v8(7.45,111.34) v8(7.45,110.9) v8(7.45,110.5) v8(7.45,84.79) v8(7.45,84.38) v8(7.45,83.95) v8(7.45,83.52) v8(7.53,114.3) v8(7.53,113.87) v8(7.53,113.44) v8(7.53,113.03) v8(7.75,75.59) v8(7.75,75.18) v8(7.75,74.75) v8(7.75,74.32) v8(7.79,72.51) v8(7.79,72.1) v8(7.79,71.67) v8(7.79,71.24) v8(7.9,115.45) v8(7.88,111.77) v8(7.88,111.36) v8(7.88,110.93) v8(7.88,110.5) v8(7.83,108.73) v8(7.83,108.3) v8(7.83,107.86) v8(7.83,107.46) v8(7.93,115.02) v8(7.96,114.3) v8(7.96,113.89) v8(7.96,113.46) v8(7.96,113.03) v8(8,84.75) v8(8,84.32) v8(8,83.88) v8(8,83.48) v8(7.95,82.85) v8(7.95,82.42) v8(7.95,81.99) v8(7.95,81.58) v8(8.16,75.59) v8(8.16,75.16) v8(8.16,74.72) v8(8.16,74.32) v8(8.2,72.51) v8(8.2,72.07) v8(8.2,71.64) v8(8.2,71.24) v8(8.29,111.77) v8(8.29,111.34) v8(8.29,110.9) v8(8.29,110.5) v8(8.26,108.73) v8(8.26,108.32) v8(8.26,107.89) v8(8.26,107.46) v8(8.36,115.02) v8(8.37,114.3) v8(8.37,113.87) v8(8.37,113.44) v8(8.37,113.03) v8(8.39,82.85) v8(8.39,82.44) v8(8.39,82.01) v8(8.39,81.58) v8(8.43,84.75) v8(8.43,84.34) v8(8.43,83.91) v8(8.43,83.48) v8(8.59,75.59) v8(8.59,75.18) v8(8.59,74.75) v8(8.59,74.32) v8(8.67,108.73) v8(8.67,108.3) v8(8.67,107.86) v8(8.67,107.46) v8(8.63,72.51) v8(8.63,72.1) v8(8.63,71.67) v8(8.63,71.24) v8(8.8,114.3) v8(8.8,113.89) v8(8.8,113.46) v8(8.8,113.03) v8(8.72,111.77) v8(8.72,111.36) v8(8.72,110.93) v8(8.72,110.5) v8(8.79,82.85) v8(8.79,82.42) v8(8.79,81.99) v8(8.79,81.58) v8(8.83,84.75) v8(8.83,84.32) v8(8.83,83.88) v8(8.83,83.48) v8(9.1,108.73) v8(9.1,108.32) v8(9.1,107.89) v8(9.1,107.46) v8(9.27,84.75) v8(9.27,84.34) v8(9.27,83.91) v8(9.27,83.48) v8(9.22,82.85) v8(9.22,82.44) v8(9.22,82.01) v8(9.22,81.58) v8(9.77,82.93) v8(9.77,82.5) v8(9.77,82.07) v8(9.77,81.66) v8(9.81,84.79) v8(9.81,84.36) v8(9.81,83.93) v8(9.81,83.52) v8(10.2,82.93) v8(10.2,82.53) v8(10.2,82.09) v8(10.2,81.66) v8(10.24,84.79) v8(10.24,84.38) v8(10.24,83.95) v8(10.24,83.52) v8(10.32,75.54) v8(10.32,75.11) v8(10.32,74.68) v8(10.32,74.27) v8(10.41,116.7) v8(10.41,116.39) v8(10.41,116.06) v8(10.41,115.73) v8(10.47,115.12) v8(10.47,114.77) v8(10.47,114.41) v8(10.47,114.08) v8(10.65,84.79) v8(10.65,84.36) v8(10.65,83.93) v8(10.65,83.52) v8(10.61,82.93) v8(10.61,82.5) v8(10.61,82.07) v8(10.61,81.66) v8(10.75,75.54) v8(10.75,75.14) v8(10.75,74.71) v8(10.75,74.27) v8(10.97,116.7) v8(10.97,116.37) v8(10.97,116.04) v8(10.97,115.71) v8(10.95,115.12) v8(10.96,114.79) v8(10.96,114.38) v8(10.95,114.06) v8(11.08,84.79) v8(11.08,84.38) v8(11.08,83.95) v8(11.08,83.52) v8(11.04,82.93) v8(11.04,82.53) v8(11.04,82.09) v8(11.04,81.66) v8(11.16,75.54) v8(11.16,75.11) v8(11.16,74.68) v8(11.16,74.27) v8(11.54,84.79) v8(11.54,84.36) v8(11.54,83.93) v8(11.54,83.52) v8(11.59,75.54) v8(11.59,75.14) v8(11.59,74.71) v8(11.59,74.27) v8(11.67,82.89) v8(11.67,82.46) v8(11.67,82.03) v8(11.67,81.62) v8(11.97,84.79) v8(11.97,84.38) v8(11.97,83.95) v8(11.97,83.52) v8(12.1,82.89) v8(12.1,82.48) v8(12.1,82.05) v8(12.1,81.62) v8(12.38,84.79) v8(12.38,84.36) v8(12.38,83.93) v8(12.38,83.52) v8(12.51,82.89) v8(12.51,82.46) v8(12.51,82.03) v8(12.51,81.62) v8(12.81,84.79) v8(12.81,84.38) v8(12.81,83.95) v8(12.81,83.52) v8(12.94,82.89) v8(12.94,82.48) v8(12.94,82.05) v8(12.94,81.62) v8(12.98,75.59) v8(12.98,75.16) v8(12.98,74.72) v8(12.98,74.32) v8(13.26,101.11) v8(13.26,100.67) v8(13.26,100.24) v8(13.26,99.84) v8(13.41,75.59) v8(13.41,75.18) v8(13.41,74.75) v8(13.41,74.32) v8(13.69,101.11) v8(13.69,100.7) v8(13.69,100.27) v8(13.69,99.84) v8(13.7,79.72) v8(13.7,79.29) v8(13.7,78.86) v8(13.7,78.45) v8(13.82,75.59) v8(13.82,75.16) v8(13.82,74.72) v8(13.82,74.32) v8(14.1,101.11) v8(14.1,100.67) v8(14.1,100.24) v8(14.1,99.84) v8(14.13,79.72) v8(14.13,79.32) v8(14.13,78.89) v8(14.13,78.45) v8(14.25,75.59) v8(14.25,75.18) v8(14.25,74.75) v8(14.25,74.32) v8(14.53,101.11) v8(14.53,100.7) v8(14.53,100.27) v8(14.53,99.84) v8(14.53,79.72) v8(14.53,79.29) v8(14.53,78.86) v8(14.53,78.45) v8(14.97,79.72) v8(14.97,79.32) v8(14.97,78.89) v8(14.97,78.45) v8(14.96,75.71) v8(14.96,75.28) v8(14.96,74.85) v8(14.96,74.44) v8(15.22,89.31) v8(15.22,88.88) v8(15.22,88.44) v8(15.22,88.04) v8(15.39,75.71) v8(15.39,75.31) v8(15.39,74.88) v8(15.39,74.44) v8(15.65,89.31) v8(15.65,88.9) v8(15.65,88.47) v8(15.65,88.04) v8(15.68,79.77) v8(15.68,79.33) v8(15.68,78.9) v8(15.68,78.5) v8(15.8,75.71) v8(15.8,75.28) v8(15.8,74.85) v8(15.8,74.44) v8(15.98,94.8) v8(15.98,94.36) v8(15.98,93.93) v8(15.98,93.53) v8(15.93,92.98) v8(15.93,92.55) v8(15.93,92.12) v8(15.93,91.71) v8(16.05,89.31) v8(16.05,88.88) v8(16.05,88.44) v8(16.05,88.04) v8(16.11,79.77) v8(16.11,79.36) v8(16.11,78.93) v8(16.11,78.5) v8(16.23,75.71) v8(16.23,75.31) v8(16.23,74.88) v8(16.23,74.44) v8(16.36,92.98) v8(16.36,92.57) v8(16.36,92.14) v8(16.36,91.71) v8(16.41,94.8) v8(16.41,94.39) v8(16.41,93.96) v8(16.41,93.53) v8(16.49,89.31) v8(16.49,88.9) v8(16.49,88.47) v8(16.49,88.04) v8(16.52,79.77) v8(16.52,79.33) v8(16.52,78.9) v8(16.52,78.5) v8(16.77,92.98) v8(16.77,92.55) v8(16.77,92.12) v8(16.77,91.71) v8(16.81,94.8) v8(16.81,94.36) v8(16.81,93.93) v8(16.81,93.53) v8(16.86,76.01) v8(16.86,75.58) v8(16.86,75.15) v8(16.86,74.74) v8(16.95,79.77) v8(16.95,79.36) v8(16.95,78.93) v8(16.95,78.5) v8(17.2,92.98) v8(17.2,92.57) v8(17.2,92.14) v8(17.2,91.71) v8(17.25,94.8) v8(17.25,94.39) v8(17.25,93.96) v8(17.25,93.53) v8(17.29,76.01) v8(17.29,75.6) v8(17.29,75.17) v8(17.29,74.74) v8(17.7,76.01) v8(17.7,75.58) v8(17.7,75.15) v8(17.7,74.74) v8(17.75,94.8) v8(17.75,94.36) v8(17.75,93.93) v8(17.75,93.53) v8(17.71,93.02) v8(17.71,92.59) v8(17.71,92.16) v8(17.71,91.75) v8(18,83.48) v8(18,83.05) v8(18,82.62) v8(18,82.21) v8(17.96,81.37) v8(17.96,80.94) v8(17.96,80.51) v8(17.96,80.1) v8(18.04,85.89) v8(18.04,85.46) v8(18.04,85.02) v8(18.04,84.62) v8(18.18,94.8) v8(18.18,94.39) v8(18.18,93.96) v8(18.18,93.53) v8(18.14,93.02) v8(18.14,92.62) v8(18.14,92.18) v8(18.14,91.75) v8(18.13,76.01) v8(18.13,75.6) v8(18.13,75.17) v8(18.13,74.74) v8(18.39,81.37) v8(18.39,80.96) v8(18.39,80.53) v8(18.39,80.1) v8(18.48,85.89) v8(18.48,85.48) v8(18.48,85.05) v8(18.48,84.62) v8(18.43,83.48) v8(18.43,83.08) v8(18.43,82.64) v8(18.43,82.21) v8(18.59,94.8) v8(18.59,94.36) v8(18.59,93.93) v8(18.59,93.53) v8(18.54,93.02) v8(18.54,92.59) v8(18.54,92.16) v8(18.54,91.75) v8(18.7,3.41) v8(18.7,2.98) v8(18.7,2.55) v8(18.7,2.14) v8(18.8,81.37) v8(18.8,80.94) v8(18.8,80.51) v8(18.8,80.1) v8(18.88,85.89) v8(18.88,85.46) v8(18.88,85.02) v8(18.88,84.62) v8(18.84,83.48) v8(18.84,83.05) v8(18.84,82.62) v8(18.84,82.21) v8(18.98,93.02) v8(18.98,92.62) v8(18.98,92.18) v8(18.98,91.75) v8(19.02,94.8) v8(19.02,94.39) v8(19.02,93.96) v8(19.02,93.53) v8(19.01,78.88) v8(19.01,78.45) v8(19.01,78.02) v8(19.01,77.61) v8(19.13,3.41) v8(19.13,3.01) v8(19.13,2.58) v8(19.13,2.14) v8(19.27,83.48) v8(19.27,83.08) v8(19.27,82.64) v8(19.27,82.21) v8(19.23,81.37) v8(19.23,80.96) v8(19.23,80.53) v8(19.23,80.1) v8(19.31,85.89) v8(19.31,85.48) v8(19.31,85.05) v8(19.31,84.62) v8(19.45,78.88) v8(19.45,78.47) v8(19.45,78.04) v8(19.45,77.61) v8(19.53,3.41) v8(19.53,2.98) v8(19.53,2.55) v8(19.53,2.14) v8(19.9,85.93) v8(19.9,85.5) v8(19.9,85.07) v8(19.9,84.66) v8(19.82,83.44) v8(19.82,83.01) v8(19.82,82.58) v8(19.82,82.17) v8(19.85,78.88) v8(19.85,78.45) v8(19.85,78.02) v8(19.85,77.61) v8(19.94,81.2) v8(19.94,80.77) v8(19.94,80.34) v8(19.94,79.93) v8(19.97,3.41) v8(19.97,3.01) v8(19.97,2.58) v8(19.97,2.14) v8(20.25,83.44) v8(20.25,83.03) v8(20.25,82.6) v8(20.25,82.17) v8(20.28,78.88) v8(20.28,78.47) v8(20.28,78.04) v8(20.28,77.61) v8(20.37,102.18) v8(20.37,101.75) v8(20.37,101.32) v8(20.37,100.91) v8(20.33,85.93) v8(20.33,85.52) v8(20.33,85.09) v8(20.33,84.66) v8(20.38,81.2) v8(20.38,80.8) v8(20.38,80.36) v8(20.38,79.93) v8(20.66,83.44) v8(20.66,83.01) v8(20.66,82.58) v8(20.66,82.17) v8(20.8,102.18) v8(20.8,101.78) v8(20.8,101.35) v8(20.8,100.91) v8(20.74,85.93) v8(20.74,85.5) v8(20.74,85.07) v8(20.74,84.66) v8(20.78,81.2) v8(20.78,80.77) v8(20.78,80.34) v8(20.78,79.93) v8(21.08,89.52) v8(21.08,89.09) v8(21.08,88.66) v8(21.08,88.25) v8(21.09,83.44) v8(21.09,83.03) v8(21.09,82.6) v8(21.09,82.17) v8(21.2,102.18) v8(21.2,101.75) v8(21.2,101.32) v8(21.2,100.91) v8(21.17,85.93) v8(21.17,85.52) v8(21.17,85.09) v8(21.17,84.66) v8(21.21,81.2) v8(21.21,80.8) v8(21.21,80.36) v8(21.21,79.93) v8(21.52,89.52) v8(21.52,89.11) v8(21.52,88.68) v8(21.52,88.25) v8(21.57,3.41) v8(21.57,2.98) v8(21.57,2.55) v8(21.57,2.14) v8(21.64,102.18) v8(21.64,101.78) v8(21.64,101.35) v8(21.64,100.91) v8(21.89,94.25) v8(21.89,93.82) v8(21.89,93.38) v8(21.89,92.98) v8(21.92,91.75) v8(21.93,91.36) v8(21.93,90.98) v8(21.93,90.57) v8(21.92,89.52) v8(21.92,89.09) v8(21.92,88.66) v8(21.92,88.25) v8(22,3.41) v8(22,3.01) v8(22,2.58) v8(22,2.14) v8(22.23,49.13) v8(22.23,48.7) v8(22.23,47.36) v8(22.23,46.92) v8(22.23,46.49) v8(22.23,46.09) v8(22.32,94.25) v8(22.32,93.84) v8(22.32,93.41) v8(22.32,92.98) v8(22.35,91.75) v8(22.36,91.38) v8(22.36,91) v8(22.36,90.57) v8(22.35,89.52) v8(22.35,89.11) v8(22.35,88.68) v8(22.35,88.25) v8(22.4,29.42) v8(22.4,28.99) v8(22.4,28.56) v8(22.4,28.15) v8(22.4,3.41) v8(22.4,2.98) v8(22.4,2.55) v8(22.4,2.14) v8(22.48,34.12) v8(22.48,33.69) v8(22.48,20.13) v8(22.48,19.69) v8(22.48,19.26) v8(22.48,18.86) v8(22.48,18.2) v8(22.48,17.76) v8(22.48,17.33) v8(22.48,16.93) v8(22.48,16.11) v8(22.48,15.68) v8(22.48,15.25) v8(22.48,14.84) v8(22.48,14.06) v8(22.48,13.62) v8(22.48,13.19) v8(22.48,12.79) v8(22.53,26.17) v8(22.53,25.74) v8(22.53,25.31) v8(22.53,24.9) v8(22.53,24.04) v8(22.53,23.61) v8(22.53,23.17) v8(22.53,22.77) v8(22.53,22.03) v8(22.53,21.6) v8(22.53,21.17) v8(22.53,20.76) v8(22.63,49.11) v8(22.63,48.68) v8(22.66,47.36) v8(22.66,46.95) v8(22.66,46.52) v8(22.66,46.09) v8(22.72,94.25) v8(22.72,93.82) v8(22.72,93.38) v8(22.72,92.98) v8(22.77,91.76) v8(22.77,91.36) v8(22.77,90.98) v8(22.77,90.57) v8(22.89,34.1) v8(22.89,33.66) v8(22.84,29.42) v8(22.84,29.02) v8(22.84,28.58) v8(22.84,28.15) v8(22.84,3.41) v8(22.84,3.01) v8(22.84,2.58) v8(22.84,2.14) v8(22.96,26.17) v8(22.96,25.77) v8(22.96,25.33) v8(22.96,24.9) v8(22.96,24.04) v8(22.96,23.63) v8(22.96,23.2) v8(22.96,22.77) v8(22.96,22.03) v8(22.96,21.63) v8(22.96,21.19) v8(22.91,20.13) v8(22.91,19.72) v8(22.91,19.29) v8(22.91,18.86) v8(22.91,18.2) v8(22.91,17.79) v8(22.91,17.36) v8(22.91,16.93) v8(22.91,16.11) v8(22.91,15.71) v8(22.91,15.28) v8(22.91,14.84) v8(22.91,14.06) v8(22.91,13.65) v8(22.91,13.22) v8(22.91,12.79) v8(23.06,49.13) v8(23.06,48.7) v8(23.06,47.36) v8(23.06,46.92) v8(23.06,46.49) v8(23.06,46.09) v8(23.16,94.25) v8(23.16,93.84) v8(23.16,93.41) v8(23.16,92.98) v8(23.2,91.76) v8(23.2,91.38) v8(23.2,91) v8(23.2,90.57) v8(23.24,29.42) v8(23.24,28.99) v8(23.24,28.56) v8(23.24,28.15) v8(23.32,34.12) v8(23.32,33.69) v8(23.34,33.13) v8(23.34,32.7) v8(23.37,26.17) v8(23.37,25.74) v8(23.37,25.31) v8(23.37,24.9) v8(23.37,24.04) v8(23.37,23.61) v8(23.37,23.17) v8(23.37,22.77) v8(23.37,22.03) v8(23.37,21.6) v8(23.37,21.17) v8(23.37,20.76) v8(23.32,20.13) v8(23.32,19.69) v8(23.32,19.26) v8(23.32,18.86) v8(23.32,18.2) v8(23.32,17.76) v8(23.32,17.33) v8(23.32,16.93) v8(23.32,16.11) v8(23.32,15.68) v8(23.32,15.25) v8(23.32,14.84) v8(23.32,14.06) v8(23.32,13.62) v8(23.32,13.19) v8(23.32,12.79) v8(23.45,102.06) v8(23.45,101.63) v8(23.45,101.19) v8(23.45,100.79) v8(23.5,47.36) v8(23.5,46.95) v8(23.5,46.52) v8(23.5,46.09) v8(23.62,96.44) v8(23.62,96.01) v8(23.62,95.58) v8(23.62,95.17) v8(23.67,29.42) v8(23.67,29.02) v8(23.67,28.58) v8(23.67,28.15) v8(23.74,94.25) v8(23.74,93.82) v8(23.74,93.38) v8(23.74,92.98) v8(23.75,33.11) v8(23.75,32.67) v8(23.8,26.17) v8(23.8,25.77) v8(23.8,25.33) v8(23.8,24.9) v8(23.8,24.04) v8(23.8,23.63) v8(23.8,23.2) v8(23.8,22.77) v8(23.8,22.03) v8(23.8,21.63) v8(23.8,21.19) v8(23.8,20.76) v8(23.75,20.13) v8(23.75,19.72) v8(23.75,19.29) v8(23.75,18.86) v8(23.75,18.2) v8(23.75,17.79) v8(23.75,17.36) v8(23.75,16.93) v8(23.75,16.11) v8(23.75,15.71) v8(23.75,15.28) v8(23.75,14.84) v8(23.75,14.06) v8(23.75,13.65) v8(23.75,13.22) v8(23.75,12.79) v8(23.88,102.06) v8(23.88,101.65) v8(23.88,101.22) v8(23.88,100.79) v8(24,91.88) v8(24,91.45) v8(24,91.02) v8(24,90.61) v8(23.93,49.57) v8(23.93,49.13) v8(23.93,48.7) v8(23.93,48.3) v8(24.05,96.44) v8(24.05,96.04) v8(24.05,95.6) v8(24.05,95.17) v8(24.17,94.25) v8(24.17,93.84) v8(24.17,93.41) v8(24.17,92.98) v8(24.13,47.3) v8(24.13,46.87) v8(24.13,46.44) v8(24.13,46.03) v8(24.18,33.13) v8(24.18,32.7) v8(24.29,102.06) v8(24.29,101.63) v8(24.29,101.19) v8(24.29,100.79) v8(24.36,49.57) v8(24.36,49.16) v8(24.36,48.73) v8(24.36,48.3) v8(24.45,96.44) v8(24.45,96.01) v8(24.45,95.58) v8(24.45,95.17) v8(24.43,91.88) v8(24.43,91.48) v8(24.43,91.04) v8(24.43,90.61) v8(24.46,19.03) v8(24.46,18.6) v8(24.46,18.17) v8(24.46,17.76) v8(24.49,17.21) v8(24.49,16.77) v8(24.49,16.34) v8(24.49,15.94) v8(24.49,15.43) v8(24.49,15) v8(24.49,14.56) v8(24.49,14.16) v8(24.49,13.6) v8(24.49,13.17) v8(24.49,12.74) v8(24.49,12.33) v8(24.46,11.69) v8(24.46,11.26) v8(24.46,10.83) v8(24.46,10.42) v8(24.41,5.5) v8(24.41,5.06) v8(24.41,4.63) v8(24.41,4.23) v8(24.58,94.25) v8(24.58,93.82) v8(24.58,93.38) v8(24.58,92.98) v8(24.56,47.3) v8(24.56,46.9) v8(24.56,46.47) v8(24.56,46.03) v8(24.59,9.69) v8(24.59,9.26) v8(24.59,8.82) v8(24.59,8.42) v8(24.64,31.53) v8(24.64,31.1) v8(24.64,30.67) v8(24.64,30.26) v8(24.64,25.1) v8(24.64,24.67) v8(24.64,24.24) v8(24.64,23.83) v8(24.64,23.15) v8(24.64,22.72) v8(24.64,22.29) v8(24.64,21.88) v8(24.72,102.06) v8(24.72,101.65) v8(24.72,101.22) v8(24.72,100.79) v8(24.77,49.57) v8(24.77,49.13) v8(24.77,48.7) v8(24.77,48.3) v8(24.89,96.44) v8(24.89,96.04) v8(24.89,95.6) v8(24.89,95.17) v8(24.83,91.88) v8(24.83,91.45) v8(24.83,91.02) v8(24.83,90.61) v8(24.89,19.03) v8(24.89,18.63) v8(24.89,18.2) v8(24.89,17.76) v8(24.89,11.69) v8(24.89,11.29) v8(24.89,10.86) v8(24.89,10.42) v8(24.84,5.5) v8(24.84,5.09) v8(24.84,4.66) v8(24.84,4.23) v8(24.97,47.3) v8(24.97,46.87) v8(24.97,46.44) v8(24.97,46.03) v8(24.99,44.99) v8(24.99,44.56) v8(24.92,17.21) v8(24.92,16.8) v8(24.92,16.37) v8(24.92,15.94) v8(24.92,15.43) v8(24.92,15.02) v8(24.92,14.59) v8(24.92,14.16) v8(24.92,13.6) v8(24.92,13.19) v8(24.92,12.76) v8(24.92,12.33) v8(25.01,94.25) v8(25.01,93.84) v8(25.01,93.41) v8(25.01,92.98) v8(25.07,31.53) v8(25.07,31.12) v8(25.07,30.69) v8(25.07,30.26) v8(25.02,26.5) v8(25.02,26.07) v8(25.07,25.1) v8(25.07,24.7) v8(25.07,24.27) v8(25.07,23.83) v8(25.07,23.15) v8(25.07,22.74) v8(25.07,22.31) v8(25.07,21.88) v8(25.02,9.69) v8(25.02,9.28) v8(25.02,8.85) v8(25.02,8.42) v8(25.2,49.57) v8(25.2,49.16) v8(25.2,48.73) v8(25.2,48.3) v8(25.27,91.88) v8(25.27,91.48) v8(25.27,91.04) v8(25.27,90.61) v8(25.3,19.03) v8(25.3,18.6) v8(25.3,18.17) v8(25.3,17.76) v8(25.3,11.69) v8(25.3,11.26) v8(25.3,10.83) v8(25.3,10.42) v8(25.25,5.5) v8(25.25,5.06) v8(25.25,4.63) v8(25.25,4.23) v8(25.4,47.3) v8(25.4,46.9) v8(25.4,46.47) v8(25.4,46.03) v8(25.4,44.97) v8(25.4,44.54) v8(25.32,17.21) v8(25.32,16.77) v8(25.32,16.34) v8(25.32,15.94) v8(25.32,15.43) v8(25.32,15) v8(25.32,14.56) v8(25.32,14.16) v8(25.32,13.6) v8(25.32,13.17) v8(25.32,12.74) v8(25.32,12.33) v8(25.38,3.31) v8(25.38,2.88) v8(25.38,2.45) v8(25.38,2.04) v8(25.48,31.53) v8(25.48,31.1) v8(25.48,30.67) v8(25.48,30.26) v8(25.43,26.48) v8(25.43,26.04) v8(25.48,25.1) v8(25.48,24.67) v8(25.48,24.24) v8(25.48,23.83) v8(25.48,23.15) v8(25.48,22.72) v8(25.48,22.29) v8(25.48,21.88) v8(25.43,9.69) v8(25.43,9.26) v8(25.43,8.82) v8(25.43,8.42) v8(25.68,5.5) v8(25.68,5.09) v8(25.68,4.66) v8(25.68,4.23) v8(25.73,19.03) v8(25.73,18.63) v8(25.73,18.2) v8(25.73,17.76) v8(25.76,17.21) v8(25.76,16.8) v8(25.76,16.37) v8(25.76,15.94) v8(25.76,15.43) v8(25.76,15.02) v8(25.76,14.59) v8(25.76,14.16) v8(25.76,13.6) v8(25.76,13.19) v8(25.76,12.76) v8(25.76,12.33) v8(25.73,11.69) v8(25.73,11.29) v8(25.73,10.86) v8(25.83,44.99) v8(25.83,44.56) v8(25.86,26.5) v8(25.86,26.07) v8(25.86,9.69) v8(25.86,9.28) v8(25.86,8.85) v8(25.86,8.42) v8(25.81,3.31) v8(25.81,2.91) v8(25.81,2.47) v8(25.81,2.04) v8(25.98,94.59) v8(25.98,94.15) v8(25.98,93.72) v8(25.98,93.32) v8(25.91,31.53) v8(25.91,31.12) v8(25.91,30.69) v8(25.91,30.26) v8(25.91,25.1) v8(25.91,24.7) v8(25.91,24.27) v8(25.91,23.83) v8(25.91,23.15) v8(25.91,22.74) v8(25.91,22.31) v8(25.91,21.88) v8(26.11,102.27) v8(26.11,101.84) v8(26.11,101.4) v8(26.11,101) v8(26.11,99.74) v8(26.11,99.3) v8(26.11,98.87) v8(26.11,98.47) v8(26.15,97.03) v8(26.15,96.6) v8(26.15,96.17) v8(26.15,95.76) v8(26.21,3.31) v8(26.21,2.88) v8(26.21,2.45) v8(26.21,2.04) v8(26.41,94.59) v8(26.41,94.18) v8(26.41,93.75) v8(26.41,93.32) v8(26.54,102.27) v8(26.54,101.86) v8(26.54,101.43) v8(26.54,101) v8(26.54,99.74) v8(26.54,99.33) v8(26.54,98.9) v8(26.54,98.47) v8(26.58,97.03) v8(26.58,96.63) v8(26.58,96.2) v8(26.58,95.76) v8(26.59,23.1) v8(26.59,22.67) v8(26.59,22.23) v8(26.59,21.83) v8(26.59,17.18) v8(26.59,16.75) v8(26.59,16.32) v8(26.59,15.91) v8(26.54,9.61) v8(26.54,9.18) v8(26.54,8.75) v8(26.54,8.34) v8(26.65,25.03) v8(26.65,24.6) v8(26.65,24.17) v8(26.65,23.76) v8(26.65,21.19) v8(26.65,20.76) v8(26.65,20.33) v8(26.65,19.92) v8(26.67,19.21) v8(26.67,18.78) v8(26.67,18.35) v8(26.67,17.94) v8(26.62,11.69) v8(26.62,11.26) v8(26.62,10.83) v8(26.62,10.42) v8(26.65,3.31) v8(26.65,2.91) v8(26.65,2.47) v8(26.65,2.04) v8(26.82,94.59) v8(26.82,94.15) v8(26.82,93.72) v8(26.82,93.32) v8(26.85,27.75) v8(26.85,27.31) v8(26.85,26.88) v8(26.85,26.48) v8(26.95,102.27) v8(26.95,101.84) v8(26.95,101.4) v8(26.95,101) v8(26.95,99.74) v8(26.95,99.3) v8(26.95,98.87) v8(26.95,98.47) v8(26.99,97.03) v8(26.99,96.6) v8(26.99,96.17) v8(26.99,95.76) v8(26.98,9.61) v8(26.98,9.2) v8(26.98,8.77) v8(26.98,8.34) v8(27.08,25.03) v8(27.08,24.62) v8(27.08,24.19) v8(27.08,23.76) v8(27.03,23.1) v8(27.03,22.69) v8(27.03,22.26) v8(27.03,21.83) v8(27.08,21.19) v8(27.08,20.79) v8(27.08,20.36) v8(27.08,19.92) v8(27.1,19.21) v8(27.1,18.81) v8(27.1,18.37) v8(27.1,17.94) v8(27.03,17.18) v8(27.03,16.77) v8(27.03,16.34) v8(27.03,15.91) v8(27.05,11.69) v8(27.05,11.29) v8(27.05,10.86) v8(27.05,10.42) v8(27.25,94.59) v8(27.25,94.18) v8(27.25,93.75) v8(27.25,93.32) v8(27.28,27.75) v8(27.28,27.34) v8(27.28,26.91) v8(27.28,26.48) v8(27.38,102.27) v8(27.38,101.86) v8(27.38,101.43) v8(27.38,101) v8(27.38,99.74) v8(27.38,99.33) v8(27.38,98.9) v8(27.38,98.47) v8(27.38,9.61) v8(27.38,9.18) v8(27.38,8.75) v8(27.38,8.34) v8(27.42,97.03) v8(27.42,96.63) v8(27.42,96.2) v8(27.42,95.76) v8(27.48,25.03) v8(27.48,24.6) v8(27.48,24.17) v8(27.48,23.76) v8(27.43,23.1) v8(27.43,22.67) v8(27.43,22.23) v8(27.43,21.83) v8(27.48,21.19) v8(27.48,20.76) v8(27.48,20.33) v8(27.48,19.92) v8(27.43,17.18) v8(27.43,16.75) v8(27.43,16.32) v8(27.43,15.91) v8(27.46,11.69) v8(27.46,11.26) v8(27.46,10.83) v8(27.46,10.42) v8(27.53,49.34) v8(27.53,48.9) v8(27.53,48.47) v8(27.56,47.58) v8(27.56,47.15) v8(27.56,46.72) v8(27.51,19.21) v8(27.51,18.78) v8(27.51,18.35) v8(27.51,17.94) v8(27.69,27.75) v8(27.69,27.31) v8(27.69,26.88) v8(27.69,26.48) v8(27.61,3.36) v8(27.61,2.93) v8(27.61,2.5) v8(27.61,2.09) v8(27.86,23.1) v8(27.86,22.69) v8(27.86,22.26) v8(27.86,21.83) v8(27.86,17.18) v8(27.86,16.77) v8(27.86,16.34) v8(27.86,15.91) v8(27.89,11.69) v8(27.89,11.29) v8(27.89,10.86) v8(27.89,10.42) v8(27.81,9.61) v8(27.81,9.2) v8(27.81,8.77) v8(27.94,49.31) v8(27.94,48.88) v8(27.94,48.47) v8(27.97,47.56) v8(27.97,47.13) v8(27.97,46.72) v8(27.92,25.03) v8(27.92,24.62) v8(27.92,24.19) v8(27.92,23.76) v8(27.92,21.19) v8(27.92,20.79) v8(27.92,20.36) v8(27.92,19.92) v8(27.94,19.21) v8(27.94,18.81) v8(27.94,18.37) v8(27.94,17.94) v8(28.04,3.36) v8(28.04,2.96) v8(28.04,2.52) v8(28.04,2.09) v8(28.12,27.75) v8(28.12,27.34) v8(28.12,26.91) v8(28.12,26.48) v8(28.37,49.34) v8(28.37,48.9) v8(28.37,48.47) v8(28.4,47.58) v8(28.4,47.15) v8(28.4,46.72) v8(28.45,3.36) v8(28.45,2.93) v8(28.45,2.5) v8(28.45,2.09) v8(28.68,13.34) v8(28.68,12.91) v8(28.78,21.75) v8(28.78,21.32) v8(28.78,20.89) v8(28.78,20.48) v8(28.88,3.36) v8(28.88,2.96) v8(28.88,2.52) v8(28.88,2.09) v8(28.91,18.91) v8(28.91,18.48) v8(29.08,13.32) v8(29.08,12.89) v8(29.21,21.75) v8(29.21,21.35) v8(29.21,20.91) v8(29.21,20.48) v8(29.31,18.88) v8(29.31,18.45) v8(29.52,13.34) v8(29.52,12.91) v8(29.62,21.75) v8(29.62,21.32) v8(29.62,20.89) v8(29.62,20.48) v8(29.79,40.8) v8(29.79,40.37) v8(29.79,39.94) v8(29.74,18.91) v8(29.74,18.48) v8(29.87,49.41) v8(29.87,48.98) v8(29.87,48.55) v8(29.97,28) v8(29.97,27.57) v8(29.97,27.14) v8(29.97,26.73) v8(30.05,47.33) v8(30.05,46.9) v8(30.05,46.47) v8(30.05,21.75) v8(30.05,21.35) v8(30.05,20.91) v8(30.05,20.48) v8(30.2,40.78) v8(30.2,40.34) v8(30.2,39.94) v8(30.28,49.39) v8(30.28,48.96) v8(30.28,48.55) v8(30.25,25.23) v8(30.25,24.8) v8(30.25,24.37) v8(30.25,23.96) v8(30.4,28) v8(30.4,27.59) v8(30.4,27.16) v8(30.4,26.73) v8(30.46,47.3) v8(30.46,46.87) v8(30.46,46.47) v8(30.51,45.32) v8(30.51,44.89) v8(30.51,44.46) v8(30.56,16.47) v8(30.56,16.04) v8(30.56,15.61) v8(30.56,15.2) v8(30.51,12.76) v8(30.51,12.33) v8(30.63,40.8) v8(30.63,40.37) v8(30.63,39.94) v8(30.68,25.23) v8(30.68,24.83) v8(30.68,24.39) v8(30.68,23.96) v8(30.71,49.41) v8(30.71,48.98) v8(30.71,48.55) v8(30.79,22.62) v8(30.79,22.18) v8(30.79,21.75) v8(30.79,21.35) v8(30.79,18.65) v8(30.79,18.22) v8(30.89,47.33) v8(30.89,46.9) v8(30.89,46.47) v8(30.81,28) v8(30.81,27.57) v8(30.81,27.14) v8(30.81,26.73) v8(30.86,20.61) v8(30.86,20.18) v8(30.91,45.3) v8(30.91,44.87) v8(30.91,44.46) v8(30.99,16.47) v8(30.99,16.06) v8(30.99,15.63) v8(30.99,15.2) v8(30.91,12.74) v8(30.91,12.3) v8(31.09,25.23) v8(31.09,24.8) v8(31.09,24.37) v8(31.09,23.96) v8(31.19,18.63) v8(31.19,18.2) v8(31.24,28) v8(31.24,27.59) v8(31.24,27.16) v8(31.24,26.73) v8(31.22,22.62) v8(31.22,22.21) v8(31.22,21.78) v8(31.22,21.35) v8(31.27,20.58) v8(31.27,20.15) v8(31.34,45.32) v8(31.34,44.89) v8(31.34,44.46) v8(31.4,16.47) v8(31.4,16.04) v8(31.4,15.61) v8(31.4,15.2) v8(31.34,12.76) v8(31.34,12.33) v8(31.52,25.23) v8(31.52,24.83) v8(31.52,24.39) v8(31.52,23.96) v8(31.62,22.62) v8(31.62,22.18) v8(31.62,21.75) v8(31.62,21.35) v8(31.7,20.61) v8(31.7,20.18) v8(31.62,18.65) v8(31.62,18.22) v8(31.83,16.47) v8(31.83,16.06) v8(31.83,15.63) v8(31.83,15.2) v8(32.06,22.62) v8(32.06,22.21) v8(32.06,21.78) v8(32.06,21.35) v8(32.28,40.5) v8(32.28,40.07) v8(32.28,39.63) v8(32.21,38.47) v8(32.21,38.06) v8(32.39,27.42) v8(32.39,26.98) v8(32.39,26.55) v8(32.39,26.15) v8(32.69,40.47) v8(32.69,40.04) v8(32.69,39.63) v8(32.64,38.49) v8(32.64,38.06) v8(32.82,27.42) v8(32.82,27.01) v8(32.82,26.58) v8(32.82,26.15) v8(33.05,20.79) v8(33.05,20.36) v8(33.05,19.92) v8(33.05,19.52) v8(33.1,18.5) v8(33.1,18.07) v8(33.1,17.64) v8(33.1,17.23) v8(33.12,40.5) v8(33.12,40.07) v8(33.12,39.63) v8(33.22,27.42) v8(33.22,26.98) v8(33.22,26.55) v8(33.22,26.15) v8(33.38,46.8) v8(33.38,46.36) v8(33.38,45.93) v8(33.43,37.55) v8(33.43,37.12) v8(33.43,36.69) v8(33.48,20.79) v8(33.48,20.38) v8(33.48,19.95) v8(33.48,19.52) v8(33.55,23.73) v8(33.55,23.3) v8(33.53,18.5) v8(33.53,18.09) v8(33.53,17.66) v8(33.53,17.23) v8(33.66,27.42) v8(33.66,27.01) v8(33.66,26.58) v8(33.66,26.15) v8(33.78,46.77) v8(33.78,46.34) v8(33.78,45.93) v8(33.71,39.38) v8(33.71,38.97) v8(33.83,37.53) v8(33.83,37.09) v8(33.83,36.69) v8(33.88,20.79) v8(33.88,20.36) v8(33.88,19.92) v8(33.88,19.52) v8(33.96,23.71) v8(33.96,23.28) v8(33.94,18.5) v8(33.94,18.07) v8(33.94,17.64) v8(33.94,17.23) v8(34.14,39.41) v8(34.14,38.97) v8(34.21,46.8) v8(34.21,46.36) v8(34.21,45.93) v8(34.27,37.55) v8(34.27,37.12) v8(34.27,36.69) v8(34.39,23.73) v8(34.39,23.3) v8(34.32,20.79) v8(34.32,20.38) v8(34.32,19.95) v8(34.32,19.52) v8(34.37,18.5) v8(34.37,18.09) v8(34.37,17.66) v8(34.37,17.23) v8(34.47,16.11) v8(34.47,15.68) v8(34.47,15.25) v8(34.47,14.84) v8(34.8,40.24) v8(34.8,39.81) v8(34.8,39.38) v8(34.9,30.79) v8(34.9,30.36) v8(34.9,29.93) v8(34.9,16.11) v8(34.9,15.71) v8(34.9,15.28) v8(34.9,14.84) v8(34.93,42.3) v8(34.93,41.89) v8(35.21,40.22) v8(35.21,39.79) v8(35.21,39.38) v8(35.15,38.14) v8(35.15,37.73) v8(35.21,20.51) v8(35.21,20.08) v8(35.36,42.33) v8(35.36,41.89) v8(35.31,30.77) v8(35.31,30.34) v8(35.31,29.93) v8(35.31,16.11) v8(35.31,15.68) v8(35.31,15.25) v8(35.31,14.84) v8(35.33,13.95) v8(35.33,13.52) v8(35.33,13.09) v8(35.33,12.68) v8(35.46,50.99) v8(35.46,50.58) v8(35.41,49.77) v8(35.41,49.36) v8(35.43,48.35) v8(35.43,47.94) v8(35.59,38.16) v8(35.59,37.73) v8(35.69,41.49) v8(35.69,41.08) v8(35.64,40.24) v8(35.64,39.81) v8(35.64,39.38) v8(35.61,20.48) v8(35.61,20.05) v8(35.74,30.79) v8(35.74,30.36) v8(35.74,29.93) v8(35.74,16.11) v8(35.74,15.71) v8(35.74,15.28) v8(35.74,14.84) v8(35.76,13.95) v8(35.76,13.55) v8(35.76,13.12) v8(35.76,12.68) v8(35.89,51.01) v8(35.89,50.58) v8(35.84,49.79) v8(35.84,49.36) v8(35.87,48.37) v8(35.87,47.94) v8(36.07,29.27) v8(36.07,28.86) v8(36.04,20.51) v8(36.04,20.08) v8(36.12,41.51) v8(36.12,41.08) v8(36.2,25.1) v8(36.2,24.67) v8(36.2,24.24) v8(36.2,23.83) v8(36.17,13.95) v8(36.17,13.52) v8(36.17,13.09) v8(36.17,12.68) v8(36.32,110.63) v8(36.32,110.2) v8(36.32,109.76) v8(36.32,109.36) v8(36.4,22.92) v8(36.4,22.49) v8(36.4,22.06) v8(36.4,21.65) v8(36.5,29.3) v8(36.5,28.86) v8(36.6,13.95) v8(36.6,13.55) v8(36.6,13.12) v8(36.6,12.68) v8(36.63,25.1) v8(36.63,24.7) v8(36.63,24.27) v8(36.63,23.83) v8(36.76,110.63) v8(36.76,110.22) v8(36.76,109.79) v8(36.76,109.36) v8(36.83,22.92) v8(36.83,22.51) v8(36.83,22.08) v8(36.83,21.65) v8(36.98,28.33) v8(36.98,27.92) v8(37.03,25.1) v8(37.03,24.67) v8(37.03,24.24) v8(37.03,23.83) v8(37.16,110.63) v8(37.16,110.2) v8(37.16,109.76) v8(37.16,109.36) v8(37.24,22.92) v8(37.24,22.49) v8(37.24,22.06) v8(37.24,21.65) v8(37.41,28.36) v8(37.41,27.92) v8(37.47,25.1) v8(37.47,24.7) v8(37.47,24.27) v8(37.47,23.83) v8(37.59,110.63) v8(37.59,110.22) v8(37.59,109.79) v8(37.59,109.36) v8(37.67,22.92) v8(37.67,22.51) v8(37.67,22.08) v8(37.67,21.65) v8(37.8,49.74) v8(37.8,49.34) v8(37.77,18.65) v8(37.77,18.22) v8(37.77,17.79) v8(37.77,17.38) v8(38,27.44) v8(38,27.04) v8(37.92,20.66) v8(37.92,20.23) v8(37.92,19.8) v8(37.92,19.39) v8(38.05,16.19) v8(38.05,15.76) v8(38.05,15.33) v8(38.05,14.92) v8(38.2,18.65) v8(38.2,18.25) v8(38.2,17.82) v8(38.2,17.38) v8(38.22,109.19) v8(38.22,108.76) v8(38.22,108.33) v8(38.22,107.92) v8(38.23,49.77) v8(38.23,49.34) v8(38.35,20.66) v8(38.35,20.25) v8(38.35,19.82) v8(38.35,19.39) v8(38.48,33.23) v8(38.48,32.8) v8(38.48,32.37) v8(38.43,27.47) v8(38.43,27.04) v8(38.48,16.19) v8(38.48,15.78) v8(38.48,15.35) v8(38.48,14.92) v8(38.51,34.58) v8(38.51,34.15) v8(38.51,33.72) v8(38.66,109.19) v8(38.66,108.79) v8(38.66,108.35) v8(38.66,107.92) v8(38.66,39.66) v8(38.66,39.23) v8(38.66,38.8) v8(38.66,38.29) v8(38.66,37.86) v8(38.66,37.42) v8(38.61,31.89) v8(38.61,31.45) v8(38.61,31.02) v8(38.61,18.65) v8(38.61,18.22) v8(38.61,17.79) v8(38.61,17.38) v8(38.76,20.66) v8(38.76,20.23) v8(38.76,19.8) v8(38.76,19.39) v8(38.86,111.56) v8(38.86,111.12) v8(38.86,110.69) v8(38.86,110.29) v8(38.86,26.32) v8(38.86,25.92) v8(38.84,24.93) v8(38.84,24.52) v8(38.89,16.19) v8(38.89,15.76) v8(38.89,15.33) v8(38.89,14.92) v8(39.06,109.19) v8(39.06,108.76) v8(39.06,108.33) v8(39.06,107.92) v8(39.04,18.65) v8(39.04,18.25) v8(39.04,17.82) v8(39.04,17.38) v8(39.19,20.66) v8(39.19,20.25) v8(39.19,19.82) v8(39.19,19.39) v8(39.29,111.56) v8(39.29,111.15) v8(39.29,110.72) v8(39.29,110.29) v8(39.29,26.35) v8(39.29,25.92) v8(39.27,24.95) v8(39.27,24.52) v8(39.27,23.73) v8(39.27,23.33) v8(39.32,16.19) v8(39.32,15.78) v8(39.32,15.35) v8(39.32,14.92) v8(39.49,109.19) v8(39.49,108.79) v8(39.49,108.35) v8(39.49,107.92) v8(39.69,111.56) v8(39.69,111.12) v8(39.69,110.69) v8(39.69,110.29) v8(39.7,23.76) v8(39.7,23.33) v8(39.88,17.89) v8(39.88,17.46) v8(39.88,17.03) v8(39.88,16.62) v8(40.01,31.58) v8(40.01,31.15) v8(40.01,30.72) v8(40.13,111.56) v8(40.13,111.15) v8(40.13,110.72) v8(40.13,110.29) v8(40.31,17.89) v8(40.31,17.48) v8(40.31,17.05) v8(40.31,16.62) v8(40.46,31.1) v8(40.46,30.67) v8(40.46,30.24) v8(40.67,14.28) v8(40.67,13.85) v8(40.67,13.42) v8(40.67,13.01) v8(40.72,17.89) v8(40.72,17.46) v8(40.72,17.03) v8(40.72,16.62) v8(40.72,11.21) v8(40.72,10.78) v8(40.72,10.35) v8(40.72,9.94) v8(40.92,30.62) v8(40.92,30.18) v8(40.92,29.75) v8(41.07,15.73) v8(41.07,15.3) v8(41.1,14.28) v8(41.1,13.88) v8(41.1,13.45) v8(41.1,13.01) v8(41.07,12.38) v8(41.07,11.95) v8(41.18,113.2) v8(41.18,112.77) v8(41.18,112.34) v8(41.18,111.93) v8(41.15,17.89) v8(41.15,17.48) v8(41.15,17.05) v8(41.15,16.62) v8(41.15,11.21) v8(41.15,10.8) v8(41.15,10.37) v8(41.15,9.94) v8(41.43,30.13) v8(41.43,29.7) v8(41.43,29.27) v8(41.48,15.71) v8(41.48,15.28) v8(41.5,14.28) v8(41.5,13.85) v8(41.5,13.42) v8(41.5,13.01) v8(41.48,12.35) v8(41.48,11.92) v8(41.56,11.21) v8(41.56,10.78) v8(41.56,10.35) v8(41.56,9.94) v8(41.61,113.2) v8(41.61,112.8) v8(41.61,112.36) v8(41.61,111.93) v8(41.71,26.32) v8(41.71,25.89) v8(41.71,25.46) v8(41.71,25.05) v8(41.96,29.6) v8(41.96,29.17) v8(41.96,28.74) v8(41.91,15.73) v8(41.91,15.3) v8(41.94,14.28) v8(41.94,13.88) v8(41.94,13.45) v8(41.94,13.01) v8(41.91,12.38) v8(41.91,11.95) v8(41.99,11.21) v8(41.99,10.8) v8(41.99,10.37) v8(41.99,9.94) v8(42.02,113.2) v8(42.02,112.77) v8(42.02,112.34) v8(42.02,111.93) v8(42.14,26.32) v8(42.14,25.92) v8(42.14,25.49) v8(42.14,25.05) v8(42.45,113.2) v8(42.45,112.8) v8(42.45,112.36) v8(42.45,111.93) v8(42.42,29.09) v8(42.42,28.66) v8(42.42,28.23) v8(42.55,26.32) v8(42.55,25.89) v8(42.55,25.46) v8(42.55,25.05) v8(42.67,4.4) v8(42.67,3.97) v8(42.85,15.22) v8(42.85,14.79) v8(42.85,14.36) v8(42.85,13.95) v8(42.98,26.32) v8(42.98,25.92) v8(42.98,25.49) v8(42.98,25.05) v8(43.03,12.91) v8(43.03,12.48) v8(43.08,4.38) v8(43.08,3.95) v8(43.28,15.22) v8(43.28,14.82) v8(43.28,14.39) v8(43.28,13.95) v8(43.43,12.89) v8(43.43,12.46) v8(43.51,4.4) v8(43.51,3.97) v8(43.69,15.22) v8(43.69,14.79) v8(43.69,14.36) v8(43.69,13.95) v8(43.74,11.52) v8(43.74,11.08) v8(43.74,10.65) v8(43.74,10.25) v8(43.87,12.91) v8(43.87,12.48) v8(43.97,6.74) v8(43.97,6.31) v8(43.97,5.88) v8(43.97,5.47) v8(44.1,69.48) v8(44.1,69.1) v8(44.1,8.87) v8(44.1,8.44) v8(44.1,8.01) v8(44.1,7.6) v8(44.18,113.2) v8(44.18,112.77) v8(44.18,112.34) v8(44.18,111.93) v8(44.13,75.73) v8(44.13,75.34) v8(44.12,15.22) v8(44.12,14.82) v8(44.12,14.39) v8(44.12,13.95) v8(44.17,11.52) v8(44.17,11.11) v8(44.17,10.68) v8(44.17,10.25) v8(44.27,37.8) v8(44.27,37.37) v8(44.4,6.74) v8(44.4,6.33) v8(44.4,5.9) v8(44.4,5.47) v8(44.48,74.2) v8(44.48,69.48) v8(44.48,69.1) v8(44.51,75.73) v8(44.51,75.34) v8(44.51,74.58) v8(44.58,11.52) v8(44.58,11.08) v8(44.58,10.65) v8(44.58,10.25) v8(44.53,8.87) v8(44.53,8.47) v8(44.53,8.04) v8(44.53,7.6) v8(44.61,113.2) v8(44.61,112.8) v8(44.61,112.36) v8(44.61,111.93) v8(44.64,72.17) v8(44.68,37.78) v8(44.68,37.35) v8(44.65,4.35) v8(44.65,3.92) v8(44.89,74.58) v8(44.85,74.21) v8(44.81,6.74) v8(44.81,6.31) v8(44.81,5.88) v8(44.81,5.47) v8(44.93,8.87) v8(44.93,8.44) v8(44.93,8.01) v8(44.93,7.6) v8(45.01,113.2) v8(45.01,112.77) v8(45.01,112.34) v8(45.01,111.93) v8(45.02,72.17) v8(45.09,41.51) v8(45.09,41.08) v8(45.01,11.52) v8(45.01,11.11) v8(45.01,10.68) v8(45.01,10.25) v8(45.06,4.33) v8(45.06,3.9) v8(45.11,37.8) v8(45.11,37.37) v8(45.22,76.13) v8(45.22,75.75) v8(45.21,12.91) v8(45.21,12.48) v8(45.24,6.74) v8(45.24,6.33) v8(45.24,5.9) v8(45.24,5.47) v8(45.37,8.87) v8(45.37,8.47) v8(45.37,8.04) v8(45.37,7.6) v8(45.45,113.2) v8(45.45,112.8) v8(45.45,112.36) v8(45.45,111.93) v8(45.49,41.49) v8(45.49,41.06) v8(45.49,4.35) v8(45.49,3.92) v8(45.6,76.13) v8(45.6,75.75) v8(45.52,26.17) v8(45.52,25.74) v8(45.52,25.31) v8(45.52,24.9) v8(45.67,35.82) v8(45.67,35.39) v8(45.62,12.89) v8(45.62,12.46) v8(45.91,75.09) v8(45.91,74.71) v8(45.91,73.57) v8(45.91,73.19) v8(45.92,41.51) v8(45.92,41.08) v8(45.92,37.55) v8(45.92,37.12) v8(45.95,26.17) v8(45.95,25.77) v8(45.95,25.33) v8(45.95,24.9) v8(46.08,40.09) v8(46.08,39.66) v8(46.08,35.8) v8(46.08,35.37) v8(46.03,34.71) v8(46.03,34.27) v8(46.05,12.91) v8(46.05,12.48) v8(46.29,75.09) v8(46.29,74.71) v8(46.29,73.57) v8(46.29,73.19) v8(46.33,37.53) v8(46.33,37.09) v8(46.36,26.17) v8(46.36,25.74) v8(46.36,25.31) v8(46.36,24.9) v8(46.38,4.33) v8(46.38,3.9) v8(46.48,40.07) v8(46.48,39.63) v8(46.43,34.68) v8(46.43,34.25) v8(46.51,35.82) v8(46.51,35.39) v8(46.76,37.55) v8(46.76,37.12) v8(46.79,26.17) v8(46.79,25.77) v8(46.79,25.33) v8(46.79,24.9) v8(46.76,24.27) v8(46.76,23.83) v8(46.76,23.4) v8(46.76,23) v8(46.79,4.3) v8(46.79,3.87) v8(46.86,34.71) v8(46.86,34.27) v8(46.92,113.2) v8(46.92,112.77) v8(46.92,112.34) v8(46.92,111.93) v8(46.95,71.56) v8(46.91,40.09) v8(46.91,39.66) v8(47.05,73.69) v8(47.05,73.31) v8(47.19,24.27) v8(47.19,23.86) v8(47.19,23.43) v8(47.19,23) v8(47.22,4.33) v8(47.22,3.9) v8(47.35,113.2) v8(47.35,112.8) v8(47.35,112.36) v8(47.35,111.93) v8(47.33,71.56) v8(47.47,73.72) v8(47.42,73.35) v8(47.56,74.96) v8(47.56,74.58) v8(47.56,72.04) v8(47.6,24.27) v8(47.6,23.83) v8(47.6,23.4) v8(47.6,23) v8(47.76,113.2) v8(47.76,112.77) v8(47.76,112.34) v8(47.76,111.93) v8(47.8,49.62) v8(47.8,49.18) v8(47.81,71.56) v8(47.94,74.96) v8(47.94,74.58) v8(47.94,72.04) v8(48.03,24.27) v8(48.03,23.86) v8(48.03,23.43) v8(48.03,23) v8(48.19,113.2) v8(48.19,112.8) v8(48.19,112.36) v8(48.19,111.93) v8(48.19,71.56) v8(48.21,49.59) v8(48.21,49.16) v8(48.21,46.29) v8(48.21,45.86) v8(48.64,49.62) v8(48.64,49.18) v8(48.62,46.26) v8(48.62,45.83) v8(48.9,72.81) v8(48.92,73.92) v8(49.05,46.29) v8(49.05,45.86) v8(49.33,39.81) v8(49.33,39.38) v8(49.46,73.95) v8(49.58,113.2) v8(49.58,112.77) v8(49.58,112.34) v8(49.58,111.93) v8(49.68,49.79) v8(49.68,49.36) v8(49.68,48.93) v8(49.68,48.52) v8(49.71,111.47) v8(49.71,111.04) v8(49.71,110.61) v8(49.71,110.2) v8(49.73,39.79) v8(49.73,39.35) v8(49.87,74.66) v8(49.92,74.13) v8(49.97,73.31) v8(49.96,47.53) v8(49.96,47.1) v8(49.96,46.67) v8(49.96,46.26) v8(49.91,44.36) v8(49.91,43.93) v8(49.91,43.49) v8(49.91,43.09) v8(50.01,113.2) v8(50.01,112.8) v8(50.01,112.36) v8(50.01,111.93) v8(50.01,41.74) v8(50.01,41.31) v8(50.01,40.88) v8(50.01,40.47) v8(50.14,111.47) v8(50.14,111.07) v8(50.14,110.63) v8(50.14,110.2) v8(50.11,49.79) v8(50.11,49.39) v8(50.11,48.96) v8(50.11,48.52) v8(50.17,39.81) v8(50.17,39.38) v8(50.39,47.53) v8(50.39,47.13) v8(50.39,46.69) v8(50.39,46.26) v8(50.34,44.36) v8(50.34,43.95) v8(50.34,43.52) v8(50.34,43.09) v8(50.39,36.08) v8(50.39,35.65) v8(50.42,113.2) v8(50.42,112.77) v8(50.42,112.34) v8(50.42,111.93) v8(50.45,41.74) v8(50.45,41.34) v8(50.45,40.9) v8(50.45,40.47) v8(50.54,111.47) v8(50.54,111.04) v8(50.54,110.61) v8(50.54,110.2) v8(50.53,73.21) v8(50.52,49.79) v8(50.52,49.36) v8(50.52,48.93) v8(50.52,48.52) v8(50.52,2.6) v8(50.52,2.17) v8(50.52,1.74) v8(50.52,1.33) v8(50.62,38.11) v8(50.62,37.68) v8(50.62,37.25) v8(50.62,36.84) v8(50.73,72.8) v8(50.73,72.42) v8(50.8,47.53) v8(50.8,47.1) v8(50.8,46.67) v8(50.8,46.26) v8(50.75,44.36) v8(50.75,43.93) v8(50.75,43.49) v8(50.75,43.09) v8(50.8,36.05) v8(50.8,35.62) v8(50.85,113.2) v8(50.85,112.8) v8(50.85,112.36) v8(50.85,111.93) v8(50.85,41.74) v8(50.85,41.31) v8(50.85,40.88) v8(50.85,40.47) v8(50.98,111.47) v8(50.98,111.07) v8(50.98,110.63) v8(50.98,110.2) v8(50.95,49.79) v8(50.95,49.39) v8(50.95,48.96) v8(50.95,48.52) v8(50.95,2.6) v8(50.95,2.19) v8(50.95,1.76) v8(50.95,1.33) v8(51.01,73.46) v8(51.05,38.11) v8(51.05,37.7) v8(51.05,37.27) v8(51.05,36.84) v8(51.18,73.97) v8(51.11,72.8) v8(51.11,72.42) v8(51.18,44.36) v8(51.18,43.95) v8(51.18,43.52) v8(51.18,43.09) v8(51.23,47.53) v8(51.23,47.13) v8(51.23,46.69) v8(51.23,46.26) v8(51.28,41.74) v8(51.28,41.34) v8(51.28,40.9) v8(51.28,40.47) v8(51.23,36.08) v8(51.23,35.65) v8(51.36,2.6) v8(51.36,2.17) v8(51.36,1.74) v8(51.36,1.33) v8(51.46,38.11) v8(51.46,37.68) v8(51.46,37.25) v8(51.46,36.84) v8(51.79,2.6) v8(51.79,2.19) v8(51.79,1.76) v8(51.79,1.33) v8(51.88,74.2) v8(51.82,42.28) v8(51.82,41.84) v8(51.89,38.11) v8(51.89,37.7) v8(51.89,37.27) v8(51.89,36.84) v8(51.99,45.22) v8(51.99,44.79) v8(52.07,113.24) v8(52.07,112.81) v8(52.07,112.38) v8(52.07,111.97) v8(52.1,9.33) v8(52.1,8.9) v8(52.1,8.47) v8(52.1,8.06) v8(52.15,17.97) v8(52.15,17.54) v8(52.17,16.62) v8(52.17,16.19) v8(52.26,74.2) v8(52.26,73.82) v8(52.22,42.25) v8(52.22,41.82) v8(52.27,15.1) v8(52.27,14.67) v8(52.27,14.23) v8(52.27,13.83) v8(52.3,13.09) v8(52.3,12.66) v8(52.4,45.2) v8(52.4,44.76) v8(52.5,113.24) v8(52.5,112.84) v8(52.5,112.41) v8(52.5,111.97) v8(52.45,111.39) v8(52.45,110.96) v8(52.45,110.52) v8(52.45,110.12) v8(52.43,2.6) v8(52.43,2.17) v8(52.43,1.74) v8(52.43,1.33) v8(52.54,109.49) v8(52.54,109.06) v8(52.54,108.62) v8(52.54,108.22) v8(52.55,17.94) v8(52.55,17.51) v8(52.58,16.6) v8(52.58,16.16) v8(52.53,9.33) v8(52.53,8.93) v8(52.53,8.49) v8(52.53,8.06) v8(52.65,42.28) v8(52.65,41.84) v8(52.63,37.6) v8(52.63,37.17) v8(52.76,49.44) v8(52.76,49.01) v8(52.71,15.1) v8(52.71,14.69) v8(52.71,14.26) v8(52.71,13.83) v8(52.71,13.07) v8(52.71,12.63) v8(52.88,111.39) v8(52.88,110.98) v8(52.88,110.55) v8(52.88,110.12) v8(52.83,45.22) v8(52.83,44.79) v8(52.86,2.6) v8(52.86,2.19) v8(52.86,1.76) v8(52.86,1.33) v8(52.91,113.24) v8(52.91,112.81) v8(52.91,112.38) v8(52.91,111.97) v8(52.97,109.49) v8(52.97,109.08) v8(52.97,108.65) v8(52.97,108.22) v8(52.93,47.18) v8(52.93,46.75) v8(52.93,46.31) v8(52.93,45.91) v8(52.99,17.97) v8(52.99,17.54) v8(52.93,9.33) v8(52.93,8.9) v8(52.93,8.47) v8(52.93,8.06) v8(53.01,43.16) v8(53.01,42.73) v8(53.04,37.58) v8(53.04,37.14) v8(53.01,16.62) v8(53.01,16.19) v8(53.16,49.41) v8(53.16,48.98) v8(53.11,15.1) v8(53.11,14.67) v8(53.11,14.23) v8(53.11,13.83) v8(53.14,13.09) v8(53.14,12.66) v8(53.29,111.39) v8(53.29,110.96) v8(53.29,110.52) v8(53.29,110.12) v8(53.26,2.6) v8(53.26,2.17) v8(53.26,1.74) v8(53.26,1.33) v8(53.34,113.24) v8(53.34,112.84) v8(53.34,112.41) v8(53.34,111.97) v8(53.37,109.49) v8(53.37,109.06) v8(53.37,108.62) v8(53.37,108.22) v8(53.37,47.18) v8(53.37,46.77) v8(53.37,46.34) v8(53.37,45.91) v8(53.37,9.33) v8(53.37,8.93) v8(53.37,8.49) v8(53.37,8.06) v8(53.42,43.14) v8(53.42,42.71) v8(53.47,37.6) v8(53.47,37.17) v8(53.59,49.44) v8(53.59,49.01) v8(53.54,15.1) v8(53.54,14.69) v8(53.54,14.26) v8(53.54,13.83) v8(53.7,2.6) v8(53.7,2.19) v8(53.7,1.76) v8(53.7,1.33) v8(53.72,111.39) v8(53.72,110.98) v8(53.72,110.55) v8(53.72,110.12) v8(53.81,109.49) v8(53.81,109.08) v8(53.81,108.65) v8(53.81,108.22) v8(53.77,47.18) v8(53.77,46.75) v8(53.77,46.31) v8(53.77,45.91) v8(53.85,43.16) v8(53.85,42.73) v8(54.2,47.18) v8(54.2,46.77) v8(54.2,46.34) v8(54.2,45.91) v8(54.2,26.1) v8(54.2,25.66) v8(54.2,2.58) v8(54.2,2.14) v8(54.2,1.71) v8(54.2,1.31) v8(54.3,29.29) v8(54.26,27.14) v8(54.26,26.71) v8(54.28,14.51) v8(54.28,14.08) v8(54.28,13.65) v8(54.28,13.24) v8(54.31,29.64) v8(54.33,25.1) v8(54.33,24.67) v8(54.43,113.24) v8(54.43,112.81) v8(54.43,112.38) v8(54.43,111.97) v8(54.51,28.36) v8(54.51,27.92) v8(54.51,16.01) v8(54.51,15.58) v8(54.67,29.63) v8(54.66,27.11) v8(54.66,26.68) v8(54.61,26.07) v8(54.61,25.64) v8(54.64,2.58) v8(54.64,2.17) v8(54.64,1.74) v8(54.64,1.31) v8(54.74,25.08) v8(54.74,24.65) v8(54.79,22.11) v8(54.79,21.7) v8(54.79,21.27) v8(54.71,14.51) v8(54.71,14.11) v8(54.71,13.67) v8(54.71,13.24) v8(54.87,113.24) v8(54.87,112.84) v8(54.87,112.41) v8(54.87,111.97) v8(54.86,45.37) v8(54.86,44.94) v8(54.86,44.51) v8(54.86,44.1) v8(54.92,28.33) v8(54.92,27.9) v8(54.92,15.99) v8(54.92,15.55) v8(55.02,29.63) v8(55.09,27.14) v8(55.09,26.71) v8(55.04,26.1) v8(55.04,25.66) v8(55.04,2.58) v8(55.04,2.14) v8(55.04,1.71) v8(55.04,1.31) v8(55.17,25.1) v8(55.17,24.67) v8(55.19,22.11) v8(55.19,21.68) v8(55.19,21.24) v8(55.12,14.51) v8(55.12,14.08) v8(55.12,13.65) v8(55.12,13.24) v8(55.27,113.24) v8(55.27,112.81) v8(55.27,112.38) v8(55.27,111.97) v8(55.3,45.37) v8(55.3,44.97) v8(55.3,44.54) v8(55.3,44.1) v8(55.35,47.18) v8(55.35,46.75) v8(55.35,28.36) v8(55.35,27.92) v8(55.35,16.01) v8(55.35,15.58) v8(55.47,2.58) v8(55.47,2.17) v8(55.47,1.74) v8(55.47,1.31) v8(55.53,111.47) v8(55.53,111.04) v8(55.53,110.61) v8(55.53,110.2) v8(55.53,20.71) v8(55.53,20.3) v8(55.53,19.87) v8(55.55,14.51) v8(55.55,14.11) v8(55.55,13.67) v8(55.55,13.24) v8(55.7,113.24) v8(55.7,112.84) v8(55.7,112.41) v8(55.7,111.97) v8(55.7,45.37) v8(55.7,44.94) v8(55.7,44.51) v8(55.7,44.1) v8(55.63,22.11) v8(55.63,21.7) v8(55.63,21.27) v8(55.75,47.15) v8(55.75,46.72) v8(55.83,12.25) v8(55.83,11.82) v8(55.83,11.39) v8(55.83,10.98) v8(55.96,111.47) v8(55.96,111.07) v8(55.96,110.63) v8(55.96,110.2) v8(55.93,20.71) v8(55.93,20.28) v8(55.93,19.85) v8(55.91,2.58) v8(55.91,2.14) v8(55.91,1.71) v8(55.91,1.31) v8(56.08,28.4) v8(56.08,28.05) v8(56.08,27.62) v8(56.19,47.18) v8(56.19,46.75) v8(56.13,45.37) v8(56.13,44.97) v8(56.13,44.54) v8(56.13,44.1) v8(56.21,39.38) v8(56.21,38.95) v8(56.21,38.52) v8(56.21,38.11) v8(56.29,14.03) v8(56.29,13.6) v8(56.29,13.17) v8(56.29,12.76) v8(56.26,12.25) v8(56.26,11.85) v8(56.26,11.41) v8(56.26,10.98) v8(56.37,111.47) v8(56.37,111.04) v8(56.37,110.61) v8(56.37,110.2) v8(56.36,20.71) v8(56.36,20.3) v8(56.36,19.87) v8(56.34,2.58) v8(56.34,2.17) v8(56.34,1.74) v8(56.34,1.31) v8(56.5,28.4) v8(56.49,28.03) v8(56.49,27.59) v8(56.59,113.24) v8(56.59,112.81) v8(56.59,112.38) v8(56.59,111.97) v8(56.59,35.37) v8(56.59,34.93) v8(56.59,34.5) v8(56.59,34.1) v8(56.64,39.38) v8(56.64,38.97) v8(56.64,38.54) v8(56.64,38.11) v8(56.67,12.25) v8(56.67,11.82) v8(56.67,11.39) v8(56.67,10.98) v8(56.8,111.47) v8(56.8,111.07) v8(56.8,110.63) v8(56.8,110.2) v8(56.77,43.34) v8(56.77,42.91) v8(56.72,14.03) v8(56.72,13.62) v8(56.72,13.19) v8(56.72,12.76) v8(56.74,2.58) v8(56.74,2.14) v8(56.74,1.71) v8(56.74,1.31) v8(56.92,28.05) v8(56.92,27.62) v8(57,26.88) v8(57,26.45) v8(57.02,113.24) v8(57.02,112.84) v8(57.02,112.41) v8(57.02,111.97) v8(57.05,39.38) v8(57.05,38.95) v8(57.05,38.52) v8(57.05,38.11) v8(57.02,35.37) v8(57.02,34.96) v8(57.02,34.53) v8(57.02,34.1) v8(57.1,12.25) v8(57.1,11.85) v8(57.1,11.41) v8(57.1,10.98) v8(57.18,43.32) v8(57.18,42.88) v8(57.13,14.03) v8(57.13,13.6) v8(57.13,13.17) v8(57.13,12.76) v8(57.18,2.58) v8(57.18,2.17) v8(57.18,1.74) v8(57.18,1.31) v8(57.23,49.49) v8(57.23,49.06) v8(57.23,48.63) v8(57.23,48.22) v8(57.4,26.86) v8(57.4,26.43) v8(57.43,113.24) v8(57.43,112.81) v8(57.43,112.38) v8(57.43,111.97) v8(57.48,39.38) v8(57.48,38.97) v8(57.48,38.54) v8(57.48,38.11) v8(57.43,35.37) v8(57.43,34.93) v8(57.43,34.5) v8(57.43,34.1) v8(57.53,25.64) v8(57.53,25.21) v8(57.53,21.8) v8(57.53,21.4) v8(57.53,20.96) v8(57.56,14.03) v8(57.56,13.62) v8(57.56,13.19) v8(57.56,12.76) v8(57.66,49.49) v8(57.66,49.08) v8(57.66,48.65) v8(57.66,48.22) v8(57.61,43.34) v8(57.61,42.91) v8(57.66,2.63) v8(57.66,2.19) v8(57.66,1.76) v8(57.66,1.36) v8(57.86,113.24) v8(57.86,112.84) v8(57.86,112.41) v8(57.86,111.97) v8(57.81,111.47) v8(57.81,111.04) v8(57.81,110.61) v8(57.81,110.2) v8(57.86,35.37) v8(57.86,34.96) v8(57.86,34.53) v8(57.86,34.1) v8(57.84,26.88) v8(57.84,26.45) v8(57.94,25.61) v8(57.94,25.18) v8(57.94,21.8) v8(57.94,21.37) v8(57.94,20.94) v8(58.07,49.49) v8(58.07,49.06) v8(58.07,48.63) v8(58.07,48.22) v8(58.09,2.63) v8(58.09,2.22) v8(58.09,1.79) v8(58.09,1.36) v8(58.14,18.96) v8(58.14,18.53) v8(58.14,18.09) v8(58.24,111.47) v8(58.24,111.07) v8(58.24,110.63) v8(58.24,110.2) v8(58.37,25.64) v8(58.37,25.21) v8(58.37,21.8) v8(58.37,21.4) v8(58.37,20.96) v8(58.5,49.49) v8(58.5,49.08) v8(58.5,48.65) v8(58.5,48.22) v8(58.5,2.63) v8(58.5,2.19) v8(58.5,1.76) v8(58.5,1.36) v8(58.6,33.13) v8(58.6,32.7) v8(58.6,32.27) v8(58.6,31.86) v8(58.57,18.96) v8(58.57,18.55) v8(58.57,18.12) v8(58.7,113.24) v8(58.7,112.81) v8(58.7,112.38) v8(58.7,111.97) v8(58.65,111.47) v8(58.65,111.04) v8(58.65,110.61) v8(58.65,110.2) v8(58.78,36.56) v8(58.78,36.13) v8(58.78,35.7) v8(58.78,35.29) v8(58.9,41.82) v8(58.9,41.39) v8(58.95,46.77) v8(58.95,46.34) v8(58.95,45.91) v8(58.95,45.5) v8(58.95,43.57) v8(58.95,43.14) v8(58.93,2.63) v8(58.93,2.22) v8(58.93,1.79) v8(58.93,1.36) v8(59.08,111.47) v8(59.08,111.07) v8(59.08,110.63) v8(59.08,110.2) v8(59.03,33.13) v8(59.03,32.72) v8(59.03,32.29) v8(59.03,31.86) v8(59.13,113.24) v8(59.13,112.84) v8(59.13,112.41) v8(59.13,111.97) v8(59.21,36.56) v8(59.21,36.15) v8(59.21,35.72) v8(59.21,35.29) v8(59.31,49.44) v8(59.31,49.01) v8(59.39,46.77) v8(59.39,46.36) v8(59.39,45.93) v8(59.39,45.5) v8(59.36,43.55) v8(59.36,43.11) v8(59.31,41.79) v8(59.31,41.36) v8(59.39,2.63) v8(59.39,2.19) v8(59.39,1.76) v8(59.39,1.36) v8(59.44,33.13) v8(59.44,32.7) v8(59.44,32.27) v8(59.44,31.86) v8(59.54,113.24) v8(59.54,112.81) v8(59.54,112.38) v8(59.54,111.97) v8(59.61,36.56) v8(59.61,36.13) v8(59.61,35.7) v8(59.61,35.29) v8(59.72,49.41) v8(59.72,48.98) v8(59.79,46.77) v8(59.79,46.34) v8(59.79,45.91) v8(59.79,45.5) v8(59.79,43.57) v8(59.79,43.14) v8(59.74,41.82) v8(59.74,41.39) v8(59.72,16.57) v8(59.72,16.16) v8(59.72,15.73) v8(59.87,33.13) v8(59.87,32.72) v8(59.87,32.29) v8(59.87,31.86) v8(59.82,22.54) v8(59.82,22.13) v8(59.82,21.7) v8(59.87,18.96) v8(59.87,18.55) v8(59.87,18.12) v8(59.82,2.63) v8(59.82,2.22) v8(59.82,1.79) v8(59.82,1.36) v8(59.97,113.24) v8(59.97,112.84) v8(59.97,112.41) v8(59.97,111.97) v8(60.05,111.47) v8(60.05,111.04) v8(60.05,110.61) v8(60.05,110.2) v8(60.05,36.56) v8(60.05,36.15) v8(60.05,35.72) v8(60.05,35.29) v8(60.15,49.44) v8(60.15,49.01) v8(60.15,25.08) v8(60.15,24.65) v8(60.12,16.57) v8(60.12,16.14) v8(60.12,15.71) v8(60.22,46.77) v8(60.22,46.36) v8(60.22,45.93) v8(60.22,45.5) v8(60.22,22.54) v8(60.22,22.11) v8(60.22,21.68) v8(60.27,18.96) v8(60.27,18.53) v8(60.27,18.09) v8(60.22,2.63) v8(60.22,2.19) v8(60.22,1.76) v8(60.22,1.36) v8(60.48,111.47) v8(60.48,111.07) v8(60.48,110.63) v8(60.48,110.2) v8(60.43,37.32) v8(60.43,36.89) v8(60.5,33.23) v8(60.5,32.8) v8(60.5,31.18) v8(60.5,30.74) v8(60.55,25.05) v8(60.55,24.62) v8(60.55,16.57) v8(60.55,16.16) v8(60.55,15.73) v8(60.68,38.92) v8(60.68,38.49) v8(60.63,34.88) v8(60.63,34.45) v8(60.66,22.54) v8(60.66,22.13) v8(60.66,21.7) v8(60.66,2.63) v8(60.66,2.22) v8(60.66,1.79) v8(60.66,1.36) v8(60.71,18.96) v8(60.71,18.55) v8(60.71,18.12) v8(60.89,111.47) v8(60.89,111.04) v8(60.89,110.61) v8(60.89,110.2) v8(60.83,37.3) v8(60.83,36.87) v8(60.99,47.43) v8(60.99,47) v8(60.91,33.21) v8(60.91,32.78) v8(60.91,31.15) v8(60.91,30.72) v8(60.99,25.08) v8(60.99,24.65) v8(61.02,113.2) v8(61.02,112.77) v8(61.02,112.34) v8(61.02,111.93) v8(61.07,75.6) v8(61.07,75.22) v8(61.09,38.9) v8(61.09,38.47) v8(61.04,34.86) v8(61.04,34.43) v8(61.09,2.6) v8(61.09,2.17) v8(61.09,1.74) v8(61.09,1.33) v8(61.19,49.57) v8(61.19,49.13) v8(61.19,48.7) v8(61.19,48.3) v8(61.29,43.42) v8(61.29,42.99) v8(61.29,42.55) v8(61.29,42.15) v8(61.27,37.32) v8(61.27,36.89) v8(61.32,111.47) v8(61.32,111.07) v8(61.32,110.63) v8(61.32,110.2) v8(61.39,47.41) v8(61.39,46.97) v8(61.34,33.23) v8(61.34,32.8) v8(61.34,31.18) v8(61.34,30.74) v8(61.32,19.14) v8(61.32,18.7) v8(61.45,113.2) v8(61.45,112.8) v8(61.45,112.36) v8(61.45,111.93) v8(61.44,51.27) v8(61.44,50.84) v8(61.47,34.88) v8(61.47,34.45) v8(61.52,38.92) v8(61.52,38.49) v8(61.52,2.6) v8(61.52,2.19) v8(61.52,1.76) v8(61.52,1.33) v8(61.62,49.57) v8(61.62,49.16) v8(61.62,48.73) v8(61.62,48.3) v8(61.7,25.13) v8(61.7,24.7) v8(61.72,43.42) v8(61.72,43.01) v8(61.72,42.58) v8(61.72,42.15) v8(61.72,19.11) v8(61.72,18.68) v8(61.86,113.2) v8(61.86,112.77) v8(61.86,112.34) v8(61.86,111.93) v8(61.85,51.24) v8(61.85,50.81) v8(61.82,47.43) v8(61.82,47) v8(61.85,22.67) v8(61.85,22.26) v8(61.85,21.83) v8(61.95,18.27) v8(61.95,17.84) v8(61.95,17.41) v8(61.95,17) v8(61.98,16.16) v8(61.98,15.73) v8(61.98,15.3) v8(61.98,14.89) v8(61.93,2.6) v8(61.93,2.17) v8(61.93,1.74) v8(61.93,1.33) v8(62.03,49.57) v8(62.03,49.13) v8(62.03,48.7) v8(62.03,48.3) v8(62.1,25.1) v8(62.1,24.67) v8(62.16,111.47) v8(62.16,111.04) v8(62.16,110.61) v8(62.16,110.2) v8(62.13,43.42) v8(62.13,42.99) v8(62.13,42.55) v8(62.13,42.15) v8(62.15,19.14) v8(62.15,18.7) v8(62.29,113.2) v8(62.29,112.8) v8(62.29,112.36) v8(62.29,111.93) v8(62.28,51.27) v8(62.28,50.84) v8(62.26,22.67) v8(62.26,22.23) v8(62.26,21.8) v8(62.36,29.12) v8(62.36,28.69) v8(62.36,28.25) v8(62.36,27.85) v8(62.38,18.27) v8(62.38,17.87) v8(62.38,17.43) v8(62.38,17) v8(62.36,2.6) v8(62.36,2.19) v8(62.36,1.76) v8(62.36,1.33) v8(62.46,49.57) v8(62.46,49.16) v8(62.46,48.73) v8(62.46,48.3) v8(62.41,16.16) v8(62.41,15.76) v8(62.41,15.33) v8(62.41,14.89) v8(62.59,111.47) v8(62.59,111.07) v8(62.59,110.63) v8(62.59,110.2) v8(62.54,46.42) v8(62.54,45.98) v8(62.54,45.55) v8(62.54,45.15) v8(62.56,43.42) v8(62.56,43.01) v8(62.56,42.58) v8(62.56,42.15) v8(62.56,30.77) v8(62.56,30.34) v8(62.54,25.13) v8(62.54,24.7) v8(62.69,22.67) v8(62.69,22.26) v8(62.69,21.83) v8(62.79,29.12) v8(62.79,28.71) v8(62.79,28.28) v8(62.79,27.85) v8(62.79,18.27) v8(62.79,17.84) v8(62.79,17.41) v8(62.79,17) v8(62.81,16.16) v8(62.81,15.73) v8(62.81,15.3) v8(62.81,14.89) v8(62.87,2.6) v8(62.87,2.17) v8(62.87,1.74) v8(62.87,1.33) v8(63,111.47) v8(63,111.04) v8(63,110.61) v8(63,110.2) v8(62.97,46.42) v8(62.97,46.01) v8(62.97,45.58) v8(62.97,45.15) v8(62.97,30.74) v8(62.97,30.31) v8(63.2,29.12) v8(63.2,28.69) v8(63.2,28.25) v8(63.2,27.85) v8(63.22,18.27) v8(63.22,17.87) v8(63.22,17.43) v8(63.22,17) v8(63.25,16.16) v8(63.25,15.76) v8(63.25,15.33) v8(63.25,14.89) v8(63.3,1.76) v8(63.3,1.33) v8(63.37,46.42) v8(63.37,45.98) v8(63.37,45.55) v8(63.37,45.15) v8(63.4,30.77) v8(63.4,30.34) v8(63.32,25.1) v8(63.32,24.67) v8(63.47,113.29) v8(63.47,112.86) v8(63.47,112.42) v8(63.47,112.02) v8(63.43,111.47) v8(63.43,111.07) v8(63.43,110.63) v8(63.43,110.2) v8(63.5,37.93) v8(63.5,37.5) v8(63.5,37.07) v8(63.5,36.66) v8(63.58,32.9) v8(63.58,32.47) v8(63.68,43.88) v8(63.68,43.44) v8(63.63,29.12) v8(63.63,28.71) v8(63.63,28.28) v8(63.63,27.85) v8(63.68,22.67) v8(63.68,22.26) v8(63.68,21.83) v8(63.7,16.21) v8(63.7,15.81) v8(63.7,15.38) v8(63.7,1.74) v8(63.7,1.33) v8(63.75,51.37) v8(63.75,50.94) v8(63.73,25.08) v8(63.73,24.65) v8(63.73,18.27) v8(63.73,17.84) v8(63.73,17.41) v8(63.73,17) v8(63.9,113.29) v8(63.9,112.88) v8(63.9,112.45) v8(63.9,112.02) v8(63.81,46.42) v8(63.81,46.01) v8(63.81,45.58) v8(63.81,45.15) v8(63.93,37.93) v8(63.93,37.53) v8(63.93,37.09) v8(63.93,36.66) v8(63.98,32.88) v8(63.98,32.45) v8(64.08,43.85) v8(64.08,43.42) v8(64.08,22.67) v8(64.08,22.23) v8(64.08,21.8) v8(64.16,51.34) v8(64.16,50.91) v8(64.19,49.54) v8(64.19,49.11) v8(64.19,48.68) v8(64.19,48.27) v8(64.16,25.1) v8(64.16,24.67) v8(64.16,18.27) v8(64.16,17.87) v8(64.16,17.43) v8(64.16,17) v8(64.11,16.21) v8(64.11,15.78) v8(64.11,15.35) v8(64.14,2.6) v8(64.14,2.19) v8(64.14,1.76) v8(64.14,1.33) v8(64.29,47.41) v8(64.29,46.97) v8(64.24,19.39) v8(64.24,18.96) v8(64.31,113.29) v8(64.31,112.86) v8(64.31,112.42) v8(64.31,112.02) v8(64.34,37.93) v8(64.34,37.5) v8(64.34,37.07) v8(64.34,36.66) v8(64.31,31.48) v8(64.31,31.05) v8(64.31,30.62) v8(64.31,30.21) v8(64.49,41.77) v8(64.49,41.34) v8(64.49,40.9) v8(64.49,40.5) v8(64.42,32.9) v8(64.42,32.47) v8(64.59,51.37) v8(64.59,50.94) v8(64.52,43.88) v8(64.52,43.44) v8(64.52,22.67) v8(64.52,22.26) v8(64.52,21.83) v8(64.57,18.27) v8(64.57,17.84) v8(64.57,17.41) v8(64.57,17) v8(64.54,16.21) v8(64.54,15.81) v8(64.54,15.38) v8(64.62,49.54) v8(64.62,49.13) v8(64.62,48.7) v8(64.62,48.27) v8(64.69,47.38) v8(64.69,46.95) v8(64.64,19.36) v8(64.64,18.93) v8(64.74,113.29) v8(64.74,112.88) v8(64.74,112.45) v8(64.74,112.02) v8(64.77,37.93) v8(64.77,37.53) v8(64.77,37.09) v8(64.77,36.66) v8(64.75,31.48) v8(64.75,31.07) v8(64.75,30.64) v8(64.75,30.21) v8(64.8,25.1) v8(64.8,24.67) v8(64.72,1.33) v8(64.92,41.77) v8(64.92,41.36) v8(64.92,40.93) v8(64.92,40.5) v8(65,18.27) v8(65,17.87) v8(65,17.43) v8(65,17) v8(65.02,49.54) v8(65.02,49.11) v8(65.02,48.68) v8(65.02,48.27) v8(65.1,22.59) v8(65.1,22.16) v8(65.08,19.39) v8(65.08,18.96) v8(65.13,47.41) v8(65.13,46.97) v8(65.15,31.48) v8(65.15,31.05) v8(65.15,30.62) v8(65.15,30.21) v8(65.2,25.08) v8(65.2,24.65) v8(65.15,1.33) v8(65.33,41.77) v8(65.33,41.34) v8(65.33,40.9) v8(65.33,40.5) v8(65.46,49.54) v8(65.46,49.13) v8(65.46,48.7) v8(65.46,48.27) v8(65.58,32.83) v8(65.58,32.39) v8(65.58,31.48) v8(65.58,31.07) v8(65.58,30.64) v8(65.58,30.21) v8(65.51,22.56) v8(65.51,22.13) v8(65.56,1.33) v8(65.69,46.42) v8(65.69,45.98) v8(65.69,45.55) v8(65.69,45.15) v8(65.69,37.78) v8(65.69,37.35) v8(65.63,25.1) v8(65.63,24.67) v8(65.76,41.77) v8(65.76,41.36) v8(65.76,40.93) v8(65.76,40.5) v8(65.81,35.67) v8(65.81,35.24) v8(65.99,51.27) v8(65.99,50.84) v8(65.99,49.41) v8(65.99,48.98) v8(65.99,32.8) v8(65.99,32.37) v8(65.94,22.59) v8(65.94,22.16) v8(65.99,1.33) v8(66.09,37.75) v8(66.09,37.32) v8(66.12,46.42) v8(66.12,46.01) v8(66.12,45.58) v8(66.12,45.15) v8(66.22,39.38) v8(66.22,38.95) v8(66.22,35.65) v8(66.22,35.21) v8(66.34,111.6) v8(66.34,111.17) v8(66.34,110.73) v8(66.34,110.33) v8(66.4,51.24) v8(66.4,50.81) v8(66.4,49.39) v8(66.4,48.96) v8(66.4,43.93) v8(66.4,43.49) v8(66.4,43.06) v8(66.4,42.66) v8(66.4,29.12) v8(66.4,28.69) v8(66.4,28.25) v8(66.4,27.85) v8(66.42,32.83) v8(66.42,32.39) v8(66.5,25.1) v8(66.5,24.67) v8(66.42,19.44) v8(66.42,19.03) v8(66.42,18.6) v8(66.42,18.02) v8(66.42,17.59) v8(66.52,46.42) v8(66.52,45.98) v8(66.52,45.55) v8(66.52,45.15) v8(66.52,37.78) v8(66.52,37.35) v8(66.55,2.63) v8(66.55,2.19) v8(66.55,1.76) v8(66.55,1.36) v8(66.7,41.92) v8(66.7,41.49) v8(66.62,39.35) v8(66.62,38.92) v8(66.65,35.67) v8(66.65,35.24) v8(66.65,22.67) v8(66.65,22.26) v8(66.65,21.83) v8(66.77,111.6) v8(66.77,111.19) v8(66.77,110.76) v8(66.77,110.33) v8(66.83,51.27) v8(66.83,50.84) v8(66.83,49.41) v8(66.83,48.98) v8(66.83,43.93) v8(66.83,43.52) v8(66.83,43.09) v8(66.83,42.66) v8(66.83,29.12) v8(66.83,28.71) v8(66.83,28.28) v8(66.83,27.85) v8(66.9,25.08) v8(66.9,24.65) v8(66.83,19.44) v8(66.83,19.01) v8(66.83,18.58) v8(66.83,17.99) v8(66.83,17.56) v8(66.96,46.42) v8(66.96,46.01) v8(66.96,45.58) v8(66.96,45.15) v8(66.98,2.63) v8(66.98,2.22) v8(66.98,1.79) v8(66.98,1.36) v8(67.06,39.38) v8(67.06,38.95) v8(67.06,22.67) v8(67.06,22.23) v8(67.06,21.8) v8(67.18,111.6) v8(67.18,111.17) v8(67.18,110.73) v8(67.18,110.33) v8(67.11,41.89) v8(67.11,41.46) v8(67.23,43.93) v8(67.23,43.49) v8(67.23,43.06) v8(67.23,42.66) v8(67.29,38.21) v8(67.29,37.78) v8(67.29,37.35) v8(67.29,36.94) v8(67.29,33.26) v8(67.29,32.83) v8(67.29,32.39) v8(67.29,31.99) v8(67.21,31.18) v8(67.21,30.74) v8(67.21,30.31) v8(67.21,29.91) v8(67.23,29.12) v8(67.23,28.69) v8(67.23,28.25) v8(67.23,27.85) v8(67.26,19.44) v8(67.26,19.03) v8(67.26,18.6) v8(67.26,18.02) v8(67.26,17.59) v8(67.34,35.75) v8(67.34,35.32) v8(67.34,34.88) v8(67.34,34.48) v8(67.34,25.1) v8(67.34,24.67) v8(67.39,2.63) v8(67.39,2.19) v8(67.39,1.76) v8(67.39,1.36) v8(67.44,49.54) v8(67.44,49.11) v8(67.44,48.68) v8(67.44,48.27) v8(67.49,22.67) v8(67.49,22.26) v8(67.49,21.83) v8(67.54,41.92) v8(67.54,41.49) v8(67.61,111.6) v8(67.61,111.19) v8(67.61,110.76) v8(67.61,110.33) v8(67.67,43.93) v8(67.67,43.52) v8(67.67,43.09) v8(67.67,42.66) v8(67.64,31.18) v8(67.64,30.77) v8(67.64,30.34) v8(67.64,29.91) v8(67.67,29.12) v8(67.67,28.71) v8(67.67,28.28) v8(67.67,27.85) v8(67.77,46.16) v8(67.77,45.73) v8(67.72,38.21) v8(67.72,37.8) v8(67.72,37.37) v8(67.72,36.94) v8(67.77,35.75) v8(67.77,35.34) v8(67.77,34.91) v8(67.77,34.48) v8(67.72,33.26) v8(67.72,32.85) v8(67.72,32.42) v8(67.72,31.99) v8(67.79,15.3) v8(67.79,14.89) v8(67.79,14.46) v8(67.87,49.54) v8(67.87,49.13) v8(67.87,48.7) v8(67.87,48.27) v8(67.82,2.63) v8(67.82,2.22) v8(67.82,1.79) v8(67.82,1.36) v8(68,44.82) v8(68,44.38) v8(68.05,31.18) v8(68.05,30.74) v8(68.05,30.31) v8(68.05,29.91) v8(68.12,47.43) v8(68.12,47) v8(68.17,46.14) v8(68.17,45.7) v8(68.12,38.21) v8(68.12,37.78) v8(68.12,37.35) v8(68.12,36.94) v8(68.17,35.75) v8(68.17,35.32) v8(68.17,34.88) v8(68.17,34.48) v8(68.12,33.26) v8(68.12,32.83) v8(68.12,32.39) v8(68.12,31.99) v8(68.15,22.67) v8(68.15,22.26) v8(68.15,21.83) v8(68.2,15.3) v8(68.2,14.87) v8(68.2,14.44) v8(68.28,49.54) v8(68.28,49.11) v8(68.28,48.68) v8(68.28,48.27) v8(68.4,44.79) v8(68.4,44.36) v8(68.48,43.52) v8(68.48,43.09) v8(68.48,31.18) v8(68.48,30.77) v8(68.48,30.34) v8(68.48,29.91) v8(68.43,2.52) v8(68.43,2.09) v8(68.43,1.66) v8(68.43,1.25) v8(68.53,47.41) v8(68.53,46.97) v8(68.56,38.21) v8(68.56,37.8) v8(68.56,37.37) v8(68.56,36.94) v8(68.56,33.26) v8(68.56,32.85) v8(68.56,32.42) v8(68.56,31.99) v8(68.56,22.67) v8(68.56,22.23) v8(68.56,21.8) v8(68.61,46.16) v8(68.61,45.73) v8(68.61,35.75) v8(68.61,35.34) v8(68.61,34.91) v8(68.61,34.48) v8(68.63,15.3) v8(68.63,14.89) v8(68.63,14.46) v8(68.71,49.54) v8(68.71,49.13) v8(68.71,48.7) v8(68.71,48.27) v8(68.83,44.82) v8(68.83,44.38) v8(68.89,43.49) v8(68.89,43.06) v8(68.86,2.52) v8(68.86,2.12) v8(68.86,1.69) v8(68.86,1.25) v8(68.96,47.43) v8(68.96,47) v8(68.99,22.67) v8(68.99,22.26) v8(68.99,21.83) v8(69.27,2.52) v8(69.27,2.09) v8(69.27,1.66) v8(69.27,1.25) v8(69.32,43.52) v8(69.32,43.09) v8(69.32,15.35) v8(69.32,14.94) v8(69.32,14.51) v8(69.42,51.24) v8(69.42,50.81) v8(69.6,49.08) v8(69.6,48.65) v8(69.67,22.64) v8(69.67,22.23) v8(69.67,21.8) v8(69.7,2.52) v8(69.7,2.12) v8(69.7,1.69) v8(69.7,1.25) v8(69.72,15.35) v8(69.72,14.92) v8(69.72,14.49) v8(69.83,51.22) v8(69.83,50.78) v8(70,49.06) v8(70,48.63) v8(69.93,46.19) v8(69.93,45.76) v8(69.93,45.32) v8(69.93,44.92) v8(70,30.34) v8(70,29.91) v8(70.08,22.64) v8(70.08,22.21) v8(70.08,21.78) v8(70.16,15.35) v8(70.16,14.94) v8(70.16,14.51) v8(70.26,51.24) v8(70.26,50.81) v8(70.28,43.7) v8(70.28,43.27) v8(70.28,42.83) v8(70.28,42.43) v8(70.36,46.19) v8(70.36,45.78) v8(70.36,45.35) v8(70.36,44.92) v8(70.33,35.49) v8(70.33,35.06) v8(70.33,34.63) v8(70.33,34.22) v8(70.43,49.08) v8(70.43,48.65) v8(70.41,30.31) v8(70.41,29.88) v8(70.51,22.64) v8(70.51,22.23) v8(70.51,21.8) v8(70.77,46.19) v8(70.77,45.76) v8(70.77,45.32) v8(70.77,44.92) v8(70.71,43.7) v8(70.71,43.29) v8(70.71,42.86) v8(70.71,42.43) v8(70.77,35.49) v8(70.77,35.09) v8(70.77,34.66) v8(70.77,34.22) v8(70.84,30.34) v8(70.84,29.91) v8(71.07,22.34) v8(71.07,21.9) v8(71.2,46.19) v8(71.2,45.78) v8(71.2,45.35) v8(71.2,44.92) v8(71.12,43.7) v8(71.12,43.27) v8(71.12,42.83) v8(71.12,42.43) v8(71.17,35.49) v8(71.17,35.06) v8(71.17,34.63) v8(71.17,34.22) v8(71.2,15.28) v8(71.2,14.87) v8(71.2,14.44) v8(71.48,22.31) v8(71.48,21.88) v8(71.55,43.7) v8(71.55,43.29) v8(71.55,42.86) v8(71.55,42.43) v8(71.6,35.49) v8(71.6,35.09) v8(71.6,34.66) v8(71.6,34.22) v8(71.6,15.28) v8(71.6,14.84) v8(71.6,14.41) v8(71.73,29.7) v8(71.73,29.27) v8(71.91,22.34) v8(71.91,21.9) v8(72.04,15.28) v8(72.04,14.87) v8(72.04,14.44) v8(72.14,29.68) v8(72.14,29.25) v8(72.57,29.7) v8(72.57,29.27) v8(72.64,22.31) v8(72.64,21.88) v8(73,2.85) v8(73,2.42) v8(73,1.99) v8(73,1.58) v8(73.05,22.29) v8(73.05,21.85) v8(73.13,48.88) v8(73.13,48.45) v8(73.18,38.8) v8(73.18,38.36) v8(73.28,43.75) v8(73.28,43.32) v8(73.28,42.88) v8(73.28,42.48) v8(73.48,22.31) v8(73.48,21.88) v8(73.43,2.85) v8(73.43,2.45) v8(73.43,2.02) v8(73.43,1.58) v8(73.53,48.85) v8(73.53,48.42) v8(73.58,38.77) v8(73.58,38.34) v8(73.64,40.93) v8(73.64,40.5) v8(73.64,40.07) v8(73.64,39.66) v8(73.71,43.75) v8(73.71,43.34) v8(73.71,42.91) v8(73.71,42.48) v8(73.86,4.89) v8(73.86,4.45) v8(73.86,4.02) v8(73.86,3.62) v8(73.84,2.85) v8(73.84,2.42) v8(73.84,1.99) v8(73.84,1.58) v8(73.97,48.88) v8(73.97,48.45) v8(74.07,40.93) v8(74.07,40.52) v8(74.07,40.09) v8(74.07,39.66) v8(74.02,38.8) v8(74.02,38.36) v8(74.07,31.1) v8(74.07,30.67) v8(74.12,43.75) v8(74.12,43.32) v8(74.12,42.88) v8(74.12,42.48) v8(74.24,19.36) v8(74.24,18.93) v8(74.24,18.5) v8(74.24,18.09) v8(74.22,17.38) v8(74.22,16.95) v8(74.22,16.52) v8(74.22,16.11) v8(74.3,4.89) v8(74.3,4.48) v8(74.3,4.05) v8(74.3,3.62) v8(74.27,2.85) v8(74.27,2.45) v8(74.27,2.02) v8(74.27,1.58) v8(74.47,40.93) v8(74.47,40.5) v8(74.47,40.07) v8(74.47,39.66) v8(74.47,31.07) v8(74.47,30.64) v8(74.42,22.9) v8(74.42,22.49) v8(74.42,22.06) v8(74.55,43.75) v8(74.55,43.34) v8(74.55,42.91) v8(74.55,42.48) v8(74.68,19.36) v8(74.68,18.96) v8(74.68,18.53) v8(74.68,18.09) v8(74.65,17.38) v8(74.65,16.98) v8(74.65,16.55) v8(74.65,16.11) v8(74.7,4.89) v8(74.7,4.45) v8(74.7,4.02) v8(74.7,3.62) v8(74.73,15.55) v8(74.73,15.12) v8(74.73,14.69) v8(74.73,14.28) v8(74.91,40.93) v8(74.91,40.52) v8(74.91,40.09) v8(74.91,39.66) v8(74.83,38.47) v8(74.83,38.03) v8(74.83,37.6) v8(74.83,37.2) v8(74.91,31.1) v8(74.91,30.67) v8(74.83,22.9) v8(74.83,22.46) v8(74.83,22.03) v8(75.03,47.05) v8(75.03,46.62) v8(75.08,19.36) v8(75.08,18.93) v8(75.08,18.5) v8(75.08,18.09) v8(75.06,17.38) v8(75.06,16.95) v8(75.06,16.52) v8(75.06,16.11) v8(75.16,36.48) v8(75.16,36.05) v8(75.16,15.55) v8(75.16,15.15) v8(75.16,14.72) v8(75.16,14.28) v8(75.13,4.89) v8(75.13,4.48) v8(75.13,4.05) v8(75.13,3.62) v8(75.26,38.47) v8(75.26,38.06) v8(75.26,37.63) v8(75.26,37.2) v8(75.26,22.9) v8(75.26,22.49) v8(75.26,22.06) v8(75.44,47.03) v8(75.44,46.59) v8(75.44,25.41) v8(75.44,25) v8(75.44,24.57) v8(75.49,17.38) v8(75.49,16.98) v8(75.49,16.55) v8(75.49,16.11) v8(75.59,65.41) v8(75.59,64.98) v8(75.59,64.55) v8(75.59,64.14) v8(75.54,41.03) v8(75.54,40.6) v8(75.57,36.46) v8(75.57,36.03) v8(75.51,19.36) v8(75.51,18.96) v8(75.51,18.53) v8(75.51,18.09) v8(75.57,15.55) v8(75.57,15.12) v8(75.57,14.69) v8(75.57,14.28) v8(75.67,38.47) v8(75.67,38.03) v8(75.67,37.6) v8(75.67,37.2) v8(75.72,103.87) v8(75.72,103.44) v8(75.72,103.01) v8(75.72,102.6) v8(75.72,30.77) v8(75.72,30.34) v8(75.9,93.96) v8(75.9,93.53) v8(75.9,93.1) v8(75.9,92.69) v8(75.85,91.53) v8(75.85,91.09) v8(75.85,90.66) v8(75.85,90.26) v8(75.87,47.05) v8(75.87,46.62) v8(75.85,25.41) v8(75.85,24.98) v8(75.85,24.55) v8(75.82,23.73) v8(75.82,23.33) v8(75.82,22.9) v8(75.95,41.01) v8(75.95,40.57) v8(76,36.48) v8(76,36.05) v8(76,15.55) v8(76,15.15) v8(76,14.72) v8(76,14.28) v8(76.02,65.41) v8(76.02,65.01) v8(76.02,64.58) v8(76.02,64.14) v8(76.1,38.47) v8(76.1,38.06) v8(76.1,37.63) v8(76.1,37.2) v8(76.07,5.27) v8(76.07,4.84) v8(76.07,4.43) v8(76.15,103.87) v8(76.15,103.46) v8(76.15,103.03) v8(76.15,102.6) v8(76.12,30.74) v8(76.12,30.31) v8(76.18,20.23) v8(76.18,19.82) v8(76.18,19.39) v8(76.28,91.53) v8(76.28,91.12) v8(76.28,90.69) v8(76.28,90.26) v8(76.28,45.76) v8(76.28,45.32) v8(76.28,25.41) v8(76.28,25) v8(76.28,24.57) v8(76.23,23.73) v8(76.23,23.3) v8(76.23,22.87) v8(76.23,18.07) v8(76.23,17.64) v8(76.23,17.21) v8(76.23,16.8) v8(76.33,93.96) v8(76.33,93.56) v8(76.33,93.13) v8(76.33,92.69) v8(76.38,41.03) v8(76.38,40.6) v8(76.56,103.87) v8(76.56,103.44) v8(76.56,103.01) v8(76.56,102.6) v8(76.56,84.92) v8(76.56,84.49) v8(76.56,84.06) v8(76.56,83.65) v8(76.56,30.77) v8(76.56,30.34) v8(76.58,20.23) v8(76.58,19.8) v8(76.58,19.36) v8(76.51,5.29) v8(76.51,4.86) v8(76.51,4.43) v8(76.56,2.8) v8(76.56,2.37) v8(76.56,1.94) v8(76.56,1.53) v8(76.66,60.97) v8(76.66,60.54) v8(76.66,60.11) v8(76.66,59.7) v8(76.68,45.73) v8(76.68,45.3) v8(76.66,23.73) v8(76.66,23.33) v8(76.66,22.9) v8(76.66,18.07) v8(76.66,17.66) v8(76.66,17.23) v8(76.66,16.8) v8(76.73,93.96) v8(76.73,93.53) v8(76.73,93.1) v8(76.73,92.69) v8(76.99,103.87) v8(76.99,103.46) v8(76.99,103.03) v8(76.99,102.6) v8(76.99,84.92) v8(76.99,84.52) v8(76.99,84.08) v8(76.99,83.65) v8(76.96,40.22) v8(76.96,39.79) v8(76.96,39.35) v8(76.96,38.95) v8(76.96,38.19) v8(76.96,37.75) v8(76.94,26.1) v8(76.94,25.69) v8(76.94,25.26) v8(76.91,5.7) v8(76.91,5.27) v8(76.91,4.84) v8(76.91,4.43) v8(76.99,2.8) v8(76.99,2.4) v8(76.99,1.97) v8(76.99,1.53) v8(77.09,60.97) v8(77.09,60.56) v8(77.09,60.13) v8(77.09,59.7) v8(77.01,37.04) v8(77.01,36.61) v8(77.01,36.18) v8(77.01,35.77) v8(77.01,20.23) v8(77.01,19.82) v8(77.01,19.39) v8(77.06,18.07) v8(77.06,17.64) v8(77.06,17.21) v8(77.06,16.8) v8(77.17,93.96) v8(77.17,93.56) v8(77.17,93.13) v8(77.17,92.69) v8(77.14,52.03) v8(77.14,51.6) v8(77.12,45.76) v8(77.12,45.32) v8(77.27,96.02) v8(77.27,95.59) v8(77.27,95.16) v8(77.27,94.75) v8(77.39,84.92) v8(77.39,84.49) v8(77.39,84.06) v8(77.39,83.65) v8(77.32,63.08) v8(77.32,62.65) v8(77.32,62.21) v8(77.32,61.81) v8(77.39,40.22) v8(77.39,39.81) v8(77.39,39.38) v8(77.39,38.95) v8(77.37,38.16) v8(77.37,37.73) v8(77.34,26.1) v8(77.34,25.66) v8(77.34,25.23) v8(77.34,5.7) v8(77.34,5.29) v8(77.34,4.86) v8(77.34,4.43) v8(77.39,2.8) v8(77.39,2.37) v8(77.39,1.94) v8(77.39,1.53) v8(77.45,37.04) v8(77.45,36.64) v8(77.45,36.2) v8(77.45,35.77) v8(77.47,34.33) v8(77.47,33.89) v8(77.47,33.46) v8(77.47,33.06) v8(77.5,18.07) v8(77.5,17.66) v8(77.5,17.23) v8(77.5,16.8) v8(77.5,7.91) v8(77.5,7.48) v8(77.5,7.05) v8(77.5,6.64) v8(77.52,91.55) v8(77.52,91.12) v8(77.52,90.69) v8(77.52,90.28) v8(77.55,52) v8(77.55,51.57) v8(77.7,96.02) v8(77.7,95.62) v8(77.7,95.18) v8(77.7,94.75) v8(77.75,63.08) v8(77.75,62.67) v8(77.75,62.24) v8(77.75,61.81) v8(77.78,53.88) v8(77.78,53.45) v8(77.8,40.22) v8(77.8,39.79) v8(77.8,39.35) v8(77.8,38.95) v8(77.8,38.19) v8(77.8,37.75) v8(77.78,26.1) v8(77.78,25.69) v8(77.78,25.26) v8(77.83,84.92) v8(77.83,84.52) v8(77.83,84.08) v8(77.83,83.65) v8(77.9,68.92) v8(77.9,68.49) v8(77.9,68.06) v8(77.9,67.65) v8(77.85,37.04) v8(77.85,36.61) v8(77.85,36.18) v8(77.85,35.77) v8(77.9,34.33) v8(77.9,33.92) v8(77.9,33.49) v8(77.9,33.06) v8(77.83,2.8) v8(77.83,2.4) v8(77.83,1.97) v8(77.83,1.53) v8(77.95,91.55) v8(77.95,91.14) v8(77.95,90.71) v8(77.95,90.28) v8(78,82.08) v8(78,81.65) v8(78,81.21) v8(78,80.81) v8(77.98,80.25) v8(77.98,79.82) v8(77.98,79.38) v8(77.98,78.98) v8(77.93,66.63) v8(77.93,66.2) v8(77.93,65.77) v8(77.93,65.36) v8(77.93,59.83) v8(77.93,59.39) v8(77.93,58.96) v8(77.93,58.56) v8(77.98,51.6) v8(77.98,21.8) v8(77.98,21.37) v8(77.98,20.94) v8(77.98,20.53) v8(77.93,7.91) v8(77.93,7.5) v8(77.93,7.07) v8(77.93,6.64) v8(78.16,63.08) v8(78.16,62.65) v8(78.16,62.21) v8(78.16,61.81) v8(78.18,53.86) v8(78.18,53.43) v8(78.18,51.11) v8(78.18,50.68) v8(78.16,19.92) v8(78.16,19.52) v8(78.16,19.09) v8(78.23,40.22) v8(78.23,39.81) v8(78.23,39.38) v8(78.23,38.95) v8(78.28,37.04) v8(78.28,36.64) v8(78.28,36.2) v8(78.28,35.77) v8(78.23,5.75) v8(78.23,5.32) v8(78.23,4.89) v8(78.23,4.48) v8(78.39,96.07) v8(78.39,95.64) v8(78.39,95.21) v8(78.39,94.8) v8(78.36,91.55) v8(78.36,91.12) v8(78.36,90.69) v8(78.36,90.28) v8(78.33,68.92) v8(78.33,68.51) v8(78.33,68.08) v8(78.33,67.65) v8(78.36,66.63) v8(78.36,66.23) v8(78.36,65.8) v8(78.36,65.36) v8(78.36,59.83) v8(78.36,59.42) v8(78.36,58.99) v8(78.36,58.56) v8(78.31,34.33) v8(78.31,33.89) v8(78.31,33.46) v8(78.31,33.06) v8(78.33,7.91) v8(78.33,7.48) v8(78.33,7.05) v8(78.33,6.64) v8(78.44,82.08) v8(78.44,81.67) v8(78.44,81.24) v8(78.44,80.81) v8(78.41,80.25) v8(78.41,79.84) v8(78.41,79.41) v8(78.41,78.98) v8(78.41,21.8) v8(78.41,21.4) v8(78.41,20.96) v8(78.41,20.53) v8(78.56,99.04) v8(78.56,98.61) v8(78.56,98.18) v8(78.56,97.77) v8(78.59,63.08) v8(78.59,62.67) v8(78.59,62.24) v8(78.59,61.81) v8(78.51,51.6) v8(78.59,51.09) v8(78.59,50.66) v8(78.56,19.92) v8(78.56,19.49) v8(78.56,19.06) v8(78.59,2.83) v8(78.59,2.4) v8(78.59,1.97) v8(78.59,1.56) v8(78.61,53.88) v8(78.61,53.45) v8(78.61,52.97) v8(78.61,52.54) v8(78.61,50.25) v8(78.61,49.82) v8(78.66,5.75) v8(78.66,5.34) v8(78.66,4.91) v8(78.66,4.48) v8(78.79,91.55) v8(78.79,91.14) v8(78.79,90.71) v8(78.79,90.28) v8(78.74,68.92) v8(78.74,68.49) v8(78.74,68.06) v8(78.74,67.65) v8(78.77,66.63) v8(78.77,66.2) v8(78.77,65.77) v8(78.77,65.36) v8(78.74,34.33) v8(78.74,33.92) v8(78.74,33.49) v8(78.74,33.06) v8(78.77,7.91) v8(78.77,7.5) v8(78.77,7.07) v8(78.77,6.64) v8(78.82,96.07) v8(78.82,95.67) v8(78.82,95.23) v8(78.82,94.8) v8(78.84,82.08) v8(78.84,81.65) v8(78.84,81.21) v8(78.84,80.81) v8(78.82,80.25) v8(78.82,79.82) v8(78.82,79.38) v8(78.82,78.98) v8(78.82,21.8) v8(78.82,21.37) v8(78.82,20.94) v8(78.82,20.53) v8(78.99,99.04) v8(78.99,98.64) v8(78.99,98.21) v8(78.99,97.77) v8(78.92,52) v8(78.92,51.57) v8(78.99,19.92) v8(78.99,19.52) v8(78.99,19.09) v8(79.05,103.18) v8(79.05,102.75) v8(79.05,102.32) v8(79.05,101.91) v8(79.04,53.44) v8(79.02,52.94) v8(79.02,52.51) v8(79.02,51.11) v8(79.02,50.68) v8(79.02,50.23) v8(79.02,49.79) v8(79.07,5.75) v8(79.07,5.32) v8(79.07,4.89) v8(79.07,4.48) v8(79.02,2.83) v8(79.02,2.42) v8(79.02,1.99) v8(79.02,1.56) v8(79.17,68.92) v8(79.17,68.51) v8(79.17,68.08) v8(79.17,67.65) v8(79.2,66.63) v8(79.2,66.23) v8(79.2,65.8) v8(79.2,65.36) v8(79.27,82.08) v8(79.27,81.67) v8(79.27,81.24) v8(79.27,80.81) v8(79.25,80.25) v8(79.25,79.84) v8(79.25,79.41) v8(79.25,78.98) v8(79.25,21.8) v8(79.25,21.4) v8(79.25,20.96) v8(79.25,20.53) v8(79.4,99.04) v8(79.4,98.61) v8(79.4,98.18) v8(79.4,97.77) v8(79.38,90.81) v8(79.38,90.38) v8(79.38,89.95) v8(79.38,89.54) v8(79.4,10.09) v8(79.4,9.66) v8(79.4,9.23) v8(79.4,8.82) v8(79.48,103.18) v8(79.48,102.78) v8(79.48,102.35) v8(79.48,101.91) v8(79.5,77.38) v8(79.5,76.95) v8(79.5,76.51) v8(79.5,76.11) v8(79.45,53.44) v8(79.45,52.97) v8(79.45,52.54) v8(79.45,50.25) v8(79.45,49.82) v8(79.5,5.75) v8(79.5,5.34) v8(79.5,4.91) v8(79.5,4.48) v8(79.43,2.83) v8(79.43,1.56) v8(79.66,23.05) v8(79.66,22.64) v8(79.66,22.21) v8(79.68,20.2) v8(79.68,19.77) v8(79.68,19.34) v8(79.68,18.93) v8(79.73,7.93) v8(79.73,7.5) v8(79.73,7.07) v8(79.73,6.66) v8(79.88,103.18) v8(79.88,102.75) v8(79.88,102.32) v8(79.88,101.91) v8(79.83,99.04) v8(79.83,98.64) v8(79.83,98.21) v8(79.83,97.77) v8(79.81,90.81) v8(79.81,90.41) v8(79.81,89.98) v8(79.81,89.54) v8(79.83,65.47) v8(79.83,65.03) v8(79.83,64.6) v8(79.83,64.2) v8(79.83,10.09) v8(79.83,9.69) v8(79.83,9.26) v8(79.83,8.82) v8(79.86,2.83) v8(79.86,1.56) v8(79.93,77.38) v8(79.93,76.97) v8(79.93,76.54) v8(79.93,76.11) v8(80.06,23.05) v8(80.06,22.62) v8(80.06,22.18) v8(80.11,20.2) v8(80.11,19.8) v8(80.11,19.36) v8(80.11,18.93) v8(80.16,7.93) v8(80.16,7.53) v8(80.16,7.1) v8(80.16,6.66) v8(80.24,68.62) v8(80.24,68.18) v8(80.24,67.75) v8(80.24,67.35) v8(80.26,65.47) v8(80.26,65.06) v8(80.26,64.63) v8(80.26,64.2) v8(80.24,10.09) v8(80.24,9.66) v8(80.24,9.23) v8(80.24,8.82) v8(80.32,103.18) v8(80.32,102.78) v8(80.32,102.35) v8(80.32,101.91) v8(80.49,23.05) v8(80.49,22.64) v8(80.49,22.21) v8(80.52,20.2) v8(80.52,19.77) v8(80.52,19.34) v8(80.52,18.93) v8(80.57,7.93) v8(80.57,7.5) v8(80.57,7.07) v8(80.57,6.66) v8(80.67,68.62) v8(80.67,68.21) v8(80.67,67.78) v8(80.67,67.35) v8(80.67,10.09) v8(80.67,9.69) v8(80.67,9.26) v8(80.67,8.82) v8(80.77,5.8) v8(80.77,5.37) v8(80.77,4.94) v8(80.77,4.53) v8(80.93,75.83) v8(80.93,75.4) v8(80.93,74.97) v8(80.93,74.56) v8(81,60.61) v8(81,60.18) v8(81,59.75) v8(81,59.34) v8(80.95,20.2) v8(80.95,19.8) v8(80.95,19.36) v8(80.95,18.93) v8(81,7.93) v8(81,7.53) v8(81,7.1) v8(81,6.66) v8(81.08,86.27) v8(81.08,85.84) v8(81.08,85.4) v8(81.08,85) v8(81.05,82.97) v8(81.05,82.53) v8(81.05,82.1) v8(81.05,81.7) v8(81.1,62.98) v8(81.1,62.54) v8(81.1,62.11) v8(81.1,61.71) v8(81.2,5.8) v8(81.2,5.39) v8(81.2,4.96) v8(81.2,4.53) v8(81.23,80.35) v8(81.23,79.92) v8(81.23,79.49) v8(81.23,79.08) v8(81.36,75.83) v8(81.36,75.42) v8(81.36,74.99) v8(81.36,74.56) v8(81.48,82.97) v8(81.48,82.56) v8(81.48,82.13) v8(81.48,81.7) v8(81.43,60.61) v8(81.43,60.21) v8(81.43,59.78) v8(81.43,59.34) v8(81.51,86.27) v8(81.51,85.86) v8(81.51,85.43) v8(81.51,85) v8(81.53,62.98) v8(81.53,62.57) v8(81.53,62.14) v8(81.53,61.71) v8(81.66,80.35) v8(81.66,79.94) v8(81.66,79.51) v8(81.66,79.08) v8(81.61,5.8) v8(81.61,5.37) v8(81.61,4.94) v8(81.61,4.53) v8(81.76,75.83) v8(81.76,75.4) v8(81.76,74.97) v8(81.76,74.56) v8(81.79,8.82) v8(81.79,8.39) v8(81.79,7.96) v8(81.79,7.55) v8(81.89,82.97) v8(81.89,82.53) v8(81.89,82.1) v8(81.89,81.7) v8(81.86,11.92) v8(81.86,11.49) v8(81.86,11.06) v8(81.86,10.65) v8(81.92,86.27) v8(81.92,85.84) v8(81.92,85.4) v8(81.92,85) v8(81.97,30.74) v8(81.97,30.34) v8(81.97,29.91) v8(82.07,80.35) v8(82.07,79.92) v8(82.07,79.49) v8(82.07,79.08) v8(82.04,5.39) v8(82.04,4.96) v8(82.04,4.53) v8(82.2,75.83) v8(82.2,75.42) v8(82.2,74.99) v8(82.2,74.56) v8(82.2,70.06) v8(82.2,69.63) v8(82.2,69.2) v8(82.2,68.79) v8(82.14,29.07) v8(82.14,28.66) v8(82.14,28.23) v8(82.14,27.8) v8(82.3,11.92) v8(82.3,11.52) v8(82.3,11.08) v8(82.3,10.65) v8(82.22,8.82) v8(82.22,8.42) v8(82.22,7.99) v8(82.22,7.55) v8(82.35,86.27) v8(82.35,85.86) v8(82.35,85.43) v8(82.35,85) v8(82.32,82.97) v8(82.32,82.56) v8(82.32,82.13) v8(82.32,81.7) v8(82.35,62.77) v8(82.35,62.34) v8(82.35,61.91) v8(82.35,61.5) v8(82.37,30.74) v8(82.37,30.31) v8(82.37,29.88) v8(82.32,26.37) v8(82.32,25.97) v8(82.32,25.54) v8(82.4,24.57) v8(82.4,24.17) v8(82.4,23.73) v8(82.37,17.92) v8(82.37,17.51) v8(82.37,17.08) v8(82.5,80.35) v8(82.5,79.94) v8(82.5,79.51) v8(82.5,79.08) v8(82.47,68.03) v8(82.47,67.6) v8(82.47,67.17) v8(82.47,66.76) v8(82.42,23.15) v8(82.42,22.74) v8(82.42,22.31) v8(82.42,21.6) v8(82.42,21.19) v8(82.42,20.76) v8(82.42,19.85) v8(82.42,19.44) v8(82.42,19.01) v8(82.63,70.06) v8(82.63,69.66) v8(82.63,69.22) v8(82.63,68.79) v8(82.7,29.27) v8(82.7,28.86) v8(82.7,28.43) v8(82.7,28) v8(82.7,11.92) v8(82.7,11.49) v8(82.7,11.06) v8(82.7,10.65) v8(82.63,8.82) v8(82.63,8.39) v8(82.63,7.96) v8(82.63,7.55) v8(82.78,62.77) v8(82.78,62.37) v8(82.78,61.93) v8(82.78,61.5) v8(82.78,56.63) v8(82.78,56.19) v8(82.78,55.76) v8(82.78,55.36) v8(82.8,30.74) v8(82.8,30.34) v8(82.8,29.91) v8(82.73,26.37) v8(82.73,25.94) v8(82.73,25.51) v8(82.8,24.57) v8(82.8,24.14) v8(82.8,23.71) v8(82.78,17.92) v8(82.78,17.48) v8(82.78,17.05) v8(82.88,44.26) v8(82.88,43.85) v8(82.88,43.42) v8(82.88,42.99) v8(82.88,41.95) v8(82.88,41.54) v8(82.88,41.11) v8(82.88,40.68) v8(82.88,38.59) v8(82.88,38.19) v8(82.88,37.75) v8(82.88,37.32) v8(82.88,33.72) v8(82.88,33.31) v8(82.88,32.88) v8(82.88,32.45) v8(82.83,23.15) v8(82.83,22.72) v8(82.83,22.29) v8(82.83,21.6) v8(82.83,21.17) v8(82.83,20.74) v8(82.83,19.85) v8(82.83,19.42) v8(82.83,18.98) v8(82.91,68.03) v8(82.91,67.62) v8(82.91,67.19) v8(82.91,66.76) v8(83.06,8.82) v8(83.06,8.42) v8(83.06,7.99) v8(83.06,7.55) v8(83.16,26.37) v8(83.16,25.97) v8(83.16,25.54) v8(83.13,11.92) v8(83.13,11.52) v8(83.13,11.08) v8(83.13,10.65) v8(83.21,56.63) v8(83.21,56.22) v8(83.21,55.79) v8(83.21,55.36) v8(83.24,48.12) v8(83.24,47.69) v8(83.24,24.57) v8(83.24,24.17) v8(83.24,23.73) v8(83.26,23.15) v8(83.26,22.74) v8(83.26,22.31) v8(83.26,21.6) v8(83.26,21.19) v8(83.26,20.76) v8(83.26,19.85) v8(83.26,19.44) v8(83.26,19.01) v8(83.21,17.92) v8(83.21,17.51) v8(83.21,17.08) v8(83.49,27.49) v8(83.49,27.09) v8(83.49,26.65) v8(83.49,26.22) v8(83.59,76.18) v8(83.59,75.75) v8(83.59,75.32) v8(83.59,74.91) v8(83.59,44.41) v8(83.59,44) v8(83.59,43.57) v8(83.59,43.14) v8(83.54,42.22) v8(83.54,41.82) v8(83.54,41.39) v8(83.54,40.95) v8(83.57,39.91) v8(83.57,39.51) v8(83.57,39.07) v8(83.57,38.64) v8(83.54,37.75) v8(83.54,37.35) v8(83.54,36.92) v8(83.54,36.48) v8(83.57,35.42) v8(83.57,35.01) v8(83.57,34.58) v8(83.57,34.15) v8(83.57,33.44) v8(83.57,33.03) v8(83.57,32.6) v8(83.57,32.17) v8(83.57,31.4) v8(83.57,31) v8(83.57,30.57) v8(83.57,30.13) v8(83.57,29.32) v8(83.57,28.91) v8(83.57,28.48) v8(83.57,28.05) v8(83.69,95.01) v8(83.69,94.57) v8(83.69,94.14) v8(83.69,93.74) v8(83.62,66.94) v8(83.62,66.51) v8(83.62,66.08) v8(83.62,65.67) v8(83.64,48.09) v8(83.64,47.66) v8(84.02,76.18) v8(84.02,75.78) v8(84.02,75.35) v8(84.02,74.91) v8(84.05,66.94) v8(84.05,66.53) v8(84.05,66.1) v8(84.05,65.67) v8(84.07,48.12) v8(84.07,47.69) v8(84.13,95.01) v8(84.13,94.6) v8(84.13,94.17) v8(84.13,93.74) v8(84.4,39.46) v8(84.4,39.05) v8(84.4,38.62) v8(84.4,38.19) v8(84.43,76.18) v8(84.43,75.75) v8(84.43,75.32) v8(84.43,74.91) v8(84.46,36.59) v8(84.46,36.18) v8(84.46,35.75) v8(84.46,35.32) v8(84.48,32.75) v8(84.48,32.34) v8(84.48,31.91) v8(84.48,31.48) v8(84.48,29.19) v8(84.48,28.79) v8(84.48,28.36) v8(84.48,27.92) v8(84.58,78.55) v8(84.58,78.11) v8(84.58,77.68) v8(84.58,77.28) v8(84.63,98.18) v8(84.63,97.75) v8(84.63,97.32) v8(84.63,96.91) v8(84.66,34.86) v8(84.66,34.45) v8(84.66,34.02) v8(84.66,33.59) v8(84.68,31.07) v8(84.68,30.67) v8(84.68,30.24) v8(84.68,29.8) v8(84.66,13.93) v8(84.66,13.5) v8(84.66,13.07) v8(84.66,12.66) v8(84.63,12.07) v8(84.63,11.64) v8(84.63,11.21) v8(84.63,10.8) v8(84.68,8.7) v8(84.68,8.26) v8(84.68,7.83) v8(84.68,7.43) v8(84.71,80.5) v8(84.71,80.07) v8(84.71,79.64) v8(84.71,79.23) v8(84.74,27.54) v8(84.74,27.14) v8(84.74,26.71) v8(84.74,26.27) v8(84.89,86.04) v8(84.89,85.61) v8(84.89,85.18) v8(84.89,84.77) v8(84.86,76.18) v8(84.86,75.78) v8(84.86,75.35) v8(84.86,74.91) v8(84.89,50.63) v8(84.89,50.23) v8(84.89,49.79) v8(84.89,49.39) v8(84.94,83.8) v8(84.94,83.37) v8(84.94,82.94) v8(84.94,82.53) v8(85.07,98.18) v8(85.07,97.77) v8(85.07,97.34) v8(85.07,96.91) v8(85.01,78.55) v8(85.01,78.14) v8(85.01,77.71) v8(85.01,77.28) v8(85.09,13.93) v8(85.09,13.52) v8(85.09,13.09) v8(85.09,12.66) v8(85.07,12.07) v8(85.07,11.67) v8(85.07,11.24) v8(85.07,10.8) v8(85.12,102.98) v8(85.12,102.55) v8(85.12,102.12) v8(85.12,101.71) v8(85.14,80.5) v8(85.14,80.1) v8(85.14,79.66) v8(85.14,79.23) v8(85.12,46.67) v8(85.12,46.26) v8(85.12,45.83) v8(85.12,8.7) v8(85.12,8.29) v8(85.12,7.86) v8(85.12,7.43) v8(85.24,45.4) v8(85.32,86.04) v8(85.32,85.63) v8(85.32,85.2) v8(85.32,84.77) v8(85.37,83.8) v8(85.37,83.4) v8(85.37,82.97) v8(85.37,82.53) v8(85.32,50.66) v8(85.32,50.25) v8(85.32,49.82) v8(85.32,49.39) v8(85.42,78.55) v8(85.42,78.11) v8(85.42,77.68) v8(85.42,77.28) v8(85.42,64.2) v8(85.42,63.76) v8(85.42,63.33) v8(85.42,62.93) v8(85.45,62.06) v8(85.45,61.63) v8(85.45,61.2) v8(85.45,60.79) v8(85.47,43.77) v8(85.47,43.34) v8(85.47,42.91) v8(85.47,42.5) v8(85.5,41.64) v8(85.5,41.21) v8(85.5,40.78) v8(85.5,40.37) v8(85.5,13.93) v8(85.5,13.5) v8(85.5,13.07) v8(85.5,12.66) v8(85.47,12.07) v8(85.47,11.64) v8(85.47,11.21) v8(85.47,10.8) v8(85.55,102.98) v8(85.55,102.57) v8(85.55,102.14) v8(85.55,101.71) v8(85.55,80.5) v8(85.55,80.07) v8(85.55,79.64) v8(85.55,79.23) v8(85.52,30.64) v8(85.52,30.24) v8(85.52,29.8) v8(85.52,29.37) v8(85.52,8.7) v8(85.52,8.26) v8(85.52,7.83) v8(85.52,7.43) v8(85.65,99.73) v8(85.65,99.3) v8(85.65,98.87) v8(85.65,98.46) v8(85.65,66.81) v8(85.65,66.38) v8(85.65,65.95) v8(85.65,65.54) v8(85.65,28.56) v8(85.65,28.15) v8(85.65,27.72) v8(85.65,27.29) v8(85.73,86.04) v8(85.73,85.61) v8(85.73,85.18) v8(85.73,84.77) v8(85.78,83.8) v8(85.78,83.37) v8(85.78,82.94) v8(85.78,82.53) v8(85.75,15.96) v8(85.75,15.53) v8(85.75,15.1) v8(85.75,14.69) v8(85.85,78.55) v8(85.85,78.14) v8(85.85,77.71) v8(85.85,77.28) v8(85.83,73.52) v8(85.83,73.09) v8(85.83,72.65) v8(85.83,72.25) v8(85.85,64.2) v8(85.85,63.79) v8(85.85,63.36) v8(85.85,62.93) v8(85.88,62.06) v8(85.88,61.66) v8(85.88,61.22) v8(85.88,60.79) v8(85.9,46.69) v8(85.9,46.29) v8(85.9,45.86) v8(85.9,45.42) v8(85.9,43.77) v8(85.9,43.37) v8(85.9,42.94) v8(85.9,42.5) v8(85.83,35.42) v8(85.83,34.99) v8(85.83,34.55) v8(85.83,34.15) v8(85.88,33.64) v8(85.88,33.21) v8(85.88,32.78) v8(85.88,32.37) v8(85.9,26.43) v8(85.9,25.99) v8(85.9,25.56) v8(85.85,24.37) v8(85.85,23.94) v8(85.85,23.5) v8(85.85,23.1) v8(85.85,20.1) v8(85.85,19.67) v8(85.85,19.24) v8(85.85,18.83) v8(85.85,18.48) v8(85.85,18.02) v8(85.83,16.6) v8(85.9,12.07) v8(85.9,11.67) v8(85.9,11.24) v8(85.9,10.8) v8(85.98,80.5) v8(85.98,80.1) v8(85.98,79.66) v8(85.98,79.23) v8(85.93,41.64) v8(85.93,41.23) v8(85.93,40.8) v8(85.93,40.37) v8(86.01,30.29) v8(86.01,29.88) v8(86.01,29.45) v8(86.01,29.02) v8(85.93,13.93) v8(85.93,13.52) v8(85.93,13.09) v8(85.93,12.66) v8(85.95,8.7) v8(85.95,8.29) v8(85.95,7.86) v8(85.95,7.43) v8(86.08,99.73) v8(86.08,99.32) v8(86.08,98.89) v8(86.08,98.46) v8(86.08,66.81) v8(86.08,66.41) v8(86.08,65.97) v8(86.08,65.54) v8(86.08,28.31) v8(86.08,27.9) v8(86.08,27.47) v8(86.08,27.04) v8(86.16,86.04) v8(86.16,85.63) v8(86.16,85.2) v8(86.16,84.77) v8(86.18,15.96) v8(86.18,15.55) v8(86.18,15.12) v8(86.18,14.69) v8(86.21,83.8) v8(86.21,83.4) v8(86.21,82.97) v8(86.21,82.53) v8(86.26,73.52) v8(86.26,73.11) v8(86.26,72.68) v8(86.26,72.25) v8(86.26,64.2) v8(86.26,63.76) v8(86.26,63.33) v8(86.26,62.93) v8(86.26,35.42) v8(86.26,35.01) v8(86.26,34.58) v8(86.26,34.15) v8(86.28,24.37) v8(86.28,23.96) v8(86.28,23.53) v8(86.28,23.1) v8(86.28,20.1) v8(86.28,19.69) v8(86.28,19.26) v8(86.28,18.83) v8(86.28,18.48) v8(86.28,18.04) v8(86.26,16.6) v8(86.31,33.64) v8(86.31,33.23) v8(86.31,32.8) v8(86.31,32.37) v8(86.34,26.43) v8(86.34,26.02) v8(86.34,25.59) v8(86.49,66.81) v8(86.49,66.38) v8(86.49,65.95) v8(86.49,65.54) v8(86.59,15.96) v8(86.59,15.53) v8(86.59,15.1) v8(86.59,14.69) v8(86.67,73.52) v8(86.67,73.09) v8(86.67,72.65) v8(86.67,72.25) v8(86.69,64.2) v8(86.69,63.79) v8(86.69,63.36) v8(86.69,62.93) v8(86.67,34.99) v8(86.67,34.55) v8(86.67,34.15) v8(86.69,24.37) v8(86.69,20.1) v8(86.69,19.67) v8(86.69,19.24) v8(86.69,18.83) v8(86.69,18.48) v8(86.67,17.05) v8(86.67,16.6) v8(86.77,101.61) v8(86.77,101.18) v8(86.77,100.75) v8(86.77,100.34) v8(86.72,83.68) v8(86.72,83.25) v8(86.72,82.81) v8(86.72,82.41) v8(86.77,58) v8(86.77,57.57) v8(86.77,57.13) v8(86.77,56.73) v8(86.72,33.64) v8(86.72,33.21) v8(86.72,32.78) v8(86.72,32.37) v8(86.74,26.43) v8(86.74,25.99) v8(86.74,25.56) v8(86.89,9.38) v8(86.89,8.95) v8(86.89,8.52) v8(86.89,8.11) v8(86.92,66.81) v8(86.92,66.41) v8(86.92,65.97) v8(86.92,65.54) v8(86.92,11.31) v8(86.92,10.88) v8(86.92,10.45) v8(86.92,10.04) v8(87.1,73.52) v8(87.1,73.11) v8(87.1,72.68) v8(87.1,72.25) v8(87.1,50.38) v8(87.1,49.95) v8(87.1,49.51) v8(87.1,49.11) v8(87.1,48.09) v8(87.1,47.66) v8(87.1,47.23) v8(87.1,46.82) v8(87.1,35.01) v8(87.1,34.58) v8(87.1,34.15) v8(87.1,17.08) v8(87.1,16.6) v8(87.02,15.96) v8(87.02,15.55) v8(87.02,15.12) v8(87.02,14.69) v8(87.2,101.61) v8(87.2,101.2) v8(87.2,100.77) v8(87.2,100.34) v8(87.15,83.68) v8(87.15,83.27) v8(87.15,82.84) v8(87.15,82.41) v8(87.2,58) v8(87.2,57.59) v8(87.2,57.16) v8(87.2,56.73) v8(87.17,45.91) v8(87.17,45.48) v8(87.17,45.04) v8(87.17,44.64) v8(87.12,43.7) v8(87.12,43.27) v8(87.12,42.83) v8(87.12,42.43) v8(87.15,41.54) v8(87.15,41.11) v8(87.15,40.68) v8(87.15,40.27) v8(87.17,39.48) v8(87.17,39.05) v8(87.17,38.62) v8(87.17,38.21) v8(87.15,33.64) v8(87.15,33.23) v8(87.15,32.8) v8(87.15,32.37) v8(87.17,26.43) v8(87.17,26.02) v8(87.17,25.59) v8(87.17,25.16) v8(87.12,24.37) v8(87.12,20.1) v8(87.12,19.69) v8(87.12,19.26) v8(87.12,18.83) v8(87.12,18.48) v8(87.3,94.73) v8(87.3,94.29) v8(87.3,93.86) v8(87.3,93.46) v8(87.35,86.17) v8(87.35,85.73) v8(87.35,85.3) v8(87.35,84.9) v8(87.35,11.31) v8(87.35,10.91) v8(87.35,10.47) v8(87.35,10.04) v8(87.33,9.38) v8(87.33,8.98) v8(87.33,8.54) v8(87.33,8.11) v8(87.53,50.38) v8(87.53,49.97) v8(87.53,49.54) v8(87.53,49.11) v8(87.53,48.09) v8(87.53,47.69) v8(87.53,47.25) v8(87.53,46.82) v8(87.61,45.91) v8(87.61,45.5) v8(87.61,45.07) v8(87.61,44.64) v8(87.55,43.7) v8(87.55,43.29) v8(87.55,42.86) v8(87.55,42.43) v8(87.58,41.54) v8(87.58,41.13) v8(87.58,40.7) v8(87.58,40.27) v8(87.61,39.48) v8(87.61,39.07) v8(87.61,38.64) v8(87.61,38.21) v8(87.53,29.25) v8(87.53,28.84) v8(87.53,28.41) v8(87.53,27.98) v8(87.68,20.41) v8(87.68,20) v8(87.68,19.57) v8(87.68,19.14) v8(87.66,18.78) v8(87.66,18.42) v8(87.71,107.96) v8(87.71,107.53) v8(87.71,107.1) v8(87.71,106.69) v8(87.78,105.65) v8(87.78,105.22) v8(87.78,104.78) v8(87.78,104.38) v8(87.73,94.73) v8(87.73,94.32) v8(87.73,93.89) v8(87.73,93.46) v8(87.78,86.17) v8(87.78,85.76) v8(87.78,85.33) v8(87.78,84.9) v8(87.76,36.76) v8(87.76,36.33) v8(87.76,35.9) v8(87.76,35.49) v8(87.78,33.82) v8(87.78,33.41) v8(87.78,26.63) v8(87.78,26.22) v8(87.78,25.79) v8(87.78,25.36) v8(87.76,11.31) v8(87.76,10.88) v8(87.76,10.45) v8(87.76,10.04) v8(87.73,9.38) v8(87.73,8.95) v8(87.73,8.52) v8(87.73,8.11) v8(87.94,50.38) v8(87.94,49.95) v8(87.94,49.51) v8(87.94,49.11) v8(87.94,48.09) v8(87.94,47.66) v8(87.94,47.23) v8(87.94,46.82) v8(87.96,43.7) v8(87.96,43.27) v8(87.96,42.83) v8(87.96,42.43) v8(87.99,41.54) v8(87.99,41.11) v8(87.99,40.68) v8(87.99,40.27) v8(88.01,45.91) v8(88.01,45.48) v8(88.01,45.04) v8(88.01,44.64) v8(88.01,39.48) v8(88.01,39.05) v8(88.01,38.62) v8(88.01,38.21) v8(88.14,107.96) v8(88.14,107.55) v8(88.14,107.12) v8(88.14,106.69) v8(88.11,100.97) v8(88.11,100.54) v8(88.11,100.11) v8(88.11,99.7) v8(88.19,36.76) v8(88.19,36.36) v8(88.19,35.93) v8(88.19,35.49) v8(88.19,11.31) v8(88.19,10.91) v8(88.19,10.47) v8(88.19,10.04) v8(88.16,9.38) v8(88.16,8.98) v8(88.16,8.54) v8(88.16,8.11) v8(88.21,105.65) v8(88.21,105.24) v8(88.21,104.81) v8(88.21,104.38) v8(88.27,59.52) v8(88.27,59.09) v8(88.27,58.66) v8(88.27,58.25) v8(88.21,33.84) v8(88.21,33.41) v8(88.32,94.7) v8(88.32,94.27) v8(88.32,93.84) v8(88.32,93.43) v8(88.37,50.38) v8(88.37,49.97) v8(88.37,49.54) v8(88.37,49.11) v8(88.37,48.09) v8(88.37,47.69) v8(88.37,47.25) v8(88.37,46.82) v8(88.39,43.7) v8(88.39,43.29) v8(88.39,42.86) v8(88.39,42.43) v8(88.32,29.27) v8(88.32,28.86) v8(88.32,28.43) v8(88.32,28) v8(88.44,52.82) v8(88.44,52.38) v8(88.44,51.95) v8(88.44,51.55) v8(88.44,45.91) v8(88.44,45.5) v8(88.44,45.07) v8(88.44,44.64) v8(88.42,41.54) v8(88.42,41.13) v8(88.42,40.7) v8(88.42,40.27) v8(88.44,39.48) v8(88.44,39.07) v8(88.44,38.64) v8(88.44,38.21) v8(88.47,20.43) v8(88.47,20.02) v8(88.47,19.59) v8(88.47,19.16) v8(88.47,18.75) v8(88.44,18.37) v8(88.55,100.97) v8(88.55,100.57) v8(88.55,100.14) v8(88.55,99.7) v8(88.55,87.06) v8(88.55,86.62) v8(88.55,86.19) v8(88.55,85.79) v8(88.55,84.74) v8(88.55,84.31) v8(88.55,83.88) v8(88.55,83.47) v8(88.6,36.76) v8(88.6,36.33) v8(88.6,35.9) v8(88.6,35.49) v8(88.57,26.65) v8(88.57,26.25) v8(88.57,25.82) v8(88.57,25.38) v8(88.7,59.52) v8(88.7,59.12) v8(88.7,58.68) v8(88.7,58.25) v8(88.62,33.82) v8(88.62,33.41) v8(88.75,94.7) v8(88.75,94.29) v8(88.75,93.86) v8(88.75,93.43) v8(88.85,67.95) v8(88.85,67.52) v8(88.85,67.09) v8(88.85,66.68) v8(88.88,52.82) v8(88.88,52.41) v8(88.88,51.98) v8(88.88,51.55) v8(88.98,87.06) v8(88.98,86.65) v8(88.98,86.22) v8(88.98,85.79) v8(88.98,84.74) v8(88.98,84.34) v8(88.98,83.91) v8(88.98,83.47) v8(88.95,70.67) v8(88.95,70.24) v8(88.95,69.81) v8(88.95,69.4) v8(88.95,65.41) v8(88.95,64.98) v8(88.95,64.55) v8(88.95,64.14) v8(89.03,36.76) v8(89.03,36.36) v8(89.03,35.93) v8(89.03,35.49) v8(89.05,34.68) v8(89.05,34.27) v8(89.05,33.84) v8(89.05,33.41) v8(89.28,67.95) v8(89.28,67.55) v8(89.28,67.12) v8(89.28,66.68) v8(89.23,60.44) v8(89.23,60) v8(89.23,59.57) v8(89.23,59.17) v8(89.28,52.82) v8(89.28,52.38) v8(89.28,51.95) v8(89.28,51.55) v8(89.38,70.67) v8(89.38,70.27) v8(89.38,69.83) v8(89.38,69.4) v8(89.38,65.41) v8(89.38,65.01) v8(89.38,64.58) v8(89.38,64.14) v8(89.66,60.44) v8(89.66,60.03) v8(89.66,59.6) v8(89.66,59.17) v8(89.71,52.82) v8(89.71,52.41) v8(89.71,51.98) v8(89.71,51.55) v8(90.5,100.03) v8(90.5,99.6) v8(90.5,99.17) v8(90.5,98.76) v8(90.93,100.03) v8(90.93,99.63) v8(90.93,99.2) v8(90.93,98.76) v8(91.31,55.56) v8(91.31,55.13) v8(91.31,54.7) v8(91.31,54.29) v8(91.67,95.34) v8(91.67,94.9) v8(91.67,94.47) v8(91.67,94.07) v8(91.75,55.56) v8(91.75,55.15) v8(91.75,54.72) v8(91.75,54.29) v8(91.9,88.17) v8(91.9,87.74) v8(91.9,87.31) v8(91.9,86.9) v8(92.1,95.34) v8(92.1,94.93) v8(92.1,94.5) v8(92.1,94.07) v8(92.1,91.91) v8(92.1,91.48) v8(92.1,91.04) v8(92.1,90.64) v8(92.15,55.56) v8(92.15,55.13) v8(92.15,54.7) v8(92.15,54.29) v8(92.33,88.17) v8(92.33,87.77) v8(92.33,87.33) v8(92.33,86.9) v8(92.43,97.09) v8(92.43,96.66) v8(92.43,96.22) v8(92.43,95.82) v8(92.53,91.91) v8(92.53,91.5) v8(92.53,91.07) v8(92.53,90.64) v8(92.58,55.56) v8(92.58,55.15) v8(92.58,54.72) v8(92.58,54.29) v8(92.58,40.84) v8(92.58,39.64) v8(92.86,97.09) v8(92.86,96.68) v8(92.86,96.25) v8(92.86,95.82) v8(92.96,66.25) v8(92.96,65.82) v8(92.96,65.39) v8(92.96,64.98) v8(93.02,72.76) v8(93.02,72.32) v8(93.02,71.89) v8(93.02,71.49) v8(93.04,69.38) v8(93.04,68.95) v8(93.04,68.51) v8(93.04,68.11) v8(93.04,63.66) v8(93.04,63.23) v8(93.04,62.8) v8(93.04,62.39) v8(93.19,90.89) v8(93.19,90.46) v8(93.19,90.03) v8(93.19,89.62) v8(93.4,87.89) v8(93.4,87.46) v8(93.4,87.03) v8(93.4,86.62) v8(93.4,66.25) v8(93.4,65.85) v8(93.4,65.41) v8(93.4,64.98) v8(93.45,72.76) v8(93.45,72.35) v8(93.45,71.92) v8(93.45,71.49) v8(93.47,69.38) v8(93.47,68.97) v8(93.47,68.54) v8(93.47,68.11) v8(93.47,63.66) v8(93.47,63.26) v8(93.47,62.82) v8(93.47,62.39) v8(93.63,90.89) v8(93.63,90.48) v8(93.63,90.05) v8(93.63,89.62) v8(93.75,116.85) v8(93.83,87.89) v8(93.83,87.49) v8(93.83,87.06) v8(93.83,86.62) v8(94.08,116.86) v8(94.7,81.49) v8(94.7,81.2) v8(94.7,80.91) v8(95.24,58.27) v8(96.11,104.84) v8(96.11,104.4) v8(96.11,103.97) v8(96.11,103.57) v8(96.49,113.13) v8(96.55,104.84) v8(96.55,104.43) v8(96.55,104) v8(96.55,103.57) v8(98.22,96.56) v8(98.22,96.12) v8(98.22,95.69) v8(98.22,95.29) v8(98.48,93.38) v8(98.48,92.95) v8(98.48,92.52) v8(98.48,92.11) v8(98.65,96.56) v8(98.65,96.15) v8(98.65,95.72) v8(98.65,95.29) v8(98.91,93.38) v8(98.91,92.97) v8(98.91,92.54) v8(98.91,92.11) v11(34.82,27.01) v11(34.85,26.12) v11(35.74,27.04) v11(35.74,26.17)
