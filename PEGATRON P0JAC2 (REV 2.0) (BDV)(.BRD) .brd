# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
76_M1_DQS6_DN: length 26.8
  L7-SIG w0.06: v6(52.25,78.42) 52.33,78.5 52.43,78.6 52.43,78.87 52.51,78.94 52.51,79.69 52.58,79.76
  L7-SIG w0.076: 49.91,90.11 49.96,90.16 49.96,91.14 49.79,91.32 49.48,91.32 49.44,91.36 49.44,91.7 49.29,91.84 48.72,91.84 v1(48.58,91.98)
  L7-SIG w0.079: 52.58,79.76 52.58,79.96 52.06,80.48 52.06,81.06 52.64,81.65 52.64,82.03 52.78,82.17 52.78,82.52 53.3,83.04 53.3,86.75 53.31,86.76 53.31,87.24 53.57,87.5 53.57,90.43 53.85,90.71 53.85,91.82 53.6,92.07 52.79,92.07 52.61,91.89 52.61,91.58 52.79,91.41 52.79,91.16 52.44,90.82 52.15,90.82 51.94,91.02 51.55,91.02 51.36,90.83 51.36,90.57 51.57,90.35 51.57,89.39 51.38,89.19 51.25,89.19 51.11,89.33 51.11,90.12 50.91,90.32 50.56,90.32 50.39,90.15 50.39,89.72 50.16,89.49 50.05,89.49 49.83,89.71 49.83,90.03 49.91,90.11
76_M1_DQS6_DP: length 26.8
  L7-SIG w0.06: v6(52.01,78.74) 52.01,78.66 52.05,78.62 52.28,78.62 52.31,78.65 52.31,78.92 52.39,78.99 52.39,79.74 52.39,79.74 52.38,79.74 52.37,79.75 52.37,79.76
  L7-SIG w0.076: v1(48.58,91.48) 48.58,91.64 48.63,91.69 49.23,91.69 49.29,91.64 49.29,91.29 49.42,91.16 49.72,91.16 49.81,91.08 49.81,90.3 49.77,90.25
  L7-SIG w0.079: 49.77,90.25 49.62,90.11 49.62,89.62 49.96,89.28 50.24,89.28 50.6,89.64 50.6,90.06 50.65,90.11 50.82,90.11 50.9,90.03 50.9,89.25 51.16,88.99 51.46,88.99 51.78,89.3 51.78,90.44 51.57,90.65 51.57,90.75 51.63,90.81 51.86,90.81 52.06,90.61 52.53,90.61 52.99,91.08 52.99,91.49 52.82,91.67 52.82,91.8 52.88,91.87 53.52,91.87 53.64,91.74 53.64,90.8 53.36,90.52 53.36,87.58 53.1,87.32 53.1,86.85 53.1,86.84 53.1,83.12 52.58,82.61 52.58,82.25 52.44,82.11 52.44,81.73 51.85,81.15 51.85,80.4 52.37,79.88 52.37,79.76
76_M1_DQS7_DN: length 25.5
  L5-SIG w0.06: 52.3,77.72 52.3,77.71 52.29,77.7 52.29,77.67 52.21,77.59 52.2,77.59 52.03,77.42 52.03,77.14 52.21,76.96 52.21,76.76 v6(52.29,76.68)
  L5-SIG w0.076: v1(50.21,90.93) 50.45,90.69 50.45,90.46 50.46,90.45
  L5-SIG w0.086: 50.46,90.45 50.46,89.92 50.57,89.81 51.25,89.81 51.44,89.62 51.44,89.12 51.29,88.96 51.15,88.96 51.06,88.87 51.06,88.31 51.41,87.96 51.78,87.96 51.88,88.06 51.88,88.66 52.14,88.92 52.14,89.22 51.94,89.42 51.94,90.63 52.2,90.9 52.76,90.9 52.93,90.73 52.93,88.57 52.82,88.46 52.82,87.92 52.85,87.89 52.85,87.88 ; 52.3,77.72 52.3,78.52 52.39,78.61 52.6,78.61 52.78,78.78 52.78,79.19 52.53,79.44 52.53,80.96 52.66,81.08 53.08,81.08 53.48,81.48 53.48,81.69 53.11,82.06 52.89,82.06 52.65,81.82 52.42,81.82 52.36,81.88 52.36,82.02 52.49,82.14 52.49,82.25 52.55,82.31 52.56,82.32 52.56,82.33
  L5-SIG w0.119: 52.56,82.33 52.56,82.34 52.85,82.63 52.85,87.88
76_M1_DQS7_DP: length 25.4
  L5-SIG w0.06: 52.15,77.72 52.15,77.71 51.91,77.47 51.91,77.09 52.09,76.91 52.09,76.6 52.2,76.48 52.2,76.39 52.17,76.35 v6(51.98,76.35)
  L5-SIG w0.086: 52.63,87.88 52.63,87.89 52.66,87.92 52.66,88.53 52.77,88.63 52.77,90.66 52.69,90.74 52.27,90.74 52.1,90.56 52.1,89.49 52.3,89.29 52.3,88.85 52.04,88.59 52.04,87.99 51.85,87.8 51.34,87.8 50.9,88.24 50.9,88.94 51.09,89.12 51.22,89.12 51.28,89.18 51.28,89.55 51.19,89.64 50.5,89.64 50.3,89.85 50.3,90.36 v1(50.21,90.44) ; 52.15,77.72 52.15,78.58 52.33,78.75 52.54,78.75 52.63,78.84 52.63,79.13 52.39,79.38 52.39,81.02 52.6,81.23 53.02,81.23 53.33,81.54 53.33,81.63 53.05,81.91 52.95,81.91 52.72,81.68 52.36,81.68 52.22,81.82 52.22,82.08 52.34,82.2 52.34,82.33
  L5-SIG w0.119: 52.63,87.88 52.63,82.72 52.34,82.43 52.34,82.33
85_USB2_CPU_P1_DN_C: length 7.7
  L3-GND w0.102: v8(95.24,56.32) 94.85,56.32 v3(94.82,56.35)
  L6-GND w0.102: v4(94.46,56.45) 94.54,56.52 94.64,56.52 v3(94.82,56.35)
  L7-SIG w0.076: v1(89.35,57.92) 89.59,58.16 92.07,58.16 92.15,58.16 93.78,56.54 94.37,56.54 v4(94.46,56.45)
  BOTTOM w0.178: v1(89.35,57.92) 89.35,57.93 RNX5227.2
85_USB2_CPU_P1_DP_C: length 7.7
  L3-GND w0.102: v8(95.24,56.97) 94.88,56.97 v3(94.82,56.91)
  L6-GND w0.102: v4(94.46,56.8) 94.54,56.73 94.64,56.73 v3(94.82,56.91)
  L7-SIG w0.076: v1(89.35,58.58) 89.58,58.35 91.99,58.35 92.23,58.35 93.86,56.73 94.39,56.73 v4(94.46,56.8)
  BOTTOM w0.178: RNX5227.4 89.35,58.58 v1(89.35,58.58)
+AC_ADAPTER: length 56
  L2-SIG w0.254: v8(78.44,23.99) 78.44,23.2 75.33,20.1 58.49,20.1 57.66,19.27 v8(57.66,17.97)
  L3-GND w0.254: v3(78.44,23.61) v8(78.44,23.99) ; v8(57.66,17.97) 57.56,17.87 v3(57.56,17.05)
  L4-SIG w2.032: 56.74,10.07 44.85,10.07 38.21,16.71 37.79,16.71 37.36,17.13
  L5-SIG w0.254: v3(57.56,17.05) 57.56,15.02 58.11,14.47 v3(58.11,10.32)
  L6-GND w0.254: v1(57.56,17.59) v3(57.56,17.05) ; v1(78.44,23.25) v3(78.44,23.61)
  vias: v2(36.4,19.16) v2(36.4,18.5) v2(36.4,17.84) v2(36.4,17.18) v2(67,8.49) v2(66.98,6.31) v2(67.34,6.8) v2(67.64,8.49) v2(67.69,6.31) v3(58.1,9.74) v3(58.7,10.32) v3(58.71,9.74) v3(59.25,10.29) v3(59.27,9.72) v8(58.1,9.32) v8(58.09,9.01) v8(58.39,9.32) v8(58.39,9.02) v8(58.69,9.31) v8(58.69,9.02) v8(59,9.31) v8(59,9) v8(59.3,9.32) v8(59.33,9)
+BATT_CN: length 70.8
  L4-SIG w0.254: v3(73.38,32.62) 73.88,32.13 73.88,30.84 74.1,30.62 74.1,27.71 74.1,26.07 73.27,25.23 v3(72.67,25.23) ; 31.68,29.65 31.68,22.53 33,21.22 36.06,21.22 38.59,18.69 40.11,18.69 46.5,12.31 48.85,12.31 49.59,13.05 59.63,13.05 v3(60.15,12.53)
  L5-SIG w0.254: v3(72.67,25.23) 69.94,25.23 69.48,24.78 68.07,24.78 66.52,24.78 62.41,20.67 62.41,18.27 60.15,16.01 v3(60.15,12.53)
  L6-GND w0.254: v1(72.97,32.98) 73.03,32.98 v3(73.38,32.62)
  vias: v1(23.5,45.2) v1(23.5,44.92) v1(23.64,44.28) v1(23.64,44) v1(23.78,45.2) v1(23.78,44.92) v1(23.92,44.28) v1(23.92,44) v1(24.05,45.2) v1(24.05,44.92) v1(24.2,44.28) v1(24.2,44) v1(25.2,40.73) v1(25.43,40.57) v1(25.6,43.93) v1(25.83,43.77) v11(24.13,43.12) v11(24.42,40.85) v11(24.99,43.11) v11(25.86,42.24) v11(25.86,41.35) v11(25.91,43.14) v11(30.6,31.68) v11(30.58,30.82) v11(31.57,31.77) v11(31.56,30.83) v11(32.49,31.78) v11(32.49,30.88)
+DCVDD: length 3.6
  BOTTOM w0.178: U1001.42 30.74,65.94 30.9,66.11
  BOTTOM w0.254: 30.9,66.11 30.95,66.15 30.95,66.65 v9(31.45,67.15) 31.49,67.19 C1023.2 C1024.1
+ENPVCC:
  vias: v1(51.99,15.3) v1(51.97,14.54) v1(52.15,15.05) v1(52.15,14.28) v1(53.92,18.25) v1(54.08,17.99) v1(54.31,18.25) v1(54.46,17.99)
+GPIO0VDD: length 14.1
  L6-GND w0.203: v4(58.98,26.27) 59.26,26.55 59.26,29.45 59.82,30 59.82,31.61 59.08,32.35 v6(59.08,32.94)
  L7-SIG w0.203: v1(59.77,21.19) R8448.2 58.82,21.58 58.82,22.4 59.03,22.62 59.03,23.44 58.58,23.9 58.58,25.29 58.98,25.69 v4(58.98,26.27)
  BOTTOM w0.254: v1(59.77,21.19) R8448.2
+HOME_POWER: length 28.9
  L7-SIG w0.254: v1(38.84,3.95) 38.08,3.18 28.91,3.18 27.53,1.81 v1(24.76,1.81) 21.54,1.81 19.28,4.07 v1(19.28,5.32) 21.34,5.32 21.75,5.72 v1(23.93,5.72)
  BOTTOM w0.254: v1(23.93,5.72) R2015.2 R2016.2
+LCD_VDD_R: length 1.1
  L7-SIG w0.102: v1(52.8,16.23) 52.8,15.73 52.93,15.6 v1(52.93,15.17)
+V_VCC: length 0.7
  BOTTOM w0.102: 55.13,72.27 54.44,72.27
  vias: v2(65.79,53.66) v2(66.4,53.65) v2(66.35,52.38) v2(66.96,52.36) v2(67.06,53.65) v2(67.06,52.99) v2(67.56,52.38) v2(67.67,52.99) v2(67.74,53.65) v2(68.17,52.38) v2(68.28,52.99) v2(68.4,53.65) v2(68.96,53.12) v3(52.52,72.18) v3(52.51,71.62) v3(52.94,71.13) v3(53.51,71.14) v3(54.26,71.16) v3(54.79,71.53) v3(54.78,70.92) v3(54.79,70.36) v3(55.41,71.19) v3(55.89,70.91) v3(56.38,70.62) v3(56.86,70.34) v3(56.88,69.79) v3(57.68,70.36) v5(52.96,72.53) v5(53.44,72.81) v5(53.42,72.25) v5(53.9,72.53) v5(53.9,71.99) v5(53.9,71.43) v5(54.38,72.27) v5(54.38,71.71) v5(55.32,72.27) v5(55.32,71.71) v5(55.8,72.55) v5(55.8,71.99) v5(55.81,71.43) v5(56.28,72.26) v5(56.28,71.16) v5(56.76,71.43) v5(56.76,70.88) v5(57.24,71.71) v5(57.24,71.16) v5(58.24,70.74) v5(58.24,70.22) v5(58.52,70.46) v6(52.96,72.53) v6(53.44,72.81) v6(53.42,72.25) v6(53.9,72.53) v6(53.9,71.99) v6(53.9,71.43) v6(54.38,72.27) v6(54.38,71.71) v6(55.32,72.27) v6(55.32,71.71) v6(55.8,72.55) v6(55.8,71.99) v6(55.81,71.43) v6(56.28,72.26) v6(56.28,71.16) v6(56.76,71.43) v6(56.76,70.88) v6(57.24,71.71) v6(57.24,71.16) v6(58.24,70.74) v6(58.24,70.22) v6(58.52,70.46) v7(58.07,70.98) v7(59.79,72.63) v7(59.97,71.94) v8(52.17,72.09) v8(52.2,71.82) v8(52.18,71.48) v8(52.54,71.2) v8(52.75,71.91) v8(52.89,72.13) v8(52.87,71.51) v8(53,71.77) v8(52.95,70.77) v8(53.17,71.98) v8(53.16,71.43) v8(53.28,71.74) v8(53.23,70.84) v8(53.45,71.98) v8(53.41,71.49) v8(53.58,71.71) v8(53.51,70.77) v8(53.69,71.47) v8(53.71,71.94) v8(53.86,71.7) v8(53.89,71.09) v8(53.82,70.81) v8(53.97,71.94) v8(53.96,71.4) v8(54.13,71.61) v8(54.11,70.81) v8(54.24,71.87) v8(54.4,71.59) v8(54.4,70.82) v8(54.46,70.55) v8(54.54,71.83) v8(54.8,71.9) v8(55.08,71.79) v8(55.02,71.22) v8(55.13,70.54) v8(55.21,70.84) v8(55.33,71.85) v8(55.32,71.57) v8(55.4,70.58) v8(55.33,70.31) v8(55.6,71.52) v8(55.52,70.84) v8(55.61,70.36) v8(55.66,70.62) v8(55.77,71.28) v8(55.86,70.27) v8(55.92,70.54) v8(56.13,70.35) v8(56.25,70.96) v8(56.39,70.23) v8(56.64,70.06) v8(56.98,70.7) v8(57.15,70.07) v8(57.26,70.67) v8(57.27,70.35) v8(57.28,69.72) v8(57.28,69.46) v8(57.43,70.08) v8(57.53,70.7) v8(57.56,69.46) v8(57.92,70.08) v8(58.07,70.98) v8(59.79,72.63) v8(59.97,71.94) v10(52.96,72.53) v10(53.44,72.81) v10(53.42,72.25) v10(53.9,72.53) v10(53.9,71.99) v10(53.9,71.43) v10(54.38,72.27) v10(54.38,71.71) v10(55.32,72.27) v10(55.32,71.71) v10(55.8,72.55) v10(55.8,71.99) v10(55.81,71.43) v10(58.24,70.74) v10(58.24,70.22) v10(58.52,70.46)
+V_VCC_PMIC:
  vias: v9(64.51,47.25)
+V_VCC_SENSE: length 65.2
  L4-SIG w0.102: v3(55.35,48.72) 55.8,49.17 67.04,49.17 69.19,51.32 69.19,51.73 v3(68.88,52.04)
  L5-SIG w0.102: v3(55.35,48.72) 56.52,47.55 57,47.55 59.39,45.16 59.39,40.06 59.46,39.98 59.46,37.68 v6(59.16,37.39)
  L5-SIG w0.152: v6(52,73.08) 51.58,72.67 51.58,67.4 51.86,67.12 51.86,65.49 53.11,64.24 53.11,61.52 53.92,60.71 53.92,59.22 54.41,58.73 55.04,58.73 55.73,59.42 58.24,59.42 58.79,58.87 58.79,58.39 v3(58.62,58.23)
  L6-GND w0.102: v3(68.88,52.04) 68.88,52.44 68.88,52.44 v1(68.88,52.44) ; v3(58.62,58.23) 59.07,57.78 v4(59.15,57.78)
  L7-SIG w0.102: v4(59.15,57.78) 59.25,57.67 59.25,57.61 59.16,57.52 59.16,57.1 59.25,57 60.21,56.04 60.77,55.48 62.26,55.48 63.44,54.3 68.36,54.3 69.37,53.29 69.37,52.95 68.88,52.47 v1(68.88,52.44)
+V_VNN:
  vias: v2(58.8,53.68) v2(58.78,53.07) v2(59.41,53.68) v2(59.41,53.06) v2(60.02,53.68) v2(60.02,53.06) v2(60.63,53.71) v2(60.94,53.17) v2(61.24,53.71) v2(61.6,53.17) v3(49.95,68.71) v3(50.08,70.32) v3(50.23,68.23) v3(50.46,68.89) v3(50.75,68.41) v3(50.89,69.21) v3(52.15,70.59) v3(53.03,68.67) v3(53.04,68.11) v3(53.36,69.54) v3(54.71,68.1) v3(54.81,69.65) v3(55.29,68.49) v3(55.29,67.93) v3(55.87,68.11) v3(56.3,68.52) v3(56.69,68.92) v5(49.61,72.26) v5(49.61,71.71) v5(49.61,71.16) v5(49.61,70.61) v5(49.61,70.06) v5(49.61,69.51) v5(49.61,68.96) v5(49.61,68.41) v5(50.09,72.99) v5(50.09,71.43) v5(50.09,69.78) v5(50.57,72.26) v5(50.57,70.61) v5(51.04,73.08) v5(51.04,72.53) v5(51.04,71.98) v5(51.04,71.43) v5(51.04,70.88) v5(51.05,70.34) v5(51.03,69.78) v5(51.04,68.68) v5(52.96,69.78) v5(53.42,68.96) v5(53.42,68.41) v5(53.9,69.78) v5(53.9,68.69) v5(53.9,68.13) v5(54.38,68.95) v5(54.38,68.4) v5(54.87,68.68) v5(55.34,68.96) v5(55.82,69.78) v5(55.82,68.68) v5(56.3,69.51) v5(56.3,68.96) v6(49.61,73.36) v6(49.61,72.26) v6(49.61,71.71) v6(49.61,71.16) v6(49.61,70.61) v6(49.61,70.06) v6(49.61,69.51) v6(49.61,68.96) v6(49.61,68.41) v6(50.09,73.63) v6(50.09,72.99) v6(50.09,71.43) v6(50.09,69.78) v6(50.57,73.91) v6(50.57,73.36) v6(50.57,72.26) v6(50.57,70.61) v6(50.57,68.41) v6(51.04,73.63) v6(51.04,73.08) v6(51.04,72.53) v6(51.04,71.98) v6(51.04,71.43) v6(51.04,70.88) v6(51.05,70.34) v6(51.03,69.78) v6(51.04,68.68) v6(51.04,68.13) v6(51.51,70.62) v6(51.51,70.06) v6(51.52,68.96) v6(51.52,68.41) v6(51.99,70.34) v6(52,69.23) v6(52.48,70.06) v6(52.47,68.96) v6(52.96,69.78) v6(52.95,68.68) v6(52.95,68.13) v6(53.42,70.06) v6(53.42,68.96) v6(53.42,68.41) v6(53.9,69.78) v6(53.9,68.69) v6(53.9,68.13) v6(54.38,70.06) v6(54.38,68.95) v6(54.38,68.4) v6(54.85,70.33) v6(54.85,69.78) v6(54.87,68.68) v6(55.33,70.06) v6(55.34,68.96) v6(55.82,69.78) v6(55.82,68.68) v6(56.3,69.51) v6(56.3,68.96) v6(56.76,69.78) v6(56.76,69.23) v8(49.74,70.43) v8(49.75,70.15) v8(49.89,69.07) v8(49.88,68.35) v8(50.15,69.07) v8(50.52,69.26) v8(50.58,68.07) v8(50.83,68.85) v8(51.08,68.9) v8(52.68,68.46) v8(52.67,68.17) v8(53.03,69.68) v8(53.36,68.51) v8(53.39,68.2) v8(53.68,69.71) v8(54.47,69.78) v8(54.47,69.53) v8(54.66,68.49) v8(54.9,67.78) v8(54.96,68.62) v8(55.06,68.22) v8(55.18,69.64) v8(55.12,68.82) v8(55.52,68.21) v8(55.65,69.55) v8(55.62,68.65) v8(55.68,67.8) v8(55.78,67.57) v8(55.82,68.47) v8(55.98,68.71) v8(55.96,67.76) v8(56.13,69.22) v8(56.23,68.16) v8(56.63,68.38) v10(49.61,72.26) v10(49.61,71.71) v10(49.61,71.16) v10(49.61,70.61) v10(49.61,70.06) v10(49.61,69.51) v10(49.61,68.96) v10(49.61,68.41) v10(50.09,72.99) v10(50.09,71.43) v10(50.09,69.78) v10(50.57,72.26) v10(50.57,70.61) v10(51.04,73.08) v10(51.04,72.53) v10(51.04,71.98) v10(51.04,71.43) v10(51.04,70.88) v10(51.05,70.34) v10(51.03,69.78) v10(51.04,68.68) v10(52.96,69.78) v10(53.42,68.96) v10(53.42,68.41) v10(53.9,68.69) v10(53.9,68.13) v10(54.38,68.95) v10(54.38,68.4) v10(54.87,68.68) v10(55.34,68.96) v10(55.82,69.78) v10(55.82,68.68) v10(56.3,69.51) v10(56.3,68.96) v11(43.18,61.4) v11(44.15,61.21) v11(44.68,61.96) v11(45.54,61.93)
+V_VNN_PMIC:
  vias: v9(55.32,49.69)
+V_VNN_SENSE: length 49.5
  L4-SIG w0.254: v3(54.26,50.7) 54.05,50.48 54.05,50.44 53.56,49.95 46.85,49.95 v3(44.83,51.97)
  L5-SIG w0.254: v3(57.3,46.27) 57.14,46.11 57.14,39.9 57.6,39.44 57.6,37.94 57.91,37.63 v6(57.91,37.34)
  L6-GND w0.203: v3(44.83,51.97) v4(44.83,52.59) ; v4(57.91,46.27) v3(57.3,46.27)
  L6-GND w0.254: v3(54.26,50.7) 54.32,50.76 v4(54.69,50.76)
  L7-SIG w0.152: v6(50.57,68.96) 50.11,68.51 50.11,67.94 49.83,67.65 49.83,66.6 48.35,65.12 48.35,63.39 47.4,62.45 47.4,62.24 47.83,61.81 47.83,58.84 45.8,56.8 45.01,56.8 44.29,56.08 44.29,55.19 45.04,54.43 45.04,52.8 v4(44.83,52.59)
  L7-SIG w0.203: v4(57.91,46.27) 57.91,47.53 v4(54.69,50.76) 54.08,51.37 v1(54.08,52.44)
+V_VSS_SENSE: length 65.1
  L4-SIG w0.102: v3(56.01,48.75) 56.2,48.93 67.09,48.93 69.39,51.24 69.39,51.98 v3(69.54,52.13)
  L5-SIG w0.102: v3(56.01,48.75) 56.01,48.34 56.6,47.75 57.08,47.75 59.59,45.25 59.59,40.14 59.66,40.07 59.66,37.58 59.38,37.3 59.38,37.29 59.25,37.16 59.24,37.16 58.62,36.54 v6(58.35,36.54)
  L5-SIG w0.152: v3(59.23,58.23) 59.05,58.41 59.05,58.97 58.34,59.67 58.13,59.67 55.6,59.67 54.92,58.99 54.52,58.99 54.18,59.33 54.18,60.81 53.37,61.63 53.37,64.28 52.07,65.58 52.07,67.24 51.79,67.52 51.79,72.33 v6(52,72.53)
  L6-GND w0.102: v3(59.23,58.23) 59.23,58.18 v4(59.56,57.85) ; v3(69.54,52.13) 69.57,52.16 v1(69.57,52.51)
  L7-SIG w0.102: v4(59.56,57.85) 59.46,57.74 59.46,57.53 59.36,57.43 59.36,57.18 60.86,55.69 62.34,55.69 63.53,54.5 68.44,54.5 69.57,53.37 v1(69.57,52.51)
+VHDMI: length 31.6
  L4-SIG w0.508: v3(80.11,21.29) v3(80.11,23.89)
  L5-SIG w0.508: v3(80.11,23.89) 78.11,25.89 78.05,25.89 76.28,27.67 76.28,27.72 75.39,28.61 73.31,28.61 73,28.31 v3(72.42,28.31) ; v3(80.11,21.29) 80.18,21.22 83.27,21.22 85.34,23.3 85.34,29.04 86.87,30.57 v3(86.87,35.77)
  vias: v1(72.18,27.96) v1(72.63,27.92) v1(86.88,36.59) v1(86.87,36.29) v4(72.18,27.96) v4(72.63,27.92) v4(86.88,36.59) v4(86.87,36.29)
+VHDMI_OUT: length 3.2
  L3-GND w0.102: v3(92.72,38.05) 92.58,38.19 v8(92.58,38.44)
  BOTTOM w0.432: D0905.3 86.57,35.73 86.69,35.85 C0901.1
  vias: v1(92.48,37.68) v1(92.46,37.36) v1(92.75,37.36) v1(92.82,37.65) v4(92.48,37.68) v4(92.46,37.36) v4(92.75,37.36) v4(92.82,37.65) v7(92.9,38.44) v8(92.9,38.44)
+VHDMI_VIN: length 26.8
  L6-GND w0.152: v6(59.9,32.94) 59.9,32.82 61.11,31.6 61.11,31 62,30.11 62,26.04 62.15,25.9 v4(62.15,25.77)
  L7-SIG w0.254: v4(62.15,25.77) 62.15,25.58 61.09,24.52 61.09,22.47 62.13,21.42 63.34,21.42 64.19,22.27 64.19,23.74 65.37,24.92 69.19,24.92 69.75,25.49 70.36,25.49 70.74,25.1 v1(70.91,25.1)
  BOTTOM w0.254: R8302.2 72.74,25.18 C8307.1 70.99,25.18 v1(70.91,25.1)
+VHOST_EN: length 4.5
  L3-GND w0.102: v3(59.18,30.27) 59.18,30.06 58.75,29.63 v8(58.75,29.6)
  L5-SIG w0.06: 58.88,31.23 58.88,33.08 58.72,33.24 v6(58.72,33.74)
  L5-SIG w0.102: v3(59.18,30.27) 59.18,30.44 58.88,30.74 58.88,31.23
+VNN_COMP: length 19.7
  L6-GND w0.06: 56.02,38.59 56,38.58 56.71,37.87 56.71,37.34 v6(57.11,36.94)
  L6-GND w0.102: 56.02,38.59 56.02,38.86 55.12,39.76 55.12,40.48 54.65,40.95 54.65,44.16 53.83,44.97 v4(53.83,45.44)
  L7-SIG w0.102: v4(53.83,45.44) 53.83,47.12 52.11,48.85 51.52,48.85 51.34,48.68 47.61,48.68 47.44,48.85 47.44,49.3 v1(47.14,49.59)
+VNN_LX0: length 2.5
  BOTTOM w0.508: 58.17,42.07 58.17,41.28 v9(58.62,40.83) 58.62,39.79
+VNN_LX1: length 4.9
  BOTTOM w0.203: U8201.E1 57.52,37.79 57.35,37.96 57.35,38.38 56.59,39.15 56.59,39.76 56.49,39.86
  BOTTOM w0.508: 56.49,42.16 56.49,39.86
+VNN_LX2:
  vias: v9(54.07,41.06)
+VNN_LX3:
  vias: v9(54.17,39.22)
+VNN_LX4: length 4.7
  BOTTOM w0.508: L8210.2 50.9,37.83 53.53,37.83 53.92,37.44 53.92,37.43 54.81,36.53 54.81,36.48
+VREF25: length 24.6
  L4-SIG w0.457: v3(62.21,31.79) 61.95,31.79 61.18,32.56 61.18,35.43 v3(61.57,35.82) 60.07,37.32 59.59,37.32 v3(59.03,37.88) 57.51,36.36 56.64,36.36 v3(55.27,34.99)
  L4-SIG w0.508: v3(62.21,31.79) 62.64,31.79 63.18,32.33 63.18,32.79 v3(62.92,33.06)
  L5-SIG w0.203: v3(62.21,31.79) 61.83,31.79 v6(60.72,32.9) ; v3(61.57,35.82) 61.27,35.82 61.18,35.74 v6(60.72,35.74)
  L6-GND w0.102: v6(60.72,34.54) 60.76,34.54 60.94,34.35 61.92,34.35 ; v3(59.03,37.88) 59.03,37.58 58.93,37.48 58.93,37.29 59.11,37.12 v6(59.11,36.94)
  L6-GND w0.152: v3(62.92,33.06) 63.07,33.21 63.07,33.84 62.64,34.27 61.99,34.27 61.92,34.35
  L6-GND w0.203: v5(55.68,34.83) 55.42,34.83 v3(55.27,34.99)
  L7-SIG w0.06: v5(55.68,34.83) 55.74,34.77 56.89,34.77 v6(57.12,34.54)
  vias: v1(63.63,31.05) v1(64.19,31.05) v4(63.63,31.05) v4(64.19,31.05)
+VREF_DQ0: length 118
  L2-SIG w0.254: v8(31.16,50.14) 31.16,50.42 31.47,50.73 31.5,50.78 31.5,60.28 33.32,62.11 33.32,67.61 33.43,67.72 33.43,72.05 28.56,76.92 28.56,87.39 32.89,91.72 32.89,96.49 39.2,102.8 41.53,102.8 42.44,101.89 52.81,101.89 v2(56.58,98.12)
  L3-GND w0.254: v8(31.16,50.14) 31.16,49.91 v3(31.29,49.77)
  L4-SIG w0.254: v2(56.58,98.12) 59.04,95.65 59.04,90.45 61.32,88.17 65.66,88.17 v3(66.27,87.56)
  L5-SIG w0.254: v3(46.1,44.1) 46.1,44.31 46.46,44.66 46.46,45.27 45.34,46.39 45.34,47.67 44.06,48.96 41.38,48.96 40.45,48.02 37.05,48.02 35.76,49.31 31.75,49.31 v3(31.29,49.77)
  L6-GND w0.254: v3(46.1,44.1) 46.1,44.21 v1(46.3,44.41) ; v1(66.68,86.85) 66.68,87.15 v3(66.27,87.56)
+VREF_DQ0_DDR: length 30
  L4-SIG w0.254: v3(67.49,86.45) 67.49,88 66.85,88.63 61.6,88.63 60.45,89.77 v2(60.45,93.63) 60.45,98.16 59.46,99.14 v3(59.46,101.41)
  L6-GND w0.254: v1(59.85,101.96) 59.85,101.8 v3(59.46,101.41) ; v3(67.49,86.45) 67.49,86.78 v1(67.56,86.85)
  BOTTOM w0.254: U1601.U8 65.86,89.77 68.2,87.44 C1617.1 v1(67.56,86.85) 67.55,86.85 R1630.1 ; U1601.H17 61.3,94.48 v2(60.45,93.63) ; R1612.2 C1616.1 v1(59.85,101.96)
+VREF_DQ1: length 101.2
  L2-SIG w0.254: v2(43.49,100.16) 41.2,102.44 39.35,102.44 33.25,96.34 33.25,91.58 28.91,87.24 28.91,77.07 33.78,72.2 33.78,67.57 33.68,67.47 33.68,61.96 31.85,60.14 31.85,50.38 31.83,50.33 v8(31.75,50.25)
  L3-GND w0.254: v8(31.75,50.25) 31.85,50.15 v3(31.85,49.87)
  L4-SIG w0.254: v3(47.69,86.81) 46.04,86.81 43.38,89.46 43.38,100.06 v2(43.49,100.16)
  L5-SIG w0.254: v3(31.85,49.87) 31.95,49.77 37.92,49.77 38.58,49.11 39.57,49.11 40.1,49.63 43.88,49.63 46.2,47.31 46.2,46.49 47.07,45.63 47.07,44.43 v3(46.79,44.15)
  L6-GND w0.254: v1(47.07,44.41) 47.04,44.41 v3(46.79,44.15) ; v1(47.33,86.81) v3(47.69,86.81)
+VREF_DQ1_DDR: length 25.7
  L4-SIG w0.254: v3(47.09,85.96) 45.97,85.96 42.93,89.01 v2(42.93,94.88) 42.93,100.33 43.42,100.82 43.71,100.82 v3(43.92,100.62)
  L6-GND w0.254: v1(47.47,85.96) v3(47.09,85.96) ; v1(43.38,101.15) 43.39,101.15 v3(43.92,100.62)
  BOTTOM w0.254: R1701.2 R1702.1 v1(43.38,101.15) ; v1(47.47,85.96) 47.74,86.23 47.74,86.28 C1703.1 48.29,89.42 48.08,89.62 U1701.U8 ; U1701.H17 43.32,94.48 v2(42.93,94.88)
+VREFB: length 15.5
  L6-GND w0.06: 62.33,34.78 62.33,34.78 60.85,34.78 60.81,34.74 60.54,34.74 60.35,34.94 v6(60.32,34.94)
  L6-GND w0.254: v4(69.14,32.98) 66.98,32.98 66.85,32.85 64.1,32.85 63.81,33.15 63.81,33.84 62.87,34.78 62.33,34.78
  L7-SIG w0.254: v4(69.14,32.98) 70.1,32.98 70.43,32.65 72.36,32.65 72.57,32.86 72.57,33.08 72.93,33.44 v1(72.93,33.66)
  BOTTOM w0.254: C8343.2 v1(72.93,33.66)
+VREFCA_0: length 22.5
  L5-SIG w0.254: v2(64.86,98.53) 64.24,97.9 61.09,97.9 60.67,98.32 v2(59.16,98.32)
  L7-SIG w0.254: v2(64.86,98.53) 64.86,99.16 65.18,99.48 69.22,99.48 70.41,98.28 70.41,94.74 v2(69.84,94.17)
  BOTTOM w0.254: v2(69.84,94.17) 69.84,94.16 69.66,93.98 U1601.J1 ; U1601.A10 v2(64.86,98.53) ; v2(59.16,98.32) 59.16,97.52 58.95,97.32 R1610.1 58.24,97.33 58.24,97.74 58.25,97.76 C1615.1 R1611.2 C1614.1
+VREFCA_1: length 24
  L7-SIG w0.254: v1(54.61,102) 54.23,101.62 54.23,96.22 52.83,94.83 v2(52.27,94.83) 52.22,94.88 52.22,95.77 52.7,96.24 52.7,98.06 50.75,100.01 47.45,100.01 46.74,99.3 46.74,98.41 47.08,98.06 v1(47.08,97.98)
  BOTTOM w0.254: v2(52.27,94.83) 52.27,94.42 51.84,93.98 U1701.J1 ; v1(54.61,102) 54.98,102 54.99,102.02 R1703.1 56.12,102.02 R1704.2 C1702.1
+VREFDQ_0_PMIC: length 13.5
  L6-GND w0.152: 54.56,36.66 54.7,36.66 55.28,36.08 55.77,36.08 56.12,35.74 v6(56.32,35.74)
  L6-GND w0.254: v4(48.84,40.02) 48.84,39.9 51.08,37.65 53.53,37.65 54.52,36.66 54.56,36.66
  L7-SIG w0.254: v1(45.71,41.85) 46.45,41.85 46.78,41.52 47.82,41.52 48.51,40.83 48.51,40.28 48.77,40.02 v4(48.84,40.02)
+VREFDQ_1_PMIC: length 12.7
  L6-GND w0.152: v4(48.86,40.42) 49.5,39.79 49.5,39.67 51.21,37.96 53.75,37.96 54.33,37.37 54.33,37.28 54.65,36.97 54.79,36.97 55.47,36.29 55.86,36.29 56.15,36 56.46,36 v6(56.72,35.74)
  L7-SIG w0.254: v1(47.01,41.88) 47.97,41.88 48.86,40.98 v4(48.86,40.42)
+VREFT: length 23.3
  L6-GND w0.152: v6(60.72,35.29) 61.91,35.29 62.52,35.9 63.15,35.9 63.44,35.6 64.42,35.6 64.72,35.9 67.39,35.9 68.78,34.5 v4(69.05,34.5)
  L7-SIG w0.203: v4(69.05,34.5) 69.32,34.24 71.49,34.24 71.73,33.99 73.13,33.99 73.92,33.2 73.92,32.31 73.3,31.69 73.3,30.93 v1(73.74,30.49)
  BOTTOM w0.254: v1(73.74,30.49) 73.74,30.24 73.71,30.21 C8341.2 73.71,29.43 73.86,29.27 75.05,29.27 75.22,29.44 R8372.2 75.22,30.11 75.31,30.21 R8328.2 R8329.2 R8326.2
+VRTC: length 37
  L2-SIG w0.254: v8(74.07,66.94) 74.74,67.61 74.74,67.63 v2(79.17,72.05)
  L3-GND w0.254: v8(74.07,66.94) 73.89,66.94 v3(73.71,66.76)
  L5-SIG w0.152: v6(58.25,69) 58.46,69 59.37,69.91 59.56,69.91
  L5-SIG w0.203: 59.56,69.91 61.2,69.91 61.7,69.41 62.02,69.41 62.87,68.56 63.12,68.56 63.66,68.03 66.76,68.03 67.65,67.14 72.95,67.14 73.33,66.76 v3(73.71,66.76)
  L7-SIG w0.254: v2(79.17,72.05) 79.15,72.05 79.14,72.04 79.15,72.03 79.15,70.64 80.42,69.38 80.42,66.27 79.93,65.79 79.93,65.71 v1(79.29,65.06) v1(79.29,64.45)
  BOTTOM w0.254: v2(79.17,72.05) 79.15,72.05 79.17,72.07 D2701.3 79.17,73.42 79.92,74.17 C2701.1 80.49,74.38 R2701.2
+VSDIO: length 125.4
  L2-SIG w0.254: v8(82.91,50.48) 83.62,50.48 v8(88.19,55.05) ; v8(43.97,43.11) 45.32,44.46 45.32,50.53 v8(44.37,51.47) ; v8(38.31,68.64) 38.31,56.16 40.08,54.39 v8(40.08,53.39)
  L3-GND w0.254: v3(40.08,53.03) v8(40.08,53.39) ; v3(38.63,68.83) 38.44,68.64 v8(38.31,68.64) ; v3(44.02,51.22) 44.27,51.47 v8(44.37,51.47) ; v8(88.19,55.05) 88.19,55.33 88.27,55.41 v3(88.27,55.46) ; v3(43.97,42.76) v8(43.97,43.11) ; v3(82.55,50.48) v8(82.91,50.48)
  L5-SIG w0.254: v3(93.47,85.92) 93.47,64.35 92.48,63.36 92.48,56.82 91.12,55.46 v3(88.27,55.46) ; v3(82.55,50.48) 82.45,50.48 81.13,49.16 59.1,49.16 57.11,51.15 54.45,51.15 53.39,51.15 52.83,50.59 49.91,50.59 49.6,50.91 46.47,50.91 46.17,51.21 44.03,51.21 v3(44.02,51.22) 41.9,51.22 v3(40.08,53.03)
  L6-GND w0.254: v4(43.97,42.4) v3(43.97,42.76) ; v3(38.63,68.83) 38.65,68.81 38.87,68.81 v4(39.05,68.64) ; v3(93.47,85.92) 93.47,86.05 v1(92.85,86.67)
  L7-SIG w0.254: v4(39.05,68.64) 39.05,68.24 39.74,67.55 40.79,67.55 41.17,67.92 v1(42.14,67.92) 42.65,67.92 42.82,68.1 43.27,68.1 ; v4(43.97,42.4) 43.97,41.79 43.05,40.88 v1(43.05,40.8)
  BOTTOM w0.102: T8311.1 93.66,85.79 R0724.1
  BOTTOM w0.254: C2762.1 42.05,68.02 v1(42.14,67.92)
  vias: v6(44.05,69.05)
+VSPI: length 165.5
  L2-SIG w0.254: v2(75.02,88.11) 75.11,88.02 v2(79.76,88.02) 80.09,87.69 v2(81.48,87.69)
  L2-SIG w0.508: v2(10.49,73.01) 11.14,72.36 17.92,72.36 22.3,76.74 22.3,85.94 30.56,94.19 30.56,104.51 30.89,104.84 36.35,104.84 37.55,103.64 42.25,103.64 42.46,103.42 59.74,103.42 63.46,107.15 79.28,107.15 81.06,105.37 81.06,94.84 80.65,94.43 80.65,91.66 81.48,90.83 v2(81.48,87.69)
  L7-SIG w0.203: 79.73,84.33 79.73,82.48 78.66,81.42 v1(78.66,81.21)
  L7-SIG w0.254: v1(76.8,85.13) 76.86,85.13 77.65,84.33 79.73,84.33 81.48,86.08 v2(81.48,87.69) ; v2(75.02,88.11) 73.92,89.21 73.23,89.21 72.77,89.67 v1(72.77,89.93) 72.23,90.47 72.23,91.92 v1(72.77,92.47) ; v1(77.5,87.72) 77.65,87.56 77.65,87.16 78.01,86.8 v1(79.76,86.8) v2(79.76,88.02) 79.76,89.58 80.65,90.47 v1(80.65,90.79)
  BOTTOM w0.102: v1(72.77,89.93) 72.77,89.01 v9(72.92,88.86)
  BOTTOM w0.203: R3348.2 v1(78.66,81.21)
  BOTTOM w0.254: R3338.1 v1(80.65,90.79) U3302.8
  BOTTOM w0.305: 16.16,74.62 16.62,74.15 CON3301.1 16.62,73.05 16.42,72.84 15.84,72.84 15.62,73.06 CON3301.3
  BOTTOM w0.432: 16.16,74.62 C3311.1 16.16,75.14 15.15,76.15 12.95,76.15 12.26,75.46 10.12,75.46 9.46,74.8 9.46,73.71 10.16,73.01 v2(10.49,73.01)
+VSPI_PROG: length 22
  L4-SIG w0.254: v3(86.87,90.28) 86.72,90.13 85.08,90.13 84.08,89.13 83.92,88.97 83.34,88.97 82.87,88.5 82.87,83.41 v3(77.6,78.14)
  L6-GND w0.254: v1(77.79,77.72) 77.6,77.9 v3(77.6,78.14) ; v3(86.87,90.28) 86.88,90.27 v4(87.25,90.27)
  L7-SIG w0.254: v1(87.65,90.27) v4(87.25,90.27)
  BOTTOM w0.102: v9(88.62,92.34) 88.11,91.83 88.11,90.54 87.85,90.27 v1(87.65,90.27)
  BOTTOM w0.254: C3319.1 77.62,77.56 v1(77.79,77.72)
+VSPI_R: length 3.2
  BOTTOM w0.203: R3348.1 77.93,80.02 77.79,79.88 U3304.5 77.79,79.02 77.93,78.88 78.97,78.88 79.14,79.04 U3304.8
+VSYS: length 114.9
  L2-SIG w0.254: v2(94.83,94.29) 95,94.13 95,85.8 89.51,80.31 89.51,73.67 89.94,73.24 89.94,61.87 85.19,57.12 85.19,54.88 82.22,51.91 82.22,50.13 83.14,49.21 83.95,49.21 v8(84.19,48.98)
  L3-GND w0.254: v8(84.19,48.98) 84.25,48.98 84.25,48.98 v3(84.55,48.98)
  L6-GND w0.254: v3(49.4,25.16) 49.33,25.23 v1(48.91,25.23) ; v1(29.97,19.24) 30.35,19.24 30.47,19.36 v3(30.56,19.36) ; v1(69.19,28.08) 68.99,28.08 v3(68.66,27.75) ; v4(84.18,48.98) 84.18,48.98 v3(84.55,48.98) ; v3(69.5,32.55) 69.11,32.17 v1(69.11,32.14)
  L7-SIG w0.203: v1(58.02,39.23) 57.99,39.19 57.99,38.12 58.37,37.74 58.51,37.74 58.75,37.51 v6(58.75,37.34)
  L7-SIG w0.254: v1(29.97,19.24) v1(29.97,20.13) ; v1(40.74,23.73) v1(40.74,23) 41.17,22.56 41.17,21.96 v1(40.74,21.52) 40.08,20.86 40.08,16.21 38.74,14.87 v11(38.74,13.55) ; v4(84.18,48.98) 84.18,45.14 79.71,40.66 72.68,40.66 v1(72.06,40.04) ; v1(39.47,47.99) v1(39.47,48.75) 41.21,48.75 41.49,48.47 41.49,47.59 40.82,46.92 38.51,46.92 38.04,46.45 38.04,44.96 37.01,43.93 37.01,42.66 36.25,41.9 v1(36.25,41.08) v1(36.25,40.19) ; v1(34.98,16.6) 34.98,15.71 34.5,15.22 v1(32.43,15.22)
  BOTTOM w0.102: v6(61.52,36.54) U8201.R4
  BOTTOM w0.152: U8201.R4 U8201.P5 ; U8201.L2 U8201.M1 ; U8201.B5 v6(55.92,36.54) ; U8201.E2 U8201.D1
  BOTTOM w0.203: U8201.D1 57.05,37.81 57.05,38.15 56.69,38.5 ; 60.45,38.36 60.32,38.23 U8201.M1
  BOTTOM w0.254: U8201.R4 61.77,36.54 62.28,37.04 62.28,37.73 62.92,38.36 63.12,38.36 ; R2021.1 v2(94.83,94.29) ; R8803.1 34.39,17.2 v1(34.98,16.6)
  vias: v1(51.7,38.65) v1(51.7,38.36) v1(52.01,38.65) v1(52.01,38.36) v1(52.53,32.58) v1(52.67,38.65) v1(52.67,38.36) v1(52.69,35.06) v1(52.69,34.79) v1(52.81,32.58) v1(52.95,38.65) v1(52.95,38.36) v1(52.97,35.06) v1(52.97,34.79) v1(53.11,32.58) v1(53.28,35.06) v1(53.28,34.79) v1(55.69,41.07) v1(55.69,40.76) v1(55.72,41.35) v1(55.71,40.19) v1(55.71,39.89) v1(55.99,41.35) v1(55.99,41.07) v1(55.99,40.76) v1(56,40.19) v1(56,39.89) v1(56.89,30.24) v1(56.89,29.94) v1(57.2,30.26) v1(57.19,29.94) v1(58.02,39.81) v1(58.02,39.53) v1(60.48,29.88) v1(60.48,29.6) v1(60.48,29.3) v1(60.53,41.03) v1(60.53,40.73) v1(60.57,40.14) v1(60.57,39.86) v1(60.57,39.56) v1(60.77,29.88) v1(60.77,29.6) v1(60.77,29.3) v1(60.82,41.03) v1(60.82,40.73) v1(60.86,40.14) v1(60.86,39.86) v1(63.3,38.45) v1(63.3,38.16) v1(63.58,38.45) v1(63.58,38.16) v1(63.59,34.86) v1(63.59,34.57) v1(63.88,38.45) v1(63.88,38.16) v1(63.87,34.86) v1(63.87,34.57) v1(64.17,34.86) v1(64.17,34.57) v1(64.26,33.48) v1(64.26,33.2) v1(64.36,38.46) v1(64.36,38.17) v1(64.54,33.48) v1(64.54,33.2) v1(64.67,38.46) v1(64.67,38.17) v1(64.85,33.48) v1(64.85,33.2) v1(64.95,38.46) v1(64.95,38.17) v1(65,28.56) v1(65,28.26) v1(65.28,28.56) v1(65.28,28.26) v1(65.58,28.56) v1(65.58,28.26) v1(71.41,40.04) v1(71.41,39.7) v1(71.41,39.38) v1(71.41,39.07) v1(71.41,38.77) v1(71.41,38.47) v1(71.69,40.04) v1(71.69,39.7) v1(71.69,39.38) v1(71.69,39.07) v1(71.69,38.77) v1(71.69,38.47) v1(71.98,39.69) v1(71.98,39.38) v1(71.98,39.07) v1(71.98,38.77) v1(71.98,38.47) v2(50.57,28.43) v2(51.44,28.43) v2(52.05,28.76) v2(52.15,29.42) v2(52.22,30.11) v2(52.65,30.59) v3(51.08,39.15) v3(51.66,39.15) v3(52.15,35.42) v3(52.15,34.88) v3(52.22,39.15) v3(52.43,32.22) v3(52.81,39.15) v3(52.93,32.22) v3(53.44,32.22) v3(55.32,42.94) v3(55.32,42.4) v3(55.86,42.96) v3(55.88,42.4) v3(57.02,30.65) v3(57.05,29.47) v3(58.12,41.67) v3(58.12,41.06) v3(60.1,29.35) v3(60.1,28.79) v3(60.68,41.46) v3(60.68,40.29) v3(63.91,39.71) v3(63.91,38.9) v3(64.29,34.15) v3(64.44,39.71) v3(64.47,38.9) v3(64.52,28.76) v3(64.52,28.25) v3(64.8,34.15) v3(65.02,39.71) v3(65.02,38.9) v3(65.02,34.63) v3(65.35,34.2) v3(65.38,33.64) v3(67.26,40.17) v3(68.5,40.17) v3(70.84,40.47) v3(70.87,39.86) v3(71.35,40.47) v3(71.88,40.47) v3(72.43,40.37) v3(72.44,39.81) v3(72.44,39.23) v3(72.44,38.64) v4(51.7,38.65) v4(51.7,38.36) v4(52.01,38.65) v4(52.01,38.36) v4(52.53,32.58) v4(52.67,38.65) v4(52.67,38.36) v4(52.69,35.06) v4(52.69,34.79) v4(52.81,32.58) v4(52.95,38.65) v4(52.95,38.36) v4(52.97,35.06) v4(52.97,34.79) v4(53.11,32.58) v4(53.28,35.06) v4(53.28,34.79) v4(55.69,41.07) v4(55.69,40.76) v4(55.72,41.35) v4(55.71,40.19) v4(55.71,39.89) v4(55.99,41.35) v4(55.99,41.07) v4(55.99,40.76) v4(56,40.19) v4(56,39.89) v4(56.89,30.24) v4(56.89,29.94) v4(57.2,30.26) v4(57.19,29.94) v4(58.02,39.81) v4(58.02,39.53) v4(60.48,29.88) v4(60.48,29.6) v4(60.48,29.3) v4(60.53,41.03) v4(60.53,40.73) v4(60.57,39.86) v4(60.57,39.56) v4(60.77,29.88) v4(60.77,29.6) v4(60.77,29.3) v4(60.82,41.03) v4(60.82,40.73) v4(60.86,39.86) v4(63.3,38.45) v4(63.3,38.16) v4(63.58,38.45) v4(63.58,38.16) v4(63.59,34.86) v4(63.59,34.57) v4(63.88,38.45) v4(63.88,38.16) v4(63.87,34.86) v4(63.87,34.57) v4(64.17,34.86) v4(64.17,34.57) v4(64.26,33.48) v4(64.26,33.2) v4(64.36,38.46) v4(64.36,38.17) v4(64.54,33.48) v4(64.54,33.2) v4(64.67,38.46) v4(64.67,38.17) v4(64.85,33.48) v4(64.85,33.2) v4(64.95,38.46) v4(64.95,38.17) v4(65,28.56) v4(65,28.26) v4(65.28,28.56) v4(65.28,28.26) v4(65.58,28.56) v4(65.58,28.26) v4(71.41,40.04) v4(71.41,39.7) v4(71.41,39.38) v4(71.41,39.07) v4(71.41,38.77) v4(71.41,38.47) v4(71.69,40.04) v4(71.69,39.7) v4(71.69,39.38) v4(71.69,39.07) v4(71.69,38.77) v4(71.69,38.47) v4(71.98,39.69) v4(71.98,39.38) v4(71.98,39.07) v4(71.98,38.77) v4(71.98,38.47) v6(55.92,34.54) v6(55.92,33.74) v6(56.32,33.74) v6(59.52,32.54) v6(59.52,32.14) v6(61.12,33.74) v6(61.52,34.94) v6(61.52,33.74) v11(32.49,14.51) v11(32.51,13.6) v11(33.38,14.56) v11(35.18,32.34) v11(35.48,36.66) v11(35.48,34.07) v11(35.48,33.21) v11(35.51,35.8) v11(35.51,34.93) v11(35.74,31.68) v11(37.85,13.07) v11(38.76,12.63) v11(50.55,30.06) v11(50.55,29.18) v11(51.44,30.03) v11(51.41,29.17)
+VSYS_DOCKING:
  vias: v11(25.15,21.04) v11(25.15,20) v11(25.3,28.76) v11(25.3,27.72) v11(28.65,16.9) v11(29.4,15.41) v11(29.4,14.47)
+VSYS_S: length 19.6
  L6-GND w0.06: v6(59.12,33.34) 59.28,33.17 59.28,32.44 60.07,31.65 60.07,31.23
  L6-GND w0.102: v4(59.23,25.36) 59.23,26.02 59.59,26.37 59.59,29.42 60.07,29.9 60.07,31.23
  L7-SIG w0.102: v1(64.97,23.73) 64.67,23.43 64.67,22.07 63.54,20.94 61.9,20.94 58.83,24 58.83,24.88 59.23,25.28 v4(59.23,25.36)
+VSYS_SX_EN#: length 17.1
  L5-SIG w0.102: v3(41.39,33.49) 41.82,33.06 43.55,33.06 43.77,33.28 57.46,33.28 v6(57.52,33.34)
  L6-GND w0.102: v1(41.11,32.98) 41.39,33.26 v3(41.39,33.49)
+VSYS_U_EN#: length 6.6
  L3-GND w0.102: v8(55.26,29.12) v3(54.9,29.12)
  L5-SIG w0.06: 57.73,33.01 57.73,33.93 v6(57.92,34.12)
  L5-SIG w0.102: v3(54.9,29.12) 54.9,30.03 57.73,32.85 57.73,33.01
+VUSBPHY_PMIC: length 15.9
  L6-GND w0.152: v6(58.67,32.94) 58.7,32.91 58.7,32.22 59.03,31.89 59.03,30.71 58.78,30.46 58.78,27.16 58.04,26.43 v4(58.04,26.27)
  L7-SIG w0.102: v1(58.31,18.47) v1(58.31,19.14)
  L7-SIG w0.152: v4(58.04,26.27) 58.04,26.1 57.94,26 57.94,23.91 58.34,23.52 58.56,23.52 58.75,23.33 58.75,22.74 58.54,22.53 58.54,21.43 58.75,21.22 58.75,20.36 58.4,20 58.4,19.22 v1(58.31,19.14)
A_BAT_THERM: length 5.1
  BOTTOM w0.102: U8800.11 31.46,24.18 R8807.1 30.94,24.37 30.81,24.24 29.79,24.24 29.64,24.39 29.64,24.88 29.43,25.09 29.43,25.26 R8822.2 R8804.1
A_BPTHERM_R: length 83.6
  L2-SIG w0.102: v8(38.64,49.23) 38.64,47.42 38.89,47.17 v8(38.89,44.94)
  L3-GND w0.102: v3(38.81,49.57) 38.64,49.39 v8(38.64,49.23) ; v3(39.24,44.76) 39.07,44.94 v8(38.89,44.94)
  L4-SIG w0.102: v3(38.81,49.57) 39.14,49.89 41.83,49.89 42.79,48.93 48.25,48.93 49.06,48.13 59.15,48.13 59.35,48.32 59.66,48.32 59.84,48.15 67.58,48.15 71.4,51.97 71.4,58.96 72.11,59.67 72.11,59.67 72.34,59.9 72.34,59.9 72.34,62.28 v3(73.42,63.36) ; v3(37.62,26.58) 37.62,32.77 36.96,33.43 36.96,37.68 v3(37.24,37.96)
  L6-GND w0.102: v3(73.42,63.36) 73.42,63.72 v1(73.36,63.78) ; v4(37.06,26.58) v3(37.62,26.58) ; v3(37.24,37.96) 37.59,38.31 v1(37.69,38.31) ; v3(39.24,44.76) v4(38.99,45.02)
  L7-SIG w0.102: v1(37.69,38.31) 39.09,39.71 39.09,41.44 38.28,42.25 38.28,42.55 37.71,43.12 37.71,44.15 38.58,45.02 v4(38.99,45.02) ; v4(37.06,26.58) 36.02,27.62 33.91,27.62 30.99,24.7 v1(30.07,24.7)
A_BT_PCM_CLK: length 15.6
  L5-SIG w0.109: v3(4,84.65) 4.35,84.65 4.67,84.33 13.18,84.33 15.5,86.66 v3(16.37,86.66)
  L6-GND w0.102: v3(16.37,86.66) 16.46,86.57 v1(16.71,86.57) ; v1(4,84.29) v3(4,84.65)
  BOTTOM w0.31: v1(16.71,86.57) 16.71,87.34 v9(16.24,87.81)
A_BT_PCM_SYNC: length 13
  L5-SIG w0.109: v3(4.37,82.86) 13.53,82.86 14,83.32 16.1,83.32 v3(16.36,83.58)
  L6-GND w0.102: v3(4.37,82.86) 4.3,82.79 v1(4,82.79) ; v1(16.71,83.58) v3(16.36,83.58)
A_CLK_32K_OUT_WIFI: length 2.5
  L7-SIG w0.084: v1(15.2,78.79) 16.17,78.79 v1(16.71,78.24) v1(16.71,77.48)
A_I2S_1_CLK: length 38.9
  L4-SIG w0.109: v3(24.45,82.25) 24.45,79.9 26.47,77.88 v3(26.47,77.75)
  L5-SIG w0.109: v3(17.6,86.93) 22.28,82.25 v3(24.45,82.25)
  L6-GND w0.102: v3(26.47,77.75) 26.64,77.75 v1(26.8,77.59) ; v3(17.6,86.93) 17.6,86.59 v1(17.58,86.57)
  L7-SIG w0.06: v6(46.35,70.18) 46.21,70.18 46.19,70.2 45.8,70.2 45.78,70.23 44.67,70.23 44.48,70.04 43.33,70.04
  L7-SIG w0.084: v1(26.8,77.59) 27.28,78.06 29.46,78.06 31.12,76.41 33.31,76.41 39.15,70.56 39.15,70.48 39.87,69.77 41.56,69.77 41.83,70.04 43.33,70.04
  BOTTOM w0.31: v1(26.8,77.59) v9(26.8,76.97)
A_I2S_1_FS: length 44.4
  L5-SIG w0.06: v6(48.06,70.82) 47.82,70.82 47.79,70.78 47.36,70.78 46.95,70.37 45.54,70.37 45.27,70.64 44.84,70.64 44.03,69.83 43.41,69.83 43.41,69.83 43.33,69.83
  L5-SIG w0.109: 43.33,69.83 40.53,69.83 40.15,70.21 38.7,70.21 29.15,79.76 29.15,83.46 29.14,83.46 29.14,85.95 29.04,86.05 v3(29.04,86.48)
  L6-GND w0.102: v3(29.04,86.48) 29.01,86.51 28.69,86.51 v4(28.68,86.5)
  L7-SIG w0.084: v1(17.58,83.58) 18.43,82.72 21.31,82.72 21.95,82.08 24.37,82.08 28.46,86.16 28.46,86.27 v4(28.68,86.5)
A_LCD_BKLT_EN_PWM: length 58.7
  L7-SIG w0.084: v1(62.38,12.63) 62.23,12.79 62.23,14.44 v1(63.88,16.09) ; v1(62.38,12.63) 62.08,12.33 61.16,12.33 60.94,12.56 60.94,13.22 60.73,13.42 59.44,13.42 58.55,14.31 57.53,14.31 54.94,16.9 54.94,18.34 54.76,18.52 52.29,18.52 51.75,17.97 49.52,17.97 47.85,19.64 47.14,19.64 44.32,22.46 44.32,23.09 43.99,23.43 43.11,23.43 v1(42.87,23.67) 42.55,23.98 42.09,23.98 v1(41.61,24.47) v1(41.61,25.21) ; v1(62.38,12.63) 64.78,12.63 66.09,11.31 83.54,11.31 v1(85.85,13.62)
  BOTTOM w0.31: v1(85.85,13.62) v9(85.85,12.77)
A_LCD_BKLT_PWM_EDP: length 12.7
  L4-SIG w0.109: v3(70.26,13.88) 69.9,13.52 68.29,13.52 67.61,12.84 64.64,12.84 63.69,13.79 v3(59.42,13.79)
  L6-GND w0.102: v3(70.26,13.88) 70.26,13.88 70.47,14.08 v1(70.47,14.26) ; v1(59.99,13.79) v3(59.42,13.79)
A_PLT_CLK3_I2SMCLK: length 13.2
  L4-SIG w0.109: v3(46,64.68) 44.98,64.68 44.2,65.46 38.18,65.46 35.42,68.22 v3(35.1,68.22)
  L6-GND w0.06: v3(46,64.68) 46.15,64.53 v6(46.35,64.53)
  L6-GND w0.102: v1(35.43,68.49) 35.37,68.49 35.3,68.42 v3(35.1,68.22)
A_PROG_SPI_CLK: length 15.1
  L6-GND w0.102: v1(87.65,91.07) 87.23,91.07 v4(86.73,91.56)
  L7-SIG w0.084: v4(86.73,91.56) 83.57,91.56 83.13,92.01 81.96,92.01 81.44,91.49 81.44,89.6 80.18,88.34 80.18,86.63 79.93,86.38 77.83,86.38 77.56,86.65 v1(77.56,86.74)
A_RTC_XTAL_IN: length 4.6
  L7-SIG w0.06: v6(64.14,62.2) 64.12,62.22 v6(63.35,62.22) 63.27,62.22 61.8,63.69 61.8,63.71
  L7-SIG w0.066: 61.8,63.71 61.8,64.13 61.45,64.47 61.37,64.47 61.14,64.71 v6(61.14,65.03)
A_RTC_XTAL_OUT: length 7.6
  L7-SIG w0.066: v6(60.78,64.8) 61.2,64.37 61.2,64.08 62.38,62.9 62.38,62.54 62.55,62.38 62.68,62.38 63.11,61.96 63.11,61.82 63.32,61.6 v1(63.32,61.38) 63.14,61.19 63.14,60.1 v1(62.99,59.96) 64.38,59.96 v1(64.47,59.88)
A_SDIO2_CLK: length 51.7
  L5-SIG w0.109: v3(39.08,68.15) 38.47,68.15 33.16,73.45 33.16,73.76 31.85,75.07 31.41,75.07 29.67,76.81 26.66,76.81 26.16,76.31 12.75,76.31 12.42,76.65 11.97,76.65 11.33,76 6.75,76 3.16,79.59 3.16,81.39 v3(3.1,81.44)
  L6-GND w0.102: v1(2.72,81.44) v3(3.1,81.44) ; v4(40.1,68.72) 39.99,68.61 39.54,68.61 v3(39.08,68.15)
  L7-SIG w0.06: 43.33,69 43.49,69 43.97,69.47 44.42,69.47 44.64,69.25 45.97,69.25 v6(46.05,69.32)
  L7-SIG w0.084: v4(40.1,68.72) 42.03,68.72 42.3,69 43.33,69
A_SDIO2_CMD: length 51.3
  L5-SIG w0.109: v3(31.7,74.39) 31.51,74.39 29.5,76.4 26.83,76.4 26.22,75.79 11.83,75.79 11.63,75.59 5.78,75.59 v3(2.74,78.62)
  L6-GND w0.102: v1(32.04,74.55) 31.87,74.39 v3(31.7,74.39) ; v3(2.74,78.62) 2.62,78.75 v1(2.62,79)
  L7-SIG w0.06: 43.33,69.33 43.43,69.33 43.69,69.59 44.48,69.59 44.7,69.37 45.81,69.37 45.96,69.53 46.15,69.53 46.28,69.4 46.62,69.4 v6(46.69,69.32)
  L7-SIG w0.084: v1(32.04,74.55) 34.16,74.55 38.44,70.27 38.44,70.19 39.57,69.06 41.88,69.06 42.16,69.33 43.33,69.33
  BOTTOM w0.31: v9(32.35,75.37) 32.04,75.05 v1(32.04,74.55) ; R5429.2 v1(2.62,79)
A_SDIO2_DATA_0: length 53.3
  L5-SIG w0.109: v3(31.23,74.04) 31.23,74.34 29.38,76.19 26.93,76.19 26.32,75.58 11.92,75.58 11.72,75.38 4.72,75.38 3.15,76.96 v3(2.72,76.96)
  L6-GND w0.102: v1(2.72,77.45) v3(2.72,76.96) ; v1(31.09,74.38) 31.09,74.29 31.23,74.15 v3(31.23,74.04)
  L7-SIG w0.06: v6(46.35,69.04) 46.31,69 45.2,69 44,67.8 43.33,67.8
  L7-SIG w0.084: 43.33,67.8 42.97,67.8 42.78,67.6 41.25,67.6 40.92,67.26 39.59,67.26 38.02,68.83 38.02,70.17 34.09,74.1 31.37,74.1 v1(31.09,74.38)
  BOTTOM w0.31: v1(31.09,74.38) 30.48,74.99 v9(30.48,75.37) ; R5430.2 v1(2.72,77.45)
A_SDIO2_DATA_1: length 53.6
  L5-SIG w0.06: 43.41,67.53 43.51,67.53 45.29,69.31 45.63,69.31 45.82,69.5 47.39,69.5 v6(47.49,69.6)
  L5-SIG w0.109: 43.41,67.53 37.64,67.53 36.36,68.8 36.36,69.56 32.75,73.18 31.55,73.18 30.83,73.9 30.83,74.44 29.29,75.97 27.83,75.97 26.81,74.96 5.35,74.96 4.05,73.66 3.71,73.66 3.1,74.27 v3(3.1,75.88)
  L6-GND w0.102: v1(2.72,75.88) v3(3.1,75.88)
  BOTTOM w0.31: R5431.2 v1(2.72,75.88)
A_SDIO2_DATA_2: length 50.7
  L5-SIG w0.109: v3(26.92,75.63) 26.67,75.37 12.01,75.37 11.8,75.17 5,75.17 v3(3.87,74.04)
  L6-GND w0.102: v1(3.46,73.82) 3.65,73.82 v3(3.87,74.04) ; v4(27.26,75.81) 27.1,75.81 v3(26.92,75.63)
  L7-SIG w0.06: v6(46.97,69.04) 46.89,69.12 46.61,69.12 46.48,69.24 46.27,69.24 46.14,69.12 44.56,69.12 44.36,69.31 43.98,69.31 43.33,68.66
  L7-SIG w0.084: v4(27.26,75.81) 28.38,74.69 31.5,74.69 31.9,74.28 34.17,74.28 38.26,70.19 38.26,69.91 39.79,68.38 42.17,68.38 42.44,68.66 43.33,68.66
  BOTTOM w0.31: v9(3.31,72.95) 3.46,73.09 v1(3.46,73.82) 2.74,74.53 R5432.2
A_SDIO2_DATA_3: length 50.9
  L5-SIG w0.06: 44.23,67.85 44.23,68.08 45.34,69.19 45.68,69.19 45.87,69.38 47.56,69.38 47.77,69.59 v6(48,69.59)
  L5-SIG w0.109: 44.23,67.85 43.7,67.32 37.54,67.32 36.14,68.72 36.14,69.48 32.66,72.96 31.46,72.96 30.62,73.81 30.62,74.35 29.2,75.76 27.92,75.76 26.9,74.75 5.71,74.75 v3(4.45,73.49)
  L6-GND w0.102: v1(4.22,73.16) 4.45,73.39 4.45,73.49 v3(4.45,73.49)
  BOTTOM w0.31: R5406.1 v1(4.22,73.16)
A_SOC_SPI_CLK: length 49.7
  L4-SIG w0.109: v3(80.75,92.59) 80.75,91.62 80.02,90.89 78.14,90.89 v3(77.11,89.86)
  L5-SIG w0.06: v5(61.44,71.31) 61.96,70.79 62.64,70.79
  L5-SIG w0.109: 62.64,70.79 64.14,69.3 68.02,69.3 68.28,69.56 69.43,69.56 69.87,69.12 70.19,69.12 72.21,71.14 72.21,71.41 73.53,72.73 74.42,72.73 76.85,75.16 76.85,77.29 76.93,77.36 76.93,79.45 76.75,79.64 76.75,87.74 76.07,88.41 76.07,88.82 76.07,88.82 v3(77.11,89.86)
  L6-GND w0.102: v1(80.75,92.97) v3(80.75,92.59)
  L7-SIG w0.06: v5(61.44,71.31) 61.44,71.31 61.05,70.92 61.04,70.92 60.89,70.77 60.72,70.77 60.61,70.88 60.39,70.88 60.24,70.74 v6(59.95,70.74)
  L7-SIG w0.084: v1(80.75,92.97) 80.75,92.57 79.61,91.43 79.61,90.3 78.83,89.52 78.83,88.52 78.22,87.9 78.18,87.9 77.92,87.9 77.58,88.24 v1(77.04,88.24)
A_SOC_XTAL_IN: length 19.4
  L7-SIG w0.066: v6(52.29,64.8) 52.45,64.64 52.45,63.54 52.15,63.23 51.58,63.23 51.06,62.71 51.06,61.88 51.56,61.38 v1(52.86,61.38)
  BOTTOM w0.257: v1(52.86,61.38) 53,61.23 v9(53,60.28) 53,59.19 52.92,59.11 52.92,58.79 52.5,58.37 44.61,58.37 43.97,59.01 43.97,59.44 SP2602.2 43.82,59.6 R2600.1
A_SOC_XTAL_OUT: length 24.6
  L7-SIG w0.06: 43.39,59.89 43.39,59.91 v6(42.95,60.35) 42.5,60.35
  L7-SIG w0.066: v6(52.01,65.08) 52.01,64.79 52.25,64.55 52.25,63.65 52.01,63.41 51.44,63.41 50.83,62.8 50.83,61.21 51.25,60.78 51.38,60.78 51.69,60.47 51.69,60 52.02,59.67 52.1,59.67 52.6,59.17 52.6,58.33 v1(52,57.73) ; 42.5,60.35 42.31,60.35 v1(42.26,60.3) 40.05,60.3 v1(39.17,61.19) ; v1(43.33,59.09) 43.39,59.15 43.39,59.89
  BOTTOM w0.257: v1(52,57.73) 50.42,57.73 46.92,57.73 44.3,57.73 43.33,58.7 v1(43.33,59.09)
A_SPI_CLK: length 114.9
  L4-SIG w0.109: v2(79.89,105.67) 80.52,105.04 80.52,94.5 v3(80.04,94.02)
  L6-GND w0.102: v1(80.65,93.84) 80.21,93.84 v3(80.04,94.02)
  L7-SIG w0.084: v1(79.54,93.33) 80.14,93.33 v1(80.65,93.84) 79.57,93.84 79.14,93.4 79.14,92.33 78.75,91.94 78.75,90.64 78.04,89.92 v1(78.04,88.74) ; v1(13.62,73.9) 13.32,74.2 13.32,75.4 13.5,75.58 13.5,84.27 14.13,84.9 14.13,86.17 16.76,88.8 16.76,98.22 20.59,102.05 24.88,102.05 26.11,103.28 26.11,104.36 27.96,106.21 v1(30.75,106.21) 79.36,106.21 v2(79.89,105.67)
  BOTTOM w0.31: v1(30.75,106.21) v9(29.9,106.21)
A_SUS_CLK_GPS: length 3.8
  L3-GND w0.06: v8(61.65,65.87) v3(61.93,66.15)
  L5-SIG w0.06: v6(59.09,67.05) 59.11,67.05 59.36,67.3 60.22,67.3 61.37,66.15 v3(61.93,66.15)
A_SUS_CLK_WLAN: length 58.8
  L4-SIG w0.109: v3(18,78.13) 23.26,72.86 26,72.86 30.68,68.19 30.95,68.19 32.5,66.64 33.37,66.64 36.63,63.38 36.63,62.37 36.32,62.06 36.32,61.72 36.59,61.45 39.28,61.45 40.52,60.2 43.7,60.2 44.57,59.33 47.48,59.33 48.54,58.28 v3(54.43,58.28)
  L6-GND w0.102: v3(54.43,58.28) 54.53,58.18 v4(55.12,58.18) ; v3(18,78.13) 17.71,78.13 17.6,78.24 v1(17.58,78.24)
  L7-SIG w0.06: 56.46,61.93 57.03,62.5 57.03,63.88 57.17,64.02 57.17,65.24 57.54,65.61 57.54,65.71 58.15,66.32 58.28,66.32 58.53,66.57 59.65,66.57 59.86,66.78 v6(59.88,66.78)
  L7-SIG w0.084: v4(55.12,58.18) 55.37,58.18 55.97,58.77 55.97,59.47 55.86,59.57 55.86,60.56 56.34,61.04 56.34,61.81 56.46,61.93
A_SVID_ALERT#: length 17.5
  L7-SIG w0.084: v1(45.56,50.99) v1(46.25,50.99) 46.45,51.19 46.45,51.25 46.69,51.49 46.69,52 48.39,53.7 48.68,53.7 54.71,53.7 58.19,57.17 58.19,57.4 57.96,57.62 57.96,58.45 57.89,58.53 v1(57.89,59.04)
A_SVID_CLK: length 31.6
  L5-SIG w0.06: v6(60.8,70.98) 60.73,71.05 60.4,71.05 60.27,71.18 60.06,71.18 58.5,69.62 58.21,69.62 57.68,69.1
  L5-SIG w0.084: v5(57.51,62.21) 57.51,62.34 57.93,62.76 57.93,65.79 57.48,66.23 57.48,67.93 57.68,68.13 57.68,69.1
  L7-SIG w0.084: v5(57.51,62.21) 56.82,61.52 56.82,60.05 57.26,59.6 57.31,59.6 57.51,59.4 57.51,58.42 57.62,58.31 57.62,57.91 57.32,57.61 57.32,56.98 54.37,54.04 48.54,54.04 48.19,54.04 46.28,52.12 46.28,51.76 v1(46.25,51.72) 46.13,51.61 v1(45.56,51.61)
A_SVID_DATA: length 18.1
  L7-SIG w0.084: v1(45.58,50.35) 46.24,50.35 v1(46.25,50.35) 46.8,50.9 46.8,51.16 46.93,51.3 46.93,51.79 48.65,53.51 54.79,53.51 58.37,57.1 58.37,57.47 58.15,57.7 58.15,58.94 v1(58.27,59.06)
A_WIFI_SD_CLK: length 2.4
  L7-SIG w0.084: v1(4,79.79) 3.51,79.79 v1(2.72,80.58) v1(1.88,80.58)
A_WIFI_SD_CMD: length 1.6
  L7-SIG w0.084: v1(2.62,79.87) 3.19,79.29 v1(4,79.29)
A_WIFI_SD_D0: length 1.5
  L7-SIG w0.084: v1(2.72,78.32) 3.01,78.32 3.49,78.79 v1(4,78.79)
A_WIFI_SD_D1: length 2.1
  L7-SIG w0.084: v1(4,78.29) 4,78.04 2.72,76.75 v1(2.72,76.74)
A_WIFI_SD_D2: length 3.3
  L7-SIG w0.084: v1(4.85,77.44) 4.85,76.94 3.46,75.54 v1(3.46,74.69)
A_WIFI_SD_D3: length 3.2
  L7-SIG w0.084: v1(5.35,77.44) 5.35,76.68 4.22,75.54 v1(4.22,74.69)
AC_PRESENT_EC: length 57.2
  L2-SIG w0.102: v8(78.89,23.66) 78.89,23.66 83.25,28.02 83.25,44.92 79.91,48.26 79.91,53.09 80.55,53.73 80.55,55.37 80.09,55.84 77.29,55.84 73.66,59.47 v8(73.66,59.99)
  L3-GND w0.102: v8(73.66,59.99) 73.6,59.93 v3(73.28,59.93) ; v3(79.17,23.94) v8(78.89,23.66)
  L6-GND w0.102: v3(79.17,23.94) 79.55,24.32 v1(79.88,24.32) ; v3(73.28,59.93) 73.61,59.93 74.07,60.39 v4(74.24,60.39)
  L7-SIG w0.102: v1(77.12,68.74) 76.57,68.74 75.8,67.96 75.8,67.65 74.73,66.58 74.73,66.49 74.32,66.08 74.32,62.65 74.63,62.35 74.63,60.77 v4(74.24,60.39)
AC_PRESENT_SOC: length 74.7
  L3-GND w0.102: v3(62.76,67.95) v8(63.09,68.28)
  L4-SIG w0.102: v3(74.24,66.33) 74.6,65.97 74.6,64.03 74.88,63.75 74.88,63.31 75.06,63.13 75.06,60.28 75.26,60.08 75.26,58.38 75.39,58.26 75.39,57.59 74.7,56.91 74.7,47.03 74.07,46.39 74.07,42.71 74.85,41.92 74.85,33.92 74.17,33.23 74.17,31.05 74.42,30.79 74.42,25.36 74.73,25.05 74.73,22.92 72.52,20.71 65.1,20.71 64.75,21.07 v3(64.47,21.07)
  L5-SIG w0.102: v3(74.24,66.33) 73.36,66.33 72.8,66.89 71.2,66.89 70.44,66.13 69.34,66.13 68.58,66.89 67.54,66.89 67.09,67.35 66.66,67.35 66.07,66.75 65.75,66.75 65.53,66.97 65.53,67.05 65.28,67.29 63.68,67.29 63.02,67.95 v3(62.76,67.95)
  L6-GND w0.102: v3(62.76,67.95) v5(62.43,68.28) ; v1(64.47,21.45) v3(64.47,21.07)
  L7-SIG w0.06: v5(62.43,68.28) 62.41,68.26 60.37,68.26 60.23,68.4 v6(59.93,68.4)
  BOTTOM w0.102: v1(64.47,21.45) 64.47,21.85 64.36,21.96 R8377.1
ADCDAT2: length 5.4
  BOTTOM w0.102: R1050.1 32.06,71.3 32.06,70.58 C1062.1 30.95,69.47 29.58,69.47 28.95,68.84 U1001.34
AU_COMBO_MIC: length 31.6
  L7-SIG w0.254: v1(4.15,66.35) 20.54,66.35 22.94,63.95 22.94,63.41 25.88,60.46 v1(27,60.46)
  BOTTOM w0.203: v1(4.15,66.35) 4.8,66.35 5.04,66.12 T2011.1
  BOTTOM w0.254: v1(27,60.46) 27,60.13 26.8,59.93 26.35,59.93 26.23,59.8 R1116.1
AU_HP_JD#: length 30.3
  L5-SIG w0.102: v2(21.92,59.62) 22.05,59.75 22.05,61.6 18.82,64.83 6.45,64.83 v3(5.87,65.41)
  L6-GND w0.102: v3(5.87,65.41) 5.43,65.85 v1(4.15,65.85)
  BOTTOM w0.102: v2(21.92,59.62) 21.92,59.63 R1119.2 22.14,60.02 R1101.1 R1126.1
  BOTTOM w0.203: T1101.1 9.61,65.51 5.06,65.51 4.72,65.85 v1(4.15,65.85)
AU_HP_L: length 36.2
  L5-SIG w0.102: v3(5.13,65.01) 5.13,65.65 6.09,66.6 22.13,66.6 24.29,68.77 25.04,68.77 25.87,69.6 v2(25.87,70)
  L6-GND w0.102: v3(5.13,65.01) 4.97,64.85 v1(4.15,64.85)
  BOTTOM w0.178: v2(25.87,70) 25.87,69.79 26.55,69.11 U1001.28
  BOTTOM w0.203: v1(4.15,64.85) 4.67,64.85 4.68,64.86 12.55,64.86 T2007.1
AU_HP_R: length 31.9
  L5-SIG w0.102: v3(4.55,65.35) 6,66.81 22.04,66.81 24.21,68.97 24.61,68.97 v2(25.02,69.38)
  L6-GND w0.102: v3(4.55,65.35) v1(4.15,65.35)
  BOTTOM w0.178: U1001.26 25.75,68.88 25.26,69.38 v2(25.02,69.38)
  BOTTOM w0.203: v1(4.15,65.35) 4.75,65.35 4.89,65.21 11.12,65.21 T2008.1
BAT_ID: length 6.7
  L7-SIG w0.102: v1(23.79,46.26) 28.71,46.26 v1(28.8,46.16)
  BOTTOM w0.102: v1(28.8,46.16) 29.12,45.84 29.12,45.01 R8974.2
BATID: length 89.2
  L4-SIG w0.102: v3(34.75,46.67) 35.06,46.36 35.06,41.95 39.35,37.66 39.35,26.24 44.32,21.27 55.16,21.27 55.62,20.8 57.96,20.8 59.24,22.08 61.81,22.08 63.41,23.69 67.93,23.69 68.5,24.27 68.83,24.27 71.58,27.01 73.11,27.01 73.61,27.51 73.61,30.21 72.79,31.03 72.79,33.2 73.2,33.61 v3(73.2,34.4)
  L5-SIG w0.102: v3(34.75,46.67) 29.79,46.67 v3(29.29,46.16)
  L6-GND w0.06: 62.33,36.14 61.7,35.51 60.49,35.51 v6(60.32,35.34)
  L6-GND w0.102: v4(69.05,34.86) 67.72,36.19 62.39,36.19 62.33,36.14 ; v1(29.67,46.16) v3(29.29,46.16) ; v3(73.2,34.4) 73.13,34.47 v1(72.8,34.47)
  L7-SIG w0.102: v1(72.8,34.47) 72.6,34.27 71.81,34.27 71.59,34.49 69.62,34.49 69.25,34.86 v4(69.05,34.86)
BATID_EC: length 69.9
  L4-SIG w0.102: v3(42.39,46.44) 43.71,46.44 44.26,45.89 57.9,45.89 58.25,46.25 73.14,46.25 74.27,47.38 74.27,47.91 73.31,48.88 73.31,49.97 74.42,51.09 74.42,57.52 v3(75.01,58.1)
  L5-SIG w0.102: v3(29.29,44.74) 34.44,44.74 35.74,43.44 39.4,43.44 v3(42.39,46.44)
  L6-GND w0.102: v3(75.01,58.1) 74.91,58.2 v1(74.91,58.79) ; v3(29.29,44.74) v1(29.67,44.74)
  BOTTOM w0.102: v1(74.91,58.79) 74.91,61.22 74.63,61.5 72.54,61.5 72.39,61.66 72.39,62.06 72.21,62.24 71.45,62.24 71.27,62.42 71.27,63.15 71.37,63.26 72.06,63.26 72.16,63.36 U3001.42
BATT_NTC: length 21.7
  L7-SIG w0.102: v1(23.91,48.16) 23.51,47.76 23.51,46.14 24.17,45.48 25.36,45.48 28.9,41.94 28.9,41.19 30.4,39.68 30.9,39.68 31.69,38.89 31.69,38.35 31.76,38.28 31.76,37.99 31.28,37.51 29.51,37.51 29.49,37.5 29.13,37.5 28.94,37.31 28.94,36.84 v1(29.6,36.18) 29.31,35.89 29.31,34.22 v1(29.58,33.94)
BCLK2: length 6.6
  BOTTOM w0.102: C1060.1 R1052.1 34.26,69.73 33.33,69.73 32.21,68.62 30.63,68.62 30.35,68.89 29.9,68.89 29.75,68.75 U1001.36
BKLT_EN_PWM_R: length 33.4
  L7-SIG w0.084: v1(61.52,12.63) 61.52,13.09 60.85,13.76 v1(60.85,13.79) v1(60.85,14.55) v1(60.85,15.29) 61.42,14.72 61.95,14.72 63.63,16.39 64.11,16.39 64.26,16.24 64.26,15.5 63.83,15.07 63.83,14.43 64.31,13.95 64.31,13.73 66.34,11.7 78.8,11.7 79.79,12.7 81.73,12.7 84.66,15.63 v1(84.66,16.04)
