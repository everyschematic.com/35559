# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
42_M1_DATA53: length 26.7
  L7-SIG w0.06: v6(51.17,78.4) 51.17,78.58 51.2,78.62 51.2,79.22 51.39,79.41
  L7-SIG w0.064: 51.39,79.41 51.44,79.45 51.44,79.63 51.27,79.79 51.01,79.79 49.97,80.83 49.97,81.62 50.12,81.77 50.12,81.97 49.79,82.31 49.79,82.75 49.89,82.85 50.02,82.85 50.06,82.89 50.06,83.11 50.02,83.15 49.76,83.15 49.68,83.23 49.68,83.39 49.76,83.48 49.98,83.48 50.06,83.55 50.06,83.72 49.99,83.78 49.76,83.78 49.69,83.85 49.69,84.11 49.77,84.18 50.43,84.18 50.5,84.26 50.5,84.5 50.43,84.57 49.77,84.57 49.69,84.66 49.69,84.82 49.77,84.9 50.41,84.9 50.5,84.99 50.5,85.15 50.43,85.23 49.77,85.23 49.69,85.31 49.69,85.47 49.77,85.55 50.41,85.55 50.5,85.64 50.5,85.8 50.43,85.88 49.77,85.88 49.69,85.96 49.69,86.12 49.77,86.2 50.41,86.2 50.5,86.28 50.5,86.7 50.42,86.78 49.74,86.78 49.68,86.83 49.68,87 49.76,87.08 50.43,87.08 50.5,87.14 50.5,87.26 50.42,87.33 49.85,87.33 49.78,87.41 49.78,87.51 49.85,87.59 50.43,87.59 50.5,87.66 50.5,87.95 50.39,88.06 50.22,88.06 49.98,87.82 49.48,87.82 49.13,88.17 48.99,88.17 48.09,89.06 48.09,89.38 48.01,89.47 47.83,89.47 47.75,89.54 47.75,89.77 47.86,89.88 47.86,90 47.92,90.05 48.11,90.05 48.19,90.14 48.19,90.32 48.14,90.37 47.93,90.37 47.86,90.44 47.86,90.59 48.01,90.74 48.68,90.74 48.82,90.88 48.82,91.39 48.87,91.44 v1(49.03,91.44)
42_M1_DATA54: length 27
  L7-SIG w0.064: v6(52.9,78.42) 52.9,78.81 53.04,78.95 53.04,80.31 52.63,80.71 52.63,81 52.8,81.16 52.99,81.16 53.2,80.95 53.44,80.95 53.56,81.06 53.56,81.18 53.49,81.24 53.49,81.36 53.61,81.47 53.72,81.47 53.79,81.41 53.9,81.41 54.02,81.52 54.02,81.81 53.77,82.05 53.77,82.18 54.11,82.52 54.69,82.52 54.82,82.65 54.82,92.79 54.66,92.95 54.66,93.43 54.53,93.56 54.39,93.56 54.31,93.48 54.31,93.02 54.2,92.92 54.2,92.92 54.05,92.92 53.97,93 53.97,93.63 53.92,93.68 53.75,93.68 53.65,93.58 53.65,93 53.56,92.92 53.35,92.92 53.25,93.02 53.25,93.46 52.92,93.79 52.09,93.79 51.97,93.66 51.97,92.13 51.76,91.92 51.42,91.92 51.34,92 51.34,92.3 51.27,92.36 50.91,92.36 50.81,92.26 50.49,92.26 50.35,92.12 50.35,92.12 50.29,92.05 v1(50.08,92.05)
42_M1_DATA55: length 27
  L7-SIG w0.06: v6(52.58,78.13) 52.55,78.16 52.55,78.55 52.55,78.55 52.55,78.82 52.63,78.89 52.63,79.06 52.71,79.14 52.71,80.07
  L7-SIG w0.064: v1(49.69,91.57) 49.9,91.57 49.98,91.66 50.18,91.66 50.35,91.49 50.35,91.34 50.45,91.24 51.27,91.24 51.33,91.17 51.71,91.17 51.85,91.32 51.85,91.54 51.9,91.6 52.15,91.6 52.32,91.77 52.32,93.33 52.38,93.38 52.65,93.38 52.71,93.32 52.71,92.6 52.9,92.41 54.21,92.41 54.33,92.29 54.33,90.5 54.06,90.22 54.06,89.77 54.23,89.6 54.23,89.44 54.04,89.25 54.04,88.86 54.11,88.79 54.19,88.71 54.19,88.55 54.03,88.39 54.03,87.98 54.2,87.81 54.2,87.52 54.08,87.4 54.08,86.86 54.01,86.79 53.88,86.79 53.76,86.67 53.76,86.44 53.86,86.34 54.26,86.34 54.31,86.29 54.31,86.13 54.23,86.04 53.72,86.04 53.63,85.95 53.63,85.81 53.72,85.72 54.23,85.72 54.31,85.64 54.31,85.48 54.23,85.39 53.73,85.39 53.64,85.3 53.64,85.16 53.73,85.07 54.23,85.07 54.31,84.99 54.31,84.83 54.23,84.74 53.84,84.74 53.76,84.66 53.76,82.82 53.25,82.31 53.25,82.19 53.09,82.04 53.09,81.59 53.05,81.54 52.78,81.54 52.21,80.97 52.21,80.58 52.71,80.07
42_M1_DATA56: length 24.4
  L5-SIG w0.06: v6(52.58,76.99) 52.58,76.87 52.65,76.79 52.75,76.79 52.82,76.86 52.82,77.09 52.77,77.15 52.77,77.22 52.82,77.27 52.82,77.69 52.73,77.78 52.73,78.17 52.86,78.3 52.91,78.3 53.01,78.2 53.08,78.2 53.14,78.26 53.14,78.32 53.04,78.42 53.04,78.48 53.1,78.54 53.16,78.54 53.24,78.46 53.3,78.46 53.35,78.51 53.35,78.8
  L5-SIG w0.109: 53.8,82.33 53.8,82.17 54.19,81.77 54.19,81.49 53.59,80.89 53.59,80.68 53.5,80.59 53.12,80.59 53.03,80.5 53.03,79.73 53.35,79.41 53.35,78.8 ; v1(51.18,90.4) 51.18,90.63 51.53,90.98 51.53,91.54 52.08,92.09 52.71,92.09 52.81,92.19 52.81,92.81 52.65,92.97 52.65,93.15 52.81,93.3 52.81,93.58 52.88,93.65 52.99,93.65
  L5-SIG w0.127: 52.99,93.65 53.14,93.65 53.14,93.65 53.62,93.65 53.8,93.47 53.8,82.33
42_M1_DATA57: length 25.2
  L5-SIG w0.06: v6(51.42,75.85) 51.42,75.85 51.42,75.34 51.37,75.3 51.13,75.3 51.08,75.35 51.08,75.55 51.03,75.6 50.86,75.6 50.77,75.51 50.77,75.23 50.63,75.09 50.63,74.97 50.72,74.88 50.85,74.88 51.04,75.08 51.11,75.08 51.69,74.5 51.78,74.5 51.85,74.57 51.85,74.8 51.67,74.97 51.67,76.2 51.66,76.22 51.66,76.5 51.56,76.6 51.56,76.93 51.54,76.95 51.54,77.78 51.59,77.82
  L5-SIG w0.109: 51.4,82.33 51.4,81.9 51.62,81.68 51.62,81.45 51.76,81.31 51.76,79.11 51.62,78.97 51.62,77.85 51.59,77.82 ; 50.01,89.16 49.49,89.69 49.49,92.64 49.57,92.73 50.09,92.73 50.59,92.22 v1(50.59,92.02)
  L5-SIG w0.127: 51.4,82.33 51.4,82.81 51.69,83.11 51.69,84.95 51.5,85.14 50.61,85.14 50.32,85.43 50.32,87.55 50.01,87.86 50.01,89.16
42_M1_DATA58: length 23.8
  L5-SIG w0.06: v6(52.23,76.11) 52.23,75.93 52.25,75.92 52.25,75.28 52.31,75.22 52.4,75.22 52.46,75.28 52.46,75.97 52.5,76.01 52.5,76.22 52.35,76.38 52.35,76.45 52.5,76.6 52.5,76.77 52.37,76.9 52.37,76.97 52.15,77.18 52.15,77.36 52.32,77.53 52.4,77.53 52.5,77.42 52.54,77.42 52.57,77.45 52.57,77.6 52.48,77.68 52.48,77.78 52.48,78.29 53.01,78.82 53.01,78.83
  L5-SIG w0.076: v1(50.69,90.57) 50.62,90.49 50.62,90.27 50.89,89.99 51.29,89.99 51.53,89.75 51.7,89.75 51.78,89.84 51.78,90.7 51.93,90.85 51.93,91.08
  L5-SIG w0.109: 53.01,78.83 53.01,79.27 52.69,79.59 52.69,80.81 52.8,80.93 53.15,80.93 53.64,81.42 53.64,81.76 53.24,82.16 53.24,82.33 ; 52.99,91.27 52.56,91.7 52.22,91.7 51.93,91.41 51.93,91.08
  L5-SIG w0.127: 53.24,82.33 53.24,91.02 52.99,91.27
42_M1_DATA59: length 25.2
  L5-SIG w0.06: 53.52,78.47 53.12,78.07 52.9,78.07 52.85,78.02 52.85,77.88 52.88,77.85 53,77.85 53.05,77.79 53.05,77.71 52.94,77.61 52.94,77.52 53.03,77.43 53.03,77.36 52.94,77.28 52.94,77.21 53.04,77.12 53.04,77.04 52.96,76.97 52.96,76.95 52.96,76.95 52.96,76.79 52.7,76.54 52.7,76.51 v6(52.6,76.41)
  L5-SIG w0.109: 52.88,93.95 52.58,93.66 52.58,93.35 52.34,93.1 52.34,92.87 52.41,92.79 52.53,92.79 52.63,92.7 52.63,92.31 52.59,92.28 51.99,92.28 51.34,91.63 51.34,91.07 51.26,90.99 v1(51.16,90.99) ; 54.08,82.33 54.08,82.19 54.22,82.05 54.31,82.05 54.39,81.97 54.39,81.45 53.76,80.82 53.76,80.46 53.65,80.34 53.28,80.34 53.2,80.26 53.2,79.8 53.52,79.48 53.52,78.47
  L5-SIG w0.127: 54.08,82.33 54.08,93.69 53.81,93.95 52.88,93.95
  BOTTOM w0.203: U1701.R2 50.86,91.19
42_M1_DATA60: length 24.4
  L5-SIG w0.06: v6(51.77,76.72) 51.77,76.89 51.66,77 51.66,77.67 51.81,77.82
  L5-SIG w0.109: 50.29,88.68 50.29,89.16 49.73,89.72 49.73,91.58 49.89,91.75 49.89,92.05 49.73,92.22 49.73,92.43 49.84,92.54 50.01,92.54 50.3,92.26 50.3,91.79 v1(50.59,91.49) ; 51.81,77.82 51.81,78.92 51.92,79.03 51.93,79.03 52.03,79.14 52.03,79.37 51.93,79.47 51.93,79.92 52.03,80.02 52.03,80.23 51.93,80.34 51.93,80.78 52.03,80.89 52.03,81.27 51.79,81.52 51.79,81.75 51.68,81.86 51.68,82.12
  L5-SIG w0.127: 50.29,88.68 50.29,87.99 50.63,87.65 50.63,87.35 50.8,87.18 51.85,87.18 51.97,87.05 51.97,86.87 51.85,86.75 50.76,86.75 50.63,86.62 50.63,86.43 50.76,86.3 51.85,86.3 51.97,86.18 51.97,85.97 51.85,85.84 50.77,85.84 50.64,85.72 50.64,85.54 50.77,85.42 51.76,85.42 51.97,85.2 51.97,82.99 51.68,82.7 51.68,82.12
42_M1_DATA61: length 24.4
  L5-SIG w0.06: 53.17,77.88 53.17,76.99 53.09,76.91 53.09,76.75 52.83,76.5 52.83,76.3 52.66,76.13 v6(52.66,75.83)
  L5-SIG w0.109: 54.36,82.3 54.56,82.1 54.56,81.38 53.93,80.75 53.93,79.78 53.69,79.53 53.69,78.4 53.17,77.88 ; v1(51.08,91.49) 51.14,91.56 51.14,91.69 52.15,92.7 52.15,93.27 52.39,93.51
  L5-SIG w0.127: 54.36,82.3 54.36,93.57 54.36,93.8 53.92,94.24 52.75,94.24 52.39,93.88 52.39,93.51
  BOTTOM w0.203: U1701.P2 50.86,91.69
42_M1_DATA62: length 24.5
  L5-SIG w0.06: 51.98,77.99 51.98,77.74 51.78,77.55 51.78,77.05 51.97,76.86 51.97,76.63 51.78,76.44 51.78,76.27 51.79,76.25 51.79,75.12 51.97,74.95 51.97,74.43 52.03,74.37 52.15,74.37 52.21,74.43 52.21,74.79 52.27,74.85 52.39,74.85 52.45,74.79 52.45,74.43 52.51,74.37 53.19,74.37 53.26,74.44 53.26,74.55 53.19,74.62 52.73,74.62 52.69,74.67 52.69,74.91 52.54,75.06 52.17,75.06 52.04,75.19 v6(52.04,75.8)
  L5-SIG w0.076: 49.91,91.11 49.98,91.18 50.33,91.18 50.41,91.09 50.49,91.09 v1(50.59,90.99)
  L5-SIG w0.109: 51.98,77.99 51.98,78.63 52.34,78.99 52.34,79.2 52.23,79.31 52.23,81.11 52.42,81.29 52.42,81.45 52.36,81.51 52.04,81.51 51.98,81.56 51.98,81.97 51.96,81.99 51.96,82.33 ; 50.57,89.21 49.91,89.87 49.91,91.11
  L5-SIG w0.127: 50.57,89.21 50.57,88.09 51.21,87.46 51.97,87.46 52.25,87.18 52.25,82.88 51.96,82.58 51.96,82.36 51.96,82.35 51.96,82.33
42_M1_DATA63: length 24.2
  L5-SIG w0.06: 51.45,77.96 51.42,77.94 51.42,76.9 51.44,76.88 51.44,76.33 v6(51.44,76.33)
  L5-SIG w0.109: 49.8,88.08 49.8,89.07 49.68,89.19 49.68,89.21 49.41,89.48 49.4,89.48 49.27,89.6 49.27,92.52 49.17,92.62 48.5,92.62 48.41,92.72 48.41,92.85 48.5,92.94 49.3,92.94 49.4,93.05 49.56,93.05 49.66,92.95 49.79,92.95 49.9,93.05 50.07,93.05 51.08,92.04 v1(51.08,92) ; 51.45,77.96 51.45,79.04 51.59,79.18 51.59,81.24 51.45,81.38 51.45,81.61 51.12,81.94
  L5-SIG w0.127: 49.8,88.08 49.8,87.78 50.04,87.54 50.04,85.17 50.35,84.86 51.3,84.86 51.42,84.74 51.42,84.57 51.3,84.45 50.49,84.45 50.36,84.33 50.36,84.15 50.49,84.03 51.29,84.03 51.42,83.91 51.42,83.23 51.12,82.93 51.12,81.94
42_M1_DM0: length 27.1
  L7-SIG w0.06: v6(46.67,76.64) 46.67,76.54 46.68,76.53 46.68,76.32 46.8,76.19 46.8,76.03 46.71,75.94 46.71,75.72 46.77,75.66 46.77,75.49 46.66,75.37 46.46,75.37 46.09,75.74 45.66,75.74 45.65,75.75
  L7-SIG w0.064: v1(45.04,94.45) 44.84,94.24 44.45,94.24 44.23,94.46 43.32,94.46 42.88,94.02 42.57,94.02 40.59,92.03 40.59,80.35 42.01,78.93 42.01,78.53 44.79,75.75 45.65,75.75
42_M1_DM1: length 35.4
  L7-SIG w0.06: v6(46.63,75.01) 46.59,75.05 46.41,75.05 46.27,75.19 45.96,75.19 45.85,75.08 45.56,75.08 45.44,75.2
  L7-SIG w0.064: 45.44,75.2 44.24,75.2 44.15,75.29 44.15,75.59 42.86,76.88 42.54,76.88 42.47,76.95 42.38,76.95 42.17,76.74 42.07,76.74 41.99,76.81 41.99,76.92 42.2,77.13 42.2,77.22 42.11,77.31 42.02,77.31 41.9,77.18 41.79,77.18 41.72,77.26 41.72,77.36 41.84,77.49 41.84,77.58 41.75,77.67 41.66,77.67 41.56,77.56 41.47,77.56 41.38,77.65 41.38,77.74 41.48,77.85 41.48,77.94 41.39,78.02 41.3,78.02 41.2,77.92 41.11,77.92 41.02,78.01 41.02,78.1 41.12,78.2 41.12,78.29 41.03,78.38 40.94,78.38 40.84,78.28 40.75,78.28 40.66,78.37 40.66,78.46 40.76,78.56 40.76,78.65 40.67,78.74 40.58,78.74 40.48,78.64 40.39,78.64 40.3,78.73 40.3,78.82 40.4,78.92 40.4,79.01 40.31,79.1 40.22,79.1 40.12,79 40.03,79 39.94,79.09 39.94,79.18 40.04,79.28 40.04,79.37 39.95,79.46 39.86,79.46 39.76,79.36 39.67,79.36 39.58,79.45 39.58,79.54 39.68,79.64 39.68,79.73 39.49,79.92 39.49,92.62 41.8,94.92 41.8,95.04 42.49,95.74 42.75,95.74 42.82,95.67 42.95,95.67 43.03,95.75 43.03,95.88 42.58,96.32 42.58,96.41 42.67,96.5 42.83,96.5 42.91,96.42 43.07,96.42 43.13,96.48 43.22,96.48 43.31,96.39 43.31,96.26 43.28,96.23 43.28,95.9 43.35,95.82 43.43,95.74 43.51,95.74 43.59,95.82 43.59,96.09 43.68,96.19 44.34,96.19 44.43,96.28 44.76,96.28 44.84,96.36 45.03,96.36 45.12,96.45 45.12,96.54 v1(45.04,96.61)
42_M1_DM2: length 34.9
  L5-SIG w0.06: 46.48,74.93 46.53,74.93 46.66,74.8 47.66,74.8 47.67,74.79 47.88,74.79 47.96,74.86 48.32,74.86 48.49,74.7 v6(48.62,74.7)
  L5-SIG w0.076: v1(45.6,95.61) 45.81,95.4 45.81,94.98 45.44,94.61 43.42,94.61 43.22,94.4 42.77,94.4
  L5-SIG w0.109: 40.98,78.23 41.69,77.51 41.69,77.21 43.97,74.93 46.48,74.93 ; 39.9,93.12 39.9,93.23 41.5,94.82 41.61,94.82 41.73,94.7 41.73,94.5 41.83,94.4 41.97,94.4 42.06,94.5 42.06,94.73 42.16,94.82 42.32,94.82 42.41,94.73 42.41,94.48 42.48,94.4 42.77,94.4
  L5-SIG w0.127: 40.98,78.23 40.98,78.24 40.2,79.01 40.2,79.45 38.82,80.83 38.82,80.95 39.03,81.16 39.03,81.3 38.08,82.24 38.08,91.12 39.9,92.94 39.9,93.12
42_M1_DM3: length 28.5
  L5-SIG w0.06: 47.25,76.91 47.47,76.69 v6(47.69,76.69)
  L5-SIG w0.076: v1(45.09,92.87) 45,92.95 44.54,92.95 44.48,92.89 44.48,92.81 44.55,92.73 44.68,92.73 44.73,92.69 44.73,92.4 44.58,92.26 44.27,92.26 44.13,92.12 43.86,92.12 43.76,92.01
  L5-SIG w0.109: 43.76,92.01 43.65,91.91 43.2,91.91 43.11,91.82 43.11,91.42 42.73,91.04 42.73,90.9 42.93,90.69 42.93,89.97 42.86,89.9 42.7,89.9 42.62,89.82 42.62,89.5 42.53,89.42 42.37,89.42 42.3,89.48 42.3,89.77 42.21,89.86 41.9,89.86 41.82,89.78 41.82,89.67 42.02,89.47 42.02,88.62 41.87,88.47 41.44,88.47 41.32,88.35 41.32,88.08 ; 47.25,76.91 46.98,76.91 46.9,76.83 45.02,76.83 43.8,78.06 43.8,78.86 43.02,79.63 43.02,79.9 42.85,80.07 42.85,80.56
  L5-SIG w0.127: 42.85,80.56 42.85,81.5 42.34,82.01 42.34,84.13 42.04,84.43 42.04,84.57 42.13,84.67 42.25,84.67 42.34,84.76 42.34,85.13 42.25,85.23 42.08,85.23 41.74,84.89 41.57,84.89 41.45,85.01 41.45,85.31 41.54,85.4 41.74,85.4 41.86,85.52 41.86,85.65 41.76,85.75 41.52,85.75 41.45,85.82 41.45,85.97 41.56,86.08 41.7,86.08 41.81,86.19 41.81,86.34 41.7,86.44 41.58,86.44 41.45,86.57 41.45,86.7 41.58,86.83 41.73,86.83 41.81,86.91 41.81,87.12 41.73,87.2 41.56,87.2 41.45,87.31 41.45,87.47 41.56,87.58 41.74,87.58 41.81,87.65 41.81,87.91 41.73,87.99 41.41,87.99 41.32,88.08
42_M1_DM4: length 23.9
  L5-SIG w0.06: v6(50.83,76.94) 50.72,77.04 50.72,77.71 50.77,77.76
  L5-SIG w0.076: v1(48.19,91.42) 48.19,91.52 48.08,91.63 48.08,91.77 47.9,91.95 47.9,92.04 47.97,92.11 48.06,92.11 48.57,91.6 48.57,91.42 48.44,91.3 48.44,91.14 48.57,91.02
  L5-SIG w0.109: 50.61,78.75 50.77,78.6 50.77,77.76 ; 48.75,87.42 48.75,87.68 48.67,87.77 48.67,88.17 48.37,88.47 48.37,88.58 48.44,88.65 48.58,88.65 48.67,88.74 48.67,88.88 48.54,89.02 48.54,89.49 48.36,89.67 48.36,89.95 48.54,90.12 48.54,90.44 48.57,90.48 48.57,91.02
  L5-SIG w0.127: 50.61,78.75 50.61,79.4 50.49,79.53 50.24,79.53 50.13,79.64 50.13,79.79 50.24,79.9 50.59,79.9 50.68,79.99 50.68,80.12 50.59,80.21 50.11,80.21 50,80.32 50,80.46 50.11,80.56 50.54,80.56 50.64,80.66 50.64,80.8 50.39,81.06 50.06,81.06 49.85,80.85 49.68,80.85 49.56,80.97 49.56,81.73 49.44,81.84 49.27,81.84 49.15,81.73 49.15,81 49.05,80.9 48.88,80.9 48.75,81.03 48.75,81.21 48.63,81.34 48.05,81.34 47.93,81.46 47.93,81.63 48.05,81.76 48.63,81.76 48.75,81.88 48.75,87.42
42_M1_DM5: length 26.7
  L7-SIG w0.06: 50.68,79.08 50.55,78.95 50.55,78.5 v6(50.64,78.42)
  L7-SIG w0.064: 50.68,79.08 50.68,79.28 49.79,80.17 49.59,80.17 49.44,80.02 49.18,80.02 49.13,80.07 49.13,80.2 49.34,80.4 49.34,81.26 49.11,81.49 47.71,81.49 47.48,81.26 47.35,81.26 47.15,81.46 47.15,81.62 47.21,81.68 47.54,81.68 47.86,82 48.12,82 48.18,82.07 48.18,82.86 48.11,82.94 47.97,82.94 47.89,83.02 47.89,83.19 48.01,83.31 48.12,83.31 48.18,83.37 48.18,84.06 48.09,84.15 48.09,84.35 48.16,84.41 48.31,84.41 48.38,84.48 48.38,84.59 48.33,84.64 47.78,84.64 47.63,84.79 47.63,84.97 47.68,85.02 48.24,85.02 48.34,85.12 48.34,85.26 48.24,85.36 47.66,85.36 47.57,85.44 47.57,85.57 47.66,85.66 48.37,85.66 48.5,85.78 48.5,86.03 48.27,86.26 46.79,86.26 46.69,86.36 46.69,86.5 46.79,86.6 47.16,86.6 47.22,86.54 48,86.54 48.11,86.65 48.11,86.98 48.01,87.08 47.5,87.08 47.44,87.14 47.44,87.38 47.6,87.54 47.65,87.54 47.75,87.64 47.75,87.87 47.69,87.93 47.38,87.93 46.88,88.43 46.75,88.43 46.43,88.75 46.43,88.99 46.39,89.03 45.86,89.03 45.75,89.14 45.75,89.44 46.04,89.74 46.4,89.74 46.48,89.82 46.48,89.98 46.2,90.26 46.2,91.26 46.39,91.44 v1(46.45,91.44)
42_M1_DM6: length 26.8
  L7-SIG w0.06: 53.72,79.08 53.65,79 53.65,78.24 53.52,78.11 53.26,78.11 53.06,77.91 53.06,77.73 52.94,77.61 52.77,77.61 52.57,77.81 v6(52.29,77.81)
  L7-SIG w0.064: 53.72,79.08 53.72,80.97 54.29,81.54 54.48,81.54 54.65,81.71 54.65,81.82 54.51,81.95 54.51,82.02 55.08,82.59 55.08,93.45 54.56,93.97 54.33,93.97 54.25,94.05 54.25,94.46 54.15,94.56 54.02,94.56 53.92,94.46 53.92,94.05 53.84,93.97 53.68,93.97 53.6,94.05 53.6,94.29 53.52,94.37 53.35,94.37 53.27,94.29 53.27,94.05 53.19,93.97 52.02,93.97 51.72,93.67 51.72,92.97 51.29,92.54 50.52,92.54 50.28,92.3 49.98,92.3 49.91,92.23 49.21,92.23 v1(49.08,92.1)
42_M1_DM7: length 25.2
  L5-SIG w0.06: v6(52.36,77.27) 52.65,77.27 52.69,77.31 52.69,77.64 52.6,77.73 52.6,78.21 53.18,78.79
  L5-SIG w0.076: 51.73,90.94 51.42,90.63 51.42,90.28 51.29,90.15 50.95,90.15 50.85,90.26 50.85,90.38 50.94,90.47 50.94,90.67 50.84,90.77 50.84,91 50.98,91.14 50.98,91.24 50.89,91.33 50.79,91.33 50.71,91.25 50.47,91.25 50.23,91.5 50.17,91.5 v1(50.08,91.42)
  L5-SIG w0.109: 51.73,90.94 51.73,91.47 52.16,91.9 52.62,91.9 52.86,91.66 52.98,91.66 ; 53.52,82.33 53.52,82.16 53.81,81.87 53.81,81.35 53.22,80.76 52.95,80.76 52.86,80.67 52.86,79.66 53.18,79.34 53.18,78.79
  L5-SIG w0.127: 52.98,91.66 53.05,91.72 53.05,93.23 53.17,93.35 53.34,93.35 53.52,93.18 53.52,82.33
42_M1_ODT0: length 28.5
  L2-SIG w0.081: v8(44.93,77.53) 44.35,77.53 44.2,77.67 44.2,77.98 44.27,78.05 44.62,78.05 44.74,78.18 44.74,78.96 44.15,79.55 43.83,79.55 43.75,79.63 43.75,79.87 43.83,79.96 44.15,79.96 44.23,80.04 44.23,80.28 44.15,80.36 43.83,80.36 43.75,80.44 43.75,80.69 43.83,80.77 44.15,80.77 44.23,80.85 44.23,81.09 44.15,81.17 43.83,81.17 43.75,81.26 43.75,81.5 43.83,81.58 44.15,81.58 44.23,81.66 44.23,81.91 44.15,81.99 43.83,81.99 43.75,82.07 43.75,82.31 43.83,82.39 44.15,82.39 44.23,82.48 44.23,82.72 44.15,82.8 43.83,82.8 43.75,82.88 43.75,83.13 43.83,83.21 44.15,83.21 44.23,83.29 44.23,86.45 45.83,88.06 45.83,91.47 45.75,91.55 45.12,91.55 45.03,91.63 45.03,91.79 45.12,91.87 45.75,91.87 45.83,91.95 45.83,92.12 45.75,92.2 45.12,92.2 45.03,92.28 45.03,92.44 45.12,92.52 45.75,92.52 45.83,92.6 45.83,92.77 45.75,92.85 45.12,92.85 45.03,92.93 45.03,93.09 45.12,93.17 45.75,93.17 45.83,93.25 v8(45.83,93.91)
  L3-GND w0.06: v8(44.93,77.53) 45.29,77.53 v3(45.31,77.55)
  L3-GND w0.076: v3(46.23,93.88) 45.86,93.88 v8(45.83,93.91)
  L6-GND w0.06: v3(45.31,77.55) 45.69,77.55 v6(45.69,77.55)
  L6-GND w0.076: v3(46.23,93.88) 46.23,93.99 v4(46.03,94.19)
  L7-SIG w0.076: v4(46.03,94.19) 45.88,94.19 v1(45.58,94.48)
42_M1_ODT2: length 28.9
  L2-SIG w0.081: v8(46.42,77.38) 46.42,76.74 46.27,76.59 45.51,76.59 45.43,76.67 45.43,76.86 45.35,76.95 45.18,76.95 45.1,76.86 45.1,76.67 45.02,76.59 44.86,76.59 44.78,76.67 44.78,76.86 44.7,76.95 44.53,76.95 44.45,76.86 44.45,76.67 44.37,76.59 44.18,76.59 44.05,76.72 44.05,77.13 44.17,77.25 45.24,77.25 45.37,77.37 45.37,77.63 45.47,77.74 45.62,77.74 45.73,77.63 45.73,77.55 45.83,77.45 45.98,77.45 46.08,77.55 46.08,78.02 46.48,78.42 46.48,79.56 45.75,80.29 45.75,86.01 46.26,86.52 48.22,86.52 48.64,86.94 48.64,90.1 47.03,91.71 v8(47.03,92.53)
  L3-GND w0.06: v8(46.42,77.38) 46.43,77.39 v3(46.43,77.74)
  L3-GND w0.076: v3(47.06,92.89) 47.06,92.56 v8(47.03,92.53)
  L6-GND w0.06: v3(46.43,77.74) 46.14,77.74 v6(46.07,77.81)
  L6-GND w0.076: v3(47.06,92.89) 47.37,92.89 v4(47.42,92.94)
  L7-SIG w0.076: v1(48.17,91.98) 48.32,92.14 48.32,92.58 48.18,92.72 47.63,92.72 v4(47.42,92.94)
76_DDR3_REF_DN: length 33.4
  L5-SIG w0.06: v6(53.06,76.4) 53.06,76.29 52.93,76.16 52.87,76.09 52.87,75.12 53.5,74.48 55.66,74.48 55.89,74.25 57,74.25 58.04,73.21 58.04,72.71 58.54,72.21 58.93,72.21 59.12,72.4 59.65,72.4 59.9,72.66 60.83,72.66 61.04,72.45
  L5-SIG w0.102: v3(74.32,79.49) 74.93,78.88 75.18,78.88 75.49,78.56 75.49,78.25 75.27,78.02 74.99,78.02 73.68,76.72 73.68,74.31 71.37,72 70.8,72 70.33,71.53 69.7,71.53 69.37,71.21 69.06,71.21 68.56,70.71 68.22,70.71 67.85,71.08 67.53,71.08 67.49,71.03 63.7,71.03 62.28,72.45 61.04,72.45
  L6-GND w0.102: v1(73.89,79.51) 74.14,79.51 74.17,79.49 v3(74.32,79.49)
76_DDR3_REF_DP: length 26.9
  L5-SIG w0.06: 63.88,72.63 63.4,73.11 58.31,73.11 57.05,74.37 55.94,74.37 55.71,74.6 53.55,74.6 53.07,75.09 v6(53.07,75.83)
  L5-SIG w0.102: v3(73.58,78.78) 73.84,78.52 73.84,78.07 68.33,72.56 65.24,72.56 64.86,72.19 64.32,72.19 63.88,72.63
  L6-GND w0.102: v1(73.58,79.13) v3(73.58,78.78)
  BOTTOM w0.102: v1(73.58,79.13) 73.58,79.21 R2402.1
76_M0_CLK0_DN: length 27.3
  L3-GND w0.102: v3(65.63,96.37) 65.54,96.37 v8(65.2,96.03) 65.08,95.91 v3(65.08,95.53)
  L5-SIG w0.076: 62.67,89.54 62.67,89.56 62.7,89.6 62.7,90.37 63.42,91.08 63.42,91.51 64.09,92.18 64.09,92.3 64.61,92.82 64.61,95.07 v3(65.08,95.53) ; v1(65.86,96.98) 65.81,97.04 65.81,97.18 65.86,97.24 65.96,97.24 66.03,97.3 66.11,97.3 66.23,97.18 66.23,96.84 66.18,96.79 66.07,96.79 65.97,96.69 65.74,96.69 65.63,96.58 v3(65.63,96.37)
  L5-SIG w0.086: 61.61,82.29 61.61,82.2 61.64,82.16 61.64,81.44 61.5,81.3 61.5,80.46 61.13,80.1 60.28,80.1 59.64,79.45 59.4,79.45 59.08,79.13 59.08,79.05 58.95,78.93 58.73,78.93 58.6,78.8 58.6,78.26 58.41,78.07 58.1,78.07 57.92,78.25 v6(57.92,78.29)
  L5-SIG w0.119: 61.61,82.29 61.61,83.61 61.81,83.81 62.15,83.81 62.41,83.55 62.52,83.55 62.69,83.72 62.69,84.23 62.57,84.35 61.87,84.35 61.57,84.66 61.57,85.1 61.83,85.36 62.58,85.36 62.67,85.46 62.67,89.54
76_M0_CLK0_DP: length 27.3
  L3-GND w0.102: v3(65.63,95.53) 65.63,95.77 v8(65.83,95.96) 66,96.13 66,96.24 66.2,96.44 v3(66.2,96.44)
  L5-SIG w0.076: v3(66.2,96.44) 66.39,96.62 66.39,97.24 66.15,97.48 v1(65.86,97.48) ; v3(65.63,95.53) 65.53,95.53 65.39,95.39 65.39,95.32 65.26,95.19 64.94,95.19 64.76,95.01 64.76,92.76 64.24,92.24 64.24,92.12 63.57,91.44 63.57,91.02 62.86,90.31 62.86,89.6 62.89,89.56 62.89,89.54
  L5-SIG w0.086: 61.83,82.29 61.83,82.28 61.79,82.24 61.79,81.38 61.65,81.24 61.65,80.4 61.19,79.95 60.34,79.95 59.7,79.31 59.46,79.31 59.23,79.07 59.23,78.99 59.01,78.78 58.79,78.78 58.74,78.74 58.74,78.2 58.47,77.92 58.02,77.92 v6(57.97,77.87)
  L5-SIG w0.119: 61.83,82.29 61.83,83.52 61.91,83.59 62.06,83.59 62.32,83.33 62.61,83.33 62.91,83.63 62.91,84.33 62.66,84.57 61.96,84.57 61.79,84.75 61.79,85.01 61.92,85.14 62.67,85.14 62.89,85.36 62.89,89.54
76_M0_CLK2_DN: length 27.4
  L3-GND w0.102: v8(68.58,93.4) 68.58,93.4 ; 68.58,93.4 68.86,93.68 v3(68.86,93.99) ; 68.58,93.4 68.47,93.29 v3(68.47,93.01)
  L5-SIG w0.06: v6(57.67,78.06) 57.52,78.06 57.39,77.93 57.39,77.83 57.42,77.79 57.74,77.79 57.89,77.64 58.2,77.64 58.32,77.75 58.88,77.75 59,77.63 59.36,77.63 60.08,78.36 60.08,78.48 60.06,78.49 60.06,78.5
  L5-SIG w0.076: 63.28,89.65 63.28,89.67 63.31,89.7 63.31,90.55 63.72,90.95 63.72,91.38 64.4,92.06 64.4,92.12 64.85,92.57 64.92,92.57 64.92,92.57 64.98,92.57 66.54,92.57 66.67,92.7 68.41,92.7 68.47,92.76 v3(68.47,93.01) ; v1(68.86,94.48) 68.72,94.48 68.61,94.59 68.61,94.67 68.72,94.77 68.99,94.77 69.17,94.59 69.17,94.31 v3(68.86,93.99)
  L5-SIG w0.086: 62.65,81.5 62.65,81.49 62.66,81.48 62.11,80.93 62.11,80.51 61.28,79.69 60.53,79.69 60.06,79.22 60.06,78.5
  L5-SIG w0.119: 63.28,89.65 63.28,83.34 62.99,83.05 62.99,82.69 63.28,82.4 63.28,82.24 62.65,81.61 62.65,81.5
76_M0_CLK2_DP: length 27.4
  L3-GND w0.102: v3(69.06,92.9) 69.06,93.24 v8(69.19,93.37) 69.19,93.59 v3(69.37,93.76)
  L5-SIG w0.06: v6(57.65,77.59) 57.78,77.59 57.84,77.52 58.25,77.52 58.37,77.63 58.83,77.63 58.95,77.51 59.41,77.51 60.2,78.31 60.2,78.49 60.21,78.5
  L5-SIG w0.076: 63.5,89.65 63.5,89.67 63.47,89.7 63.47,90.48 63.87,90.89 63.87,91.32 64.56,92 64.56,92.06 64.92,92.42 64.92,92.42 65.04,92.42 66.61,92.42 66.74,92.55 68.72,92.55 v3(69.06,92.9) ; v1(68.36,94.48) 68.46,94.58 68.46,94.73 68.65,94.92 69.05,94.92 69.37,94.61 v3(69.37,93.76)
  L5-SIG w0.086: 62.87,81.5 62.87,81.49 62.86,81.48 62.86,81.48 62.8,81.43 62.8,81.42 62.26,80.87 62.26,80.45 61.34,79.54 60.6,79.54 60.21,79.16 60.21,78.5
  L5-SIG w0.119: 62.87,81.5 62.87,81.52 63.5,82.15 63.5,82.49 63.44,82.55 63.21,82.78 63.21,82.96 63.5,83.25 63.5,89.65
76_M0_DQS0_DN: length 34.8
  L5-SIG w0.06: 60.71,74.73 60.66,74.69 60.14,74.69 60.03,74.8 59.38,74.8 59.3,74.72 58.83,74.72 v6(58.81,74.7)
  L5-SIG w0.076: 67.54,91.09 67.54,91.09 67.05,91.09 66.96,91.18 66.65,91.18 66.51,91.32 66.25,91.32 66.1,91.47 66.1,91.87 66.21,91.98 v1(66.36,91.98)
  L5-SIG w0.086: 70.59,88.1 70.59,88.12 70.62,88.15 70.62,88.56 68.63,90.55 68.63,90.94 68.54,91.03 68.47,91.03 68.47,91.03 68.3,91.03 68.1,90.84 67.79,90.84 67.54,91.09 ; 66.38,75.37 65.63,75.37 65.35,75.08 64.45,75.08 64.12,74.75 63.77,74.75 63.47,75.06 62.86,75.06 62.53,74.73 60.71,74.73
  L5-SIG w0.119: 66.38,75.37 67.13,75.37 68.35,76.59 68.35,77.14 69.79,78.57 70.33,78.57 70.59,78.83 70.59,79.66 70.5,79.74 70.28,79.74 70.05,79.96 70.05,80.45 70.27,80.66 70.55,80.66 70.64,80.75 70.64,81.07 70.57,81.14 70.3,81.14 70.05,81.39 70.05,81.81 70.3,82.06 70.47,82.06 70.59,82.18 70.59,82.42 70.47,82.54 70.27,82.54 70.05,82.75 70.05,83.21 70.3,83.46 70.47,83.46 70.59,83.57 70.59,83.81 70.47,83.93 70.3,83.93 70.05,84.18 70.05,84.6 70.3,84.85 70.47,84.85 70.59,84.97 70.59,85.21 70.47,85.33 70.3,85.33 70.05,85.58 70.05,86 70.3,86.25 70.47,86.25 70.59,86.37 70.59,86.61 70.47,86.73 70.3,86.73 70.05,86.98 70.05,87.4 70.3,87.65 70.47,87.65 70.59,87.77 70.59,88.1
76_M0_DQS0_DP: length 34.7
  L5-SIG w0.06: 60.79,74.59 60.77,74.57 60.09,74.57 59.98,74.68 59.43,74.68 59.35,74.6 59.12,74.6 59.08,74.57 v6(59.08,74.52)
  L5-SIG w0.076: 67.66,91.2 67.65,91.21 67.64,91.21 67.61,91.25 67.54,91.25 67.48,91.25 67.48,91.24 67.11,91.24 67.03,91.33 66.72,91.33 66.62,91.42 66.62,91.67 66.65,91.69 66.65,91.77 66.6,91.82 66.54,91.82 66.46,91.74 66.44,91.74 66.34,91.64 v1(66.34,91.58)
  L5-SIG w0.086: 60.79,74.59 62.59,74.59 62.92,74.91 63.41,74.91 63.71,74.61 64.18,74.61 64.51,74.94 65.41,74.94 65.7,75.23 66.29,75.23 66.36,75.16 66.36,75.16 66.37,75.15 66.38,75.15 ; 67.66,91.2 67.86,91 68.04,91 68.23,91.2 68.4,91.2 68.61,91.2 68.79,91.01 68.79,90.61 70.78,88.63 70.78,88.15 70.81,88.12 70.81,88.1
  L5-SIG w0.119: 70.81,88.1 70.81,87.67 70.56,87.43 70.39,87.43 70.27,87.31 70.27,87.07 70.39,86.95 70.56,86.95 70.81,86.7 70.81,86.28 70.56,86.03 70.39,86.03 70.27,85.91 70.27,85.67 70.39,85.55 70.56,85.55 70.81,85.3 70.81,84.88 70.56,84.63 70.39,84.63 70.27,84.51 70.27,84.27 70.39,84.15 70.56,84.15 70.81,83.91 70.81,83.48 70.56,83.23 70.39,83.23 70.27,83.11 70.27,82.84 70.36,82.76 70.56,82.76 70.81,82.51 70.81,82.09 70.56,81.84 70.39,81.84 70.27,81.72 70.27,81.48 70.39,81.36 70.66,81.36 70.86,81.16 70.86,80.66 70.65,80.44 70.36,80.44 70.27,80.35 70.27,80.06 70.37,79.96 70.59,79.96 70.81,79.75 70.81,78.73 70.42,78.35 69.88,78.35 68.58,77.05 68.58,76.5 67.22,75.15 66.38,75.15
76_M0_DQS1_DN: length 29.8
  L7-SIG w0.06: 63.1,75.09 62.67,74.66 61.74,74.66 61.53,74.88 60.91,74.88 v6(60.81,74.98)
  L7-SIG w0.079: v1(67.86,90.98) 67.61,90.73 67.61,90.35 67.73,90.23 67.97,90.23 68.21,89.99 68.26,89.99 70.23,88.01 70.23,84.04 70.76,83.51 70.76,82.75 70.65,82.64 70.14,82.64 69.93,82.43 69.93,81.99 70.12,81.8 70.67,81.8 70.77,81.71 70.77,81.5 70.64,81.36 70.18,81.36 69.94,81.13 69.94,80.75 70.18,80.52 70.4,80.52 70.69,80.52 70.77,80.43 70.77,80.19 70.63,80.05 70.62,80.05 70.09,80.05 69.91,79.88 69.91,79.54 70.15,79.31 70.15,78.48 68.51,76.84 68.38,76.84 68.25,76.97 68.25,77.43 67.89,77.79 67.63,77.79 67.38,77.54 67.38,76.97 67.16,76.75 64.76,76.75 63.1,75.09
76_M0_DQS1_DP: length 29.8
  L7-SIG w0.06: v6(60.51,74.75) 60.61,74.86 60.64,74.86 60.74,74.76 61.48,74.76 61.7,74.54 62.88,74.54 63.09,74.76
  L7-SIG w0.079: 63.09,74.76 64.87,76.54 67.25,76.54 67.59,76.88 67.59,77.45 67.72,77.58 67.81,77.58 68.04,77.34 68.04,76.89 68.29,76.64 68.6,76.64 70.35,78.39 70.35,79.39 70.12,79.63 70.12,79.79 70.17,79.85 70.54,79.85 70.72,79.85 70.98,80.11 70.98,80.52 70.77,80.72 70.32,80.72 70.27,80.72 70.15,80.84 70.15,81.04 70.27,81.16 70.72,81.16 70.98,81.41 70.98,81.79 70.76,82.01 70.2,82.01 70.14,82.07 70.14,82.35 70.23,82.44 70.73,82.44 70.96,82.67 70.96,83.6 70.44,84.12 70.44,88.1 68.34,90.2 68.29,90.2 68.05,90.44 67.91,90.44 v1(67.86,90.48)
76_M0_DQS2_DN: length 24.7
  L7-SIG w0.06: 61.92,76.94 61.91,76.94 61.91,76.84 61.85,76.78 60.96,76.78 v6(60.81,76.63)
  L7-SIG w0.076: 63.85,89.45 63.84,89.46 63.84,89.49 63.56,89.76 63.56,90.29 63.57,90.29 63.57,90.82 v1(63.73,90.98)
  L7-SIG w0.079: 61.92,76.94 62.29,77.31 62.29,77.63 62.46,77.81 63.04,77.81 63.18,77.94 63.18,78.1 63.09,78.18 62.48,78.18 62.26,78.4 62.26,78.77 62.5,79 63.37,79 63.45,79.08 63.45,79.25 63.22,79.47 62.42,79.47 62.21,79.69 62.21,80.12 62.43,80.35 63.62,80.35 64.07,79.9 64.19,79.9 64.36,80.07 65.06,80.07 65.78,80.79 65.78,81.22 65.95,81.4 66.32,81.4 66.43,81.5 66.43,81.72 66.33,81.82 66,81.82 65.77,82.04 65.77,85.49 66.11,85.83 66.11,86.02 65.46,86.67 65.46,86.95 65.29,87.12 65.29,88.01 63.85,89.45
76_M0_DQS2_DP: length 24.8
  L7-SIG w0.06: 62.06,76.8 62.06,76.79 62.04,76.79 62.02,76.77 62,76.77 61.9,76.66 61.06,76.66 61.02,76.62 61.02,76.46 61.07,76.42 61.18,76.42 v6(61.19,76.41)
  L7-SIG w0.076: v1(63.81,90.52) 63.85,90.52 63.93,90.44 63.93,90.29 63.86,90.23 63.75,90.23 63.72,90.19 63.72,89.82 63.91,89.63 63.91,89.63 63.94,89.6 63.99,89.6 63.99,89.59
  L7-SIG w0.079: 62.06,76.8 62.49,77.23 62.49,77.55 62.54,77.6 63.13,77.6 63.38,77.86 63.38,78.18 63.18,78.39 62.57,78.39 62.47,78.49 62.47,78.69 62.58,78.8 63.46,78.8 63.66,79 63.66,79.33 63.31,79.68 62.51,79.68 62.42,79.77 62.42,80.04 62.52,80.14 63.53,80.14 63.98,79.69 64.27,79.69 64.45,79.86 65.15,79.86 65.99,80.7 65.99,81.14 66.04,81.19 66.41,81.19 66.63,81.41 66.63,81.81 66.42,82.02 66.08,82.02 65.97,82.13 65.97,85.4 66.32,85.75 66.32,86.1 65.66,86.76 65.66,87.04 65.5,87.21 65.5,88.09 63.99,89.59
76_M0_DQS3_DN: length 25
  L5-SIG w0.06: 63.48,78.41 63.46,78.41 63.41,78.36 63.15,78.36 62.76,77.98 62.76,77.71 61.84,76.79 60.12,76.79 59.88,76.55 59.74,76.55 v6(59.65,76.64)
  L5-SIG w0.076: 64.63,89.62 64.63,89.63 64.64,89.64 64.64,89.93 64.57,89.99 64.57,90.23 64.57,90.66 64.7,90.79 64.92,90.79 65.03,90.9 65.03,91.49 65.2,91.66 65.2,91.71 65.15,91.76 65.15,91.9 65.2,91.95 v1(65.35,91.95)
  L5-SIG w0.086: 65.58,87.79 65.58,87.8 65.6,87.82 65.6,88.05 65.36,88.3 65.29,88.3 65.29,88.3 65.16,88.3 64.63,88.82 64.63,89.62
  L5-SIG w0.119: 65.58,87.79 65.58,87.25 65.83,87 65.95,87 66.08,86.88 66.08,86.65 65.95,86.53 65.83,86.53 65.58,86.28 65.58,85.86 65.83,85.61 66.51,85.61 66.64,85.48 66.64,85.26 66.51,85.13 65.83,85.13 65.58,84.88 65.58,84.46 65.83,84.21 66.53,84.21 66.66,84.08 66.66,83.86 66.53,83.73 65.46,83.73 65.2,83.48 65.2,83.06 65.46,82.81 65.51,82.81 65.63,82.68 65.63,82.46 65.51,82.33 65.44,82.33 65.21,82.1 65.21,79.93 64.5,79.22 63.69,78.41 63.48,78.41
76_M0_DQS3_DP: length 25.1
  L5-SIG w0.06: 63.48,78.19 63.46,78.19 63.41,78.24 63.2,78.24 62.88,77.93 62.88,77.66 61.89,76.67 60.17,76.67 59.93,76.43 59.4,76.43 v6(59.37,76.4)
  L5-SIG w0.076: v1(65.37,91.48) 65.26,91.48 65.18,91.41 65.18,90.84 64.98,90.64 64.77,90.64 64.72,90.59 64.72,90.29 64.72,90.06 64.79,89.99 64.79,89.69 64.8,89.69 64.8,89.62
  L5-SIG w0.086: 64.8,89.62 64.8,88.89 65.23,88.46 65.35,88.46 65.43,88.46 65.76,88.12 65.76,87.85 65.8,87.8 65.8,87.79
  L5-SIG w0.119: 65.8,87.79 65.8,87.34 65.92,87.22 66.04,87.22 66.3,86.97 66.3,86.56 66.04,86.3 65.92,86.3 65.8,86.19 65.8,85.95 65.92,85.83 66.6,85.83 66.86,85.57 66.86,85.16 66.6,84.91 65.92,84.91 65.8,84.79 65.8,84.55 65.92,84.43 66.62,84.43 66.88,84.17 66.88,83.77 66.62,83.51 65.55,83.51 65.42,83.38 65.42,83.16 65.55,83.03 65.6,83.03 65.86,82.77 65.86,82.37 65.6,82.11 65.53,82.11 65.43,82.01 65.43,79.84 63.78,78.19 63.48,78.19
76_M0_DQS4_DN: length 25.4
  L5-SIG w0.06: v6(56.02,76.4) 56.06,76.4 56.12,76.46 56.12,76.52 56.01,76.64 56.01,76.8 56.27,77.06 56.27,78.09 56.28,78.09 56.28,78.14 56.32,78.18
  L5-SIG w0.076: v1(62.26,92.52) 62.26,92.64 62.29,92.68 62.43,92.68 62.53,92.58 62.53,92.26 62.48,92.21 62.48,91.66 62.49,91.66 62.49,91.46 62.48,91.45 62.48,91.44 62.31,91.27 62.14,91.27 62.01,91.14 61.75,91.14 61.72,91.17 61.71,91.17
  L5-SIG w0.086: 59.69,82.02 59.69,82.01 59.74,81.95 59.74,81.57 59.57,81.4 59.01,81.4 56.9,79.29 56.9,78.76 56.32,78.18
  L5-SIG w0.119: 59.69,82.02 59.69,86.37 59.94,86.61 60.51,86.61 60.71,86.82 60.71,86.98 60.6,87.09 59.92,87.09 59.67,87.35 59.67,87.76 59.92,88.01 60.63,88.01 60.75,88.14 60.75,88.36 60.59,88.53 59.87,88.53 59.63,88.77 59.63,89.04 59.63,89.15 59.88,89.41 60.17,89.41 60.3,89.54 60.3,89.76 60.17,89.89 59.94,89.89 59.57,90.25 59.57,90.76 59.98,91.17 61.71,91.17
76_M0_DQS4_DP: length 25.5
  L5-SIG w0.06: v6(56.25,76.7) 56.25,76.86 56.39,77.01 56.39,78.04 56.43,78.07
  L5-SIG w0.076: 61.71,90.95 61.8,90.95 61.84,90.99 62.08,90.99 62.2,91.12 62.38,91.12 62.64,91.38 62.64,91.39 62.64,91.39 62.64,91.72 62.64,91.72 62.64,92.15 62.68,92.19 62.68,92.64 62.5,92.83 62.21,92.83 v1(61.86,92.48)
  L5-SIG w0.086: 56.43,78.07 56.43,78.08 57.05,78.7 57.05,79.23 59.07,81.25 59.63,81.25 59.89,81.51 59.89,81.98 59.91,82.01 59.91,82.02
  L5-SIG w0.119: 59.91,82.02 59.91,86.27 60.03,86.39 60.6,86.39 60.94,86.72 60.94,87.07 60.69,87.31 60.02,87.31 59.89,87.44 59.89,87.66 60.02,87.79 60.72,87.79 60.97,88.05 60.97,88.45 60.68,88.75 59.96,88.75 59.85,88.86 59.85,88.95 59.85,89.06 59.98,89.19 60.27,89.19 60.52,89.44 60.52,89.85 60.27,90.11 60.03,90.11 59.79,90.34 59.79,90.67 60.07,90.95 61.71,90.95
76_M0_DQS5_DN: length 24.7
  L7-SIG w0.06: 56.73,79.42 56.63,79.42 56.48,79.28 56.48,78.77 56.6,78.66 56.6,78.28 56.54,78.23 v6(56.54,78.09)
  L7-SIG w0.076: v1(63.36,93.98) 63.3,93.98 63.01,93.69 62.26,93.69 62.18,93.61 61.79,93.61 61.52,93.35
  L7-SIG w0.079: 56.73,79.42 56.88,79.58 57.27,79.58 57.99,80.29 59.25,80.29 59.95,80.99 59.95,82.19 59.89,82.25 59.89,82.62 59.95,82.68 59.95,83.08 59.89,83.14 59.89,84.24 59.98,84.34 60.19,84.34 60.3,84.44 60.58,84.44 60.83,84.69 60.83,84.96 60.61,85.17 60.04,85.17 59.94,85.26 59.94,85.39 60.04,85.49 60.61,85.49 60.81,85.68 60.81,86.02 60.61,86.21 60.02,86.21 59.94,86.29 59.94,86.47 60.03,86.56 60.39,86.56 60.64,86.56 60.83,86.74 60.83,87.22 60.65,87.39 60.38,87.39 60.32,87.45 60.32,88.42 59.92,88.82 59.92,91.36 60.63,92.08 60.63,92.51 60.64,92.53 61.27,93.15 61.33,93.15 61.52,93.35
76_M0_DQS5_DP: length 24.8
  L7-SIG w0.06: 56.59,79.57 56.59,79.55 56.36,79.33 56.36,78.72 56.48,78.61 56.48,78.33 56.25,78.11 v6(56.25,77.83)
  L7-SIG w0.076: 61.38,93.49 61.39,93.5 61.46,93.5 61.72,93.77 62.11,93.77 62.19,93.84 62.83,93.84 62.86,93.88 v1(62.86,93.98)
  L7-SIG w0.079: 61.38,93.49 61.24,93.36 61.19,93.36 61.13,93.31 60.44,92.61 60.42,92.6 60.42,92.16 59.71,91.45 59.71,88.74 60.11,88.34 60.11,87.37 60.29,87.19 60.56,87.19 60.62,87.13 60.62,86.83 60.56,86.76 60.47,86.76 59.94,86.76 59.74,86.56 59.74,86.21 59.94,86.01 60.53,86.01 60.61,85.93 60.61,85.77 60.53,85.69 59.95,85.69 59.74,85.48 59.74,85.18 59.95,84.96 60.53,84.96 60.62,84.87 60.62,84.77 60.5,84.65 60.22,84.65 60.11,84.54 59.89,84.54 59.68,84.33 59.68,83.02 59.73,82.98 59.74,82.96 59.74,82.76 59.68,82.7 59.68,82.16 59.74,82.1 59.74,81.07 59.17,80.5 57.91,80.5 57.19,79.78 56.8,79.78 56.59,79.57
76_M0_DQS6_DN: length 25.9
  L7-SIG w0.06: 54.48,80.05 54.48,79.02 54.47,79.02 54.47,78.54 v6(54.59,78.42)
  L7-SIG w0.076: 61.67,96.83 61.77,96.72 62.12,96.72 v1(62.36,96.48)
  L7-SIG w0.079: 54.48,80.05 54.48,80.51 54.69,80.72 55.49,80.72 56.16,81.39 56.16,81.71 56.62,82.17 56.62,83.35 56.71,83.44 56.71,84.63 56.62,84.72 56.62,85.18 56.71,85.27 56.71,85.67 56.62,85.76 56.62,86.22 56.71,86.31 56.71,93.95 56.71,94.12 57.02,94.43 57.3,94.43 57.51,94.22 57.65,94.22 57.74,94.31 57.74,94.44 57.51,94.66 57.51,94.93 57.77,95.18 58.02,95.18 58.22,94.98 58.32,94.98 58.45,95.11 58.45,95.2 58.33,95.32 58.26,95.39 58.26,95.5 58.26,95.67 59.21,96.63 59.38,96.63 60.76,96.63 61.04,96.91 61.59,96.91 61.67,96.83
76_M0_DQS6_DP: length 25.8
  L7-SIG w0.06: 54.68,80.03 54.6,79.94 54.6,79.02 54.66,78.95 54.66,78.88 54.59,78.81 54.59,78.64 54.62,78.62 54.68,78.62 54.81,78.49 54.86,78.49 54.98,78.6 54.98,78.71 54.93,78.76 v6(54.89,78.76)
  L7-SIG w0.076: 61.58,96.67 61.58,96.38 61.6,96.35 61.66,96.35 61.7,96.39 61.81,96.39 61.86,96.45 v1(61.86,96.48)
  L7-SIG w0.079: 61.58,96.67 61.54,96.7 61.13,96.7 60.85,96.42 59.3,96.42 58.47,95.59 58.47,95.59 58.47,95.48 58.47,95.47 58.66,95.29 58.66,95.03 58.41,94.78 58.14,94.78 57.94,94.98 57.85,94.98 57.72,94.84 57.72,94.75 57.95,94.52 57.95,94.22 57.74,94.01 57.43,94.01 57.22,94.23 57.1,94.23 56.91,94.03 56.91,86.22 56.83,86.14 56.83,85.84 56.91,85.76 56.91,85.18 56.83,85.1 56.83,84.8 56.91,84.71 56.91,83.35 56.83,83.27 56.83,82.08 56.37,81.62 56.37,81.3 55.58,80.51 54.77,80.51 54.68,80.42 54.68,80.03
76_M0_DQS7_DN: length 30.2
  L5-SIG w0.06: 55.32,79.34 55.32,79.33 55.31,79.32 55.31,79.28 55.23,79.2 55.23,79.2 54.9,78.87 54.9,78.82 54.9,76.96 54.82,76.88 54.82,76.43 v6(54.85,76.41)
  L5-SIG w0.086: v1(63.36,95.04) 63.27,94.94 63.27,94.83 63.45,94.65 63.45,94.38 63.31,94.24 61.32,94.24 60.9,94.66 60.36,94.66 60.15,94.87 60.15,95.42 60.05,95.51 59.89,95.51 59.72,95.34 59.72,94.97 59.55,94.8 59.17,94.8 58.98,94.99 58.98,95.19 58.98,95.19 58.98,95.23 58.96,95.24 ; 56.74,82.04 56.74,82.03 56.72,82.02 56.72,82.02 56.69,81.99 56.69,81.98 56.69,81.42 56.59,81.33 56.46,81.2 56.34,81.08 56.28,81.02 55.89,80.63 55.32,80.06 55.32,79.34
  L5-SIG w0.119: 58.96,95.24 58.92,95.28 58.92,95.28 58.79,95.42 58.48,95.42 58.34,95.28 58.34,95.05 58.04,94.74 57.69,94.74 57.48,94.95 57.48,95.23 57.39,95.32 57.14,95.32 56.73,94.91 56.73,94.66 56.87,94.52 57.05,94.52 57.25,94.32 57.25,93.96 56.94,93.64 56.79,93.64 56.73,93.59 56.73,83.14 56.74,83.14 56.74,82.04
76_M0_DQS7_DP: length 30.3
  L5-SIG w0.06: 55.18,79.34 55.18,79.32 54.78,78.92 54.78,78.77 54.78,77.01 54.7,76.93 54.7,76.79 v6(54.59,76.68)
  L5-SIG w0.086: 56.51,82.04 56.51,81.95 56.54,81.92 56.54,81.49 56.36,81.3 56.23,81.18 56.18,81.12 55.68,80.63 55.18,80.12 55.18,79.34 ; v1(62.86,95.04) 63.08,95.04 63.11,95 63.11,94.76 63.29,94.58 63.29,94.45 63.24,94.4 61.38,94.4 60.97,94.82 60.43,94.82 60.31,94.94 60.31,95.48 60.12,95.68 59.83,95.68 59.55,95.4 59.55,95.03 59.48,94.96 59.24,94.96 59.14,95.06 59.14,95.26 59.14,95.26 59.14,95.32 59.13,95.33 59.13,95.39 59.12,95.4
  L5-SIG w0.119: 59.12,95.4 59.08,95.44 59.08,95.44 59.08,95.44 58.88,95.64 58.39,95.64 58.12,95.37 58.12,95.14 57.95,94.96 57.79,94.96 57.7,95.05 57.7,95.32 57.49,95.54 57.05,95.54 56.51,95 56.51,94.56 56.77,94.3 56.96,94.3 57.03,94.23 57.03,94.05 56.85,93.87 56.7,93.87 56.51,93.68 56.51,83.24 56.51,83.05 56.51,83.05 56.51,82.04
76_M1_CLK0_DN: length 28.4
  L3-GND w0.102: v3(51.79,92.97) 51.81,92.99 v8(51.81,93.37) 51.81,93.6 v3(52.02,93.81)
  L5-SIG w0.06: v6(48.9,77.85) 48.9,78 49.16,78.27
  L5-SIG w0.086: v3(52.02,93.81) 51.35,94.48 v1(51.08,94.48) ; v3(51.79,92.97) 51.61,92.79 51.61,92.6 51.39,92.38 50.99,92.38 50.14,93.23 49.34,93.23 49.23,93.12 48.41,93.12 48.13,93.4 47.01,93.4 46.68,93.07 46.68,91.9 46.19,91.42 46.19,90.83 45.61,90.25 45.61,88.72 45.25,88.36 45.25,88.23 45.28,88.2 45.28,88.19 ; 44.5,82.08 44.5,82.06 44.46,82.02 44.46,80.24 44.75,79.96 47.57,79.96 48.1,79.43 48.48,79.43 48.77,79.14 48.77,78.83 49.16,78.44 49.16,78.27
  L5-SIG w0.119: 45.28,88.19 45.28,82.96 44.5,82.18 44.5,82.08
76_M1_CLK0_DP: length 28.3
  L3-GND w0.102: v3(51.21,93) 51.39,93.18 v8(51.39,93.34) 51.54,93.49 51.54,93.65 v3(51.33,93.86)
  L5-SIG w0.086: v3(51.33,93.86) 51.48,94 51.48,94.12 51.37,94.24 50.95,94.24 50.71,94.48 v1(50.57,94.48) ; v6(48.92,78.36) 48.81,78.25 48.74,78.25 48.62,78.36 48.62,79.08 48.42,79.28 48.04,79.28 47.51,79.81 44.69,79.81 44.32,80.18 44.32,82.02 44.28,82.06 44.28,82.08 ; v3(51.21,93) 51.44,92.76 51.44,92.67 51.32,92.54 51.05,92.54 50.21,93.39 49.27,93.39 49.16,93.28 48.48,93.28 48.2,93.56 46.94,93.56 46.52,93.14 46.52,91.97 46.03,91.49 46.03,90.9 45.45,90.32 45.45,88.79 45.09,88.43 45.09,88.23 45.06,88.2 45.06,88.19
  L5-SIG w0.119: 44.28,82.08 44.28,82.27 45.06,83.05 45.06,88.19
76_M1_CLK2_DN: length 28.2
  L3-GND w0.102: v3(48.3,95.57) 48.22,95.64 v8(48.22,96.06) 48.22,96.38 v3(48.31,96.47)
  L5-SIG w0.06: v6(49.2,78.01) 49.2,77.85 48.99,77.65 48.78,77.65 48.59,77.84 48.59,77.91
  L5-SIG w0.086: v3(48.3,95.57) 48.13,95.4 48.13,95.13 47.97,94.97 47.61,94.97 47.39,94.75 47.39,94.25 46.31,93.17 46.31,92.66 46.16,92.52 46.16,92.4 46.31,92.25 46.31,92 46.13,91.82 45.84,91.82 45.76,91.89 45.64,91.89 45.38,91.63 45.38,91.51 45.44,91.45 45.69,91.45 45.87,91.27 45.87,91.01 45.69,90.83 45.36,90.83 45.28,90.75 45.28,88.93 44.65,88.29 44.65,87.75 44.66,87.74 44.66,87.72 ; v3(48.31,96.47) 47.68,96.47 47.55,96.59 47.55,96.84 47.69,96.98 v1(48,96.98) ; 44.17,82.63 44.17,82.61 44.15,82.59 44.15,82.53 44.12,82.49 44.12,80.09 44.64,79.57 47.44,79.57 47.72,79.29 47.72,78.51 47.81,78.41 48.32,78.41 48.59,78.15 48.59,77.91
  L5-SIG w0.119: 44.17,82.63 44.17,82.7 44.66,83.19 44.66,87.72
76_M1_CLK2_DP: length 28.3
  L3-GND w0.102: v3(47.73,95.55) 47.73,96.07 47.68,96.12 v8(47.57,96.12) 47.47,96.12 47.19,96.4 v3(47.19,96.48)
  L5-SIG w0.06: 48.44,77.91 48.44,77.9 48.45,77.88 48.45,77.8 48.73,77.53 49.1,77.53 v6(49.13,77.5)
  L5-SIG w0.086: v3(47.19,96.48) 47.39,96.68 47.39,96.91 47.63,97.15 47.75,97.15 v1(48.08,97.48) ; 48.44,77.91 48.44,78.08 48.26,78.27 47.75,78.27 47.57,78.45 47.57,79.23 47.38,79.42 44.58,79.42 43.97,80.03 43.97,82.55 43.95,82.57 43.95,82.63 ; 44.44,87.72 44.44,87.74 44.48,87.78 44.48,88.36 45.12,89 45.12,90.82 45.29,90.99 45.62,90.99 45.71,91.08 45.71,91.2 45.62,91.29 45.37,91.29 45.22,91.44 45.22,91.7 45.57,92.05 45.83,92.05 45.9,91.98 46.06,91.98 46.14,92.06 46.14,92.19 46,92.33 46,92.59 46.14,92.73 46.14,93.24 47.23,94.32 47.23,94.81 47.54,95.13 47.9,95.13 47.97,95.2 47.97,95.31 v3(47.73,95.55)
  L5-SIG w0.119: 44.44,87.72 44.44,83.28 43.95,82.8 43.95,82.63
76_M1_DQS0_DN: length 27.6
  L7-SIG w0.06: v6(46.08,76.68) 46.03,76.68 45.71,77 45.08,77 44.99,77.09
  L7-SIG w0.079: 44.99,77.09 44.84,77.24 44.84,78.04 44.64,78.24 44.38,78.24 44.29,78.15 44.16,78.02 44.07,77.93 43.95,77.93 43.86,78.02 43.86,78.14 44.58,78.86 44.58,79.43 44.39,79.62 44.11,79.62 43.29,78.8 43.15,78.8 43.07,78.89 43.07,79.26 43.82,80.02 43.82,80.3 43.47,80.65 43.11,80.65 42.78,80.33 42.66,80.33 42.38,80.61 42.38,80.72 42.44,80.78 42.66,80.78 42.91,81.03 42.91,81.29 42.71,81.49 42.3,81.49 42.23,81.56 42.23,89.37 41.95,89.65 41.95,89.9 42.22,90.18 42.22,90.51 41.95,90.78 41.95,91.02 43.34,92.41 43.34,92.58 43.48,92.73 43.59,92.73 43.69,92.82 43.99,93.13 44.73,93.13 44.93,93.33 44.93,93.49 45.08,93.63 45.24,93.63 45.33,93.72 45.33,93.87 45.44,93.99 45.52,93.99 v1(45.62,93.89)
76_M1_DQS0_DP: length 27.5
  L7-SIG w0.06: 44.84,76.94 44.84,76.94 44.86,76.94 44.88,76.96 44.95,76.96 45.03,76.88 45.66,76.88 45.88,76.66 45.88,76.53 45.83,76.48 v6(45.75,76.48)
  L7-SIG w0.079: 44.84,76.94 44.63,77.15 44.63,77.95 44.55,78.03 44.46,78.03 44.24,77.81 44.24,77.81 44.15,77.73 43.86,77.73 43.66,77.93 43.66,78.23 44.38,78.95 44.38,79.34 44.3,79.42 44.2,79.42 43.38,78.6 43.07,78.6 42.86,78.8 42.86,79.35 43.62,80.1 43.62,80.21 43.38,80.45 43.2,80.45 42.87,80.12 42.58,80.12 42.17,80.53 42.17,80.81 42.35,80.99 42.57,80.99 42.7,81.12 42.7,81.2 42.62,81.29 42.21,81.29 42.02,81.48 42.02,89.28 41.74,89.56 41.74,89.99 42.02,90.26 42.02,90.42 41.74,90.7 41.74,91.1 43.13,92.5 43.13,92.67 43.4,92.93 43.5,92.93 43.6,93.03 43.9,93.33 44.65,93.33 44.73,93.41 44.73,93.57 44.99,93.84 45.03,93.84 v1(45.08,93.89)
76_M1_DQS1_DN: length 34.8
  L7-SIG w0.06: 45.39,75.03 45.46,74.96 46.05,74.96 v6(46.06,74.97)
  L7-SIG w0.079: 45.39,75.03 44.09,75.03 43.99,75.13 43.99,75.55 42.85,76.69 42.51,76.69 42.3,76.48 42.3,76.01 43.11,75.2 43.11,74.95 43,74.84 42.8,74.84 41.97,75.68 41.82,75.82 41.82,76.75 39.17,79.41 39.17,92.83 41.26,94.92 41.26,95.29 41.37,95.4 41.83,95.4 42.24,95.82 42.24,96.28 42.81,96.84 43.57,96.84 43.79,96.62 43.79,96.42 43.87,96.35 44.2,96.35 44.31,96.45 44.31,96.66 44.38,96.73 44.54,96.73 44.58,96.69 v1(44.58,96.6)
76_M1_DQS1_DP: length 34.8
  L7-SIG w0.06: 43.98,74.85 45.22,74.85 45.23,74.84 45.9,74.84 45.97,74.77 46.37,74.77 v6(46.38,74.75)
  L7-SIG w0.079: 43.98,74.85 43.78,75.05 43.78,75.47 42.77,76.49 42.6,76.49 42.5,76.39 42.5,76.09 43.32,75.28 43.32,74.87 43.09,74.64 42.71,74.64 41.82,75.53 41.62,75.73 41.62,76.67 38.96,79.32 38.96,92.92 41.05,95.01 41.05,95.38 41.28,95.61 41.75,95.61 42.04,95.9 42.04,96.36 42.72,97.05 43.65,97.05 44.05,96.65 v1(44.05,96.59)
76_M1_DQS2_DN: length 36.7
  L5-SIG w0.06: v6(48.07,74.66) 47.62,74.66 47.6,74.68 46.61,74.68 46.6,74.68 46.56,74.68 46.49,74.76 45.57,74.76 45.56,74.77 45.55,74.77
  L5-SIG w0.086: v1(45.57,95.08) 45.26,94.77 43.7,94.77 43.22,95.25 42.52,95.25 42.33,95.06 41.23,95.06 41.04,94.87 41.04,94.61 40.77,94.35 40.53,94.35 40.34,94.16 40.34,93.95 39.38,92.99 39.38,92.95 39.36,92.93 ; 42.52,75.75 42.52,75.73 42.86,75.38 42.86,74.92 43.01,74.77 43.17,74.77 43.34,74.94 43.63,74.94 43.8,74.77 45.55,74.77
  L5-SIG w0.119: 39.36,92.93 37.71,91.27 37.71,81.98 37.81,81.87 37.92,81.87 38.34,81.45 38.34,81.18 38.09,80.92 37.76,80.92 37.71,80.86 37.71,80.66 37.94,80.42 38.1,80.42 38.19,80.51 38.5,80.51 38.76,80.26 38.76,79.97 38.64,79.85 38.64,79.72 38.9,79.45 39.03,79.45 39.17,79.6 39.51,79.6 39.82,79.28 39.82,78.92 39.71,78.81 39.71,78.65 39.84,78.53 40.14,78.53 40.43,78.23 40.43,77.92 40.56,77.8 40.98,77.8 41.32,77.46 41.32,76.87 41.6,76.59 41.94,76.59 42.52,76.02 42.52,75.75
76_M1_DQS2_DP: length 36.6
  L5-SIG w0.06: 45.55,74.62 45.56,74.62 45.57,74.64 46.44,74.64 46.51,74.56 46.55,74.56 46.56,74.56 47.55,74.56 47.57,74.54 47.7,74.54 v6(47.79,74.45)
  L5-SIG w0.086: v1(45.16,95.08) 45.16,94.98 45.11,94.93 43.77,94.93 43.29,95.42 42.46,95.42 42.26,95.22 41.16,95.22 40.87,94.94 40.87,94.68 40.7,94.51 40.46,94.51 40.18,94.23 40.18,94.02 39.24,93.08 39.2,93.08 ; 42.29,75.75 42.29,75.74 42.3,75.73 42.45,75.59 42.71,75.32 42.71,74.86 42.95,74.62 43.23,74.62 43.4,74.79 43.57,74.79 43.73,74.62 45.55,74.62
  L5-SIG w0.119: 39.2,93.08 39.2,93.08 37.49,91.37 37.49,81.89 37.72,81.65 37.83,81.65 38.12,81.36 38.12,81.27 37.99,81.14 37.67,81.14 37.49,80.95 37.49,80.56 37.85,80.2 38.19,80.2 38.28,80.29 38.41,80.29 38.54,80.16 38.54,80.06 38.42,79.94 38.42,79.62 38.81,79.23 39.12,79.23 39.26,79.37 39.42,79.37 39.6,79.19 39.6,79.01 39.49,78.9 39.49,78.56 39.75,78.31 40.05,78.31 40.21,78.14 40.21,77.83 40.46,77.58 40.89,77.58 41.1,77.37 41.1,76.78 41.5,76.37 41.85,76.37 42.29,75.93 42.29,75.75
76_M1_DQS3_DN: length 29.2
  L5-SIG w0.076: 43.74,92.27 44.05,92.27 44.19,92.41 44.19,92.59 44.25,92.65 44.32,92.65 v1(44.46,92.51)
  L5-SIG w0.086: 41.07,88.09 41.07,88.1 41.03,88.14 41.03,88.61 41.09,88.67 41.68,88.67 41.85,88.84 41.85,89.36 41.64,89.56 41.17,89.56 41.1,89.49 40.87,89.49 40.75,89.62 40.75,90.4 41.05,90.7 41.13,90.7 41.18,90.66 41.18,90.18 41.32,90.04 42.59,90.04 42.74,90.19 42.74,90.57 42.58,90.74 42.04,90.74 41.97,90.81 41.97,91.02 41.68,91.31 41.68,91.4 41.91,91.64 42.01,91.64 42.43,91.22 42.66,91.22 42.93,91.49 42.93,91.74 42.54,92.13 42.51,92.16 42.51,92.24 42.7,92.43 42.85,92.43 43.19,92.08 43.55,92.08 43.74,92.27 ; v6(47.18,76.68) 47.12,76.62 44.93,76.62 43.95,77.6 43.95,77.66 43.93,77.67
  L5-SIG w0.119: 41.07,88.09 41.07,84.86 41.96,83.96 41.96,81.86 42.67,81.15 42.67,80.01 42.85,79.83 42.85,79.56 43.62,78.79 43.62,77.99 43.93,77.67
76_M1_DQS3_DP: length 29.2
  L5-SIG w0.086: v1(43.95,92.51) 43.9,92.46 43.7,92.46 43.48,92.25 43.26,92.25 42.91,92.59 42.63,92.59 42.35,92.31 42.35,92.09 42.42,92.02 42.77,91.67 42.77,91.56 42.6,91.38 42.5,91.38 42.08,91.8 41.85,91.8 41.51,91.47 41.51,91.24 41.81,90.95 41.81,90.74 41.97,90.57 42.51,90.57 42.58,90.51 42.58,90.26 42.53,90.2 41.39,90.2 41.34,90.25 41.34,90.72 41.2,90.86 40.98,90.86 40.58,90.47 40.58,89.55 40.81,89.33 41.17,89.33 41.24,89.4 41.57,89.4 41.68,89.29 41.68,88.9 41.61,88.83 41.02,88.83 40.87,88.68 40.87,88.12 40.85,88.1 40.85,88.09 ; v6(47.43,76.41) 47.37,76.46 47.09,76.46 47.07,76.48 44.87,76.48 43.85,77.5 43.79,77.5 43.78,77.52
  L5-SIG w0.119: 43.78,77.52 43.4,77.9 43.4,78.7 42.63,79.46 42.63,79.74 42.45,79.92 42.45,81.06 41.74,81.76 41.74,83.87 40.85,84.76 40.85,88.09
76_M1_DQS4_DN: length 24.8
  L5-SIG w0.06: 47.98,81.93 47.86,81.93 47.56,81.63 46.16,81.63 46,81.47 46,81.24 46.09,81.16 48.38,81.16 49.11,80.43 49.2,80.43 49.37,80.6 49.65,80.6 49.85,80.4 49.85,80.12 49.68,79.95 49.68,79.87 50.42,79.13 50.42,78.7 50.6,78.52 50.6,76.82 50.64,76.78 50.69,76.78 50.81,76.67 50.81,76.45 50.88,76.38 v6(50.88,76.38)
  L5-SIG w0.086: v1(47.63,92) 47.75,91.88 47.92,91.7 47.92,91.34 48.35,90.91 48.35,90.26 48.17,90.08 47.99,90.08 47.9,90 47.9,89.7 47.99,89.62 48.17,89.62 48.35,89.43 48.35,89 48.17,88.82 47.14,88.82 47.01,88.7 47.01,88.48 47.14,88.36 48.17,88.36 48.35,88.17 48.35,87.95 48.38,87.92 48.38,87.9
  L5-SIG w0.119: 47.98,81.93 48.38,82.32 48.38,87.9
76_M1_DQS4_DP: length 24.7
  L5-SIG w0.06: v6(50.6,76.58) 50.56,76.54 50.46,76.54 50.4,76.6 50.4,76.78 50.48,76.87 50.48,78.47 50.3,78.65 50.3,79.08 49.56,79.82 49.56,80 49.73,80.17 49.73,80.35 49.6,80.48 49.42,80.48 49.25,80.31 49.06,80.31 48.33,81.04 46.04,81.04 45.88,81.19 45.88,81.52 46.11,81.75 47.51,81.75 47.81,82.05 47.81,82.07 47.82,82.08
  L5-SIG w0.086: v1(47.46,91.51) 47.4,91.56 47.4,91.67 47.48,91.75 47.63,91.75 47.76,91.62 47.76,91.27 48.19,90.85 48.19,90.33 48.1,90.25 47.92,90.25 47.74,90.06 47.74,89.63 47.92,89.45 48.1,89.45 48.19,89.37 48.19,89.07 48.1,88.99 47.07,88.99 46.85,88.76 46.85,88.42 47.07,88.19 48.1,88.19 48.19,88.11 48.19,87.94 48.16,87.91 48.16,87.9
  L5-SIG w0.119: 47.82,82.08 48.16,82.41 48.16,87.9
76_M1_DQS5_DN: length 25.9
  L7-SIG w0.06: 49.76,79.66 49.88,79.66 50.31,79.23 v6(50.31,78.1)
  L7-SIG w0.079: v1(45.96,90.93) 45.96,90.85 45.71,90.6 45.71,90.36 45.35,90 45.35,89.21 45.12,88.98 45.12,88.52 45.4,88.24 45.7,88.24 46.01,88.55 46.12,88.55 46.83,87.84 46.83,87.68 46.14,86.99 46.14,85.72 46.31,85.56 46.88,85.56 46.96,85.48 46.96,85.32 46.88,85.24 46.46,85.24 46.26,85.04 46.26,84.54 46.5,84.31 47.31,84.31 47.43,84.19 47.43,83.67 47.28,83.52 46.86,83.52 46.7,83.36 46.7,82.75 46.92,82.53 47.27,82.53 47.3,82.56 47.39,82.56 47.47,82.47 47.47,82.15 47.35,82.03 46.96,82.03 46.79,82.2 46.33,82.2 46.13,82.01 46.13,81.31 46.31,81.13 46.99,81.13 47.24,80.88 47.59,80.88 47.85,81.14 48.89,81.14 48.98,81.05 48.98,80.61 48.92,80.55 47.96,80.55 47.78,80.37 47.78,79.84 47.96,79.66 49.76,79.66
76_M1_DQS5_DP: length 25.9
  L7-SIG w0.06: v6(50.57,77.78) 50.52,77.78 50.44,77.85 50.44,77.92 50.57,78.05 50.57,78.2 50.53,78.24 50.46,78.24 50.43,78.26 50.43,79.01 50.47,79.04 50.47,79.24 49.93,79.78 49.83,79.78 49.82,79.79 49.78,79.79 49.77,79.8 49.76,79.8
  L7-SIG w0.079: v1(45.96,90.48) 45.96,90.32 45.85,90.21 45.85,90.07 45.89,90.03 45.89,89.83 45.57,89.51 45.57,89.14 45.32,88.89 45.32,88.61 45.49,88.45 45.61,88.45 45.92,88.76 46.2,88.76 47.03,87.93 47.03,87.59 46.35,86.91 46.35,85.81 46.39,85.76 46.97,85.76 47.17,85.56 47.17,85.23 46.97,85.03 46.55,85.03 46.47,84.96 46.47,84.63 46.58,84.51 47.4,84.51 47.63,84.28 47.63,83.58 47.37,83.32 46.95,83.32 46.9,83.27 46.9,82.84 47,82.74 47.19,82.74 47.21,82.76 47.47,82.76 47.68,82.56 47.68,82.07 47.43,81.82 46.88,81.82 46.7,82 46.42,82 46.34,81.92 46.34,81.4 46.4,81.34 47.08,81.34 47.33,81.09 47.51,81.09 47.76,81.34 48.98,81.34 49.19,81.13 49.19,80.53 49,80.35 48.05,80.35 47.99,80.29 47.99,79.92 48.11,79.8 49.76,79.8
