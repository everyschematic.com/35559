# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
42_M1_CS2_N: length 33.7
  L2-SIG w0.081: v8(48.31,94.98) 48.13,94.98 48.03,95.08 48.03,95.44 47.93,95.54 47.7,95.54 47.61,95.44 47.61,94.92 47.18,94.5 47.18,94.18 46.77,93.77 46.77,91.51 47.56,90.71 48.41,89.87 48.41,87.07 48.09,86.76 46.12,86.76 45.51,86.15 45.51,80.17 46.24,79.44 46.24,78.61 45.89,78.26 v8(45.8,78.26)
  L3-GND w0.06: v8(45.8,78.26) 45.62,78.44 v3(45.46,78.44)
  L3-GND w0.076: v8(48.31,94.98) 48.44,94.85 v3(48.82,94.85)
  L6-GND w0.06: v3(45.46,78.44) 45.46,78.41 45.78,78.1 v6(45.79,78.1)
  L6-GND w0.076: v3(48.82,94.85) 49.2,95.23 49.63,95.23 v4(49.73,95.34)
  L7-SIG w0.076: v1(48.58,97.48) 48.72,97.48 48.96,97.24 49.18,97.24 49.34,97.39 49.34,97.58 49.48,97.72 49.68,97.72 50.28,97.13 50.28,96.19 49.73,95.65 v4(49.73,95.34) 49.81,95.26 50.3,95.26 50.37,95.19 50.37,95.11 50.34,95.08 50.34,94.95 50.13,94.74 49.9,94.74 49.86,94.7 49.86,94.69 49.86,94.57 49.9,94.53 50.28,94.53 50.47,94.73 50.75,94.73 50.83,94.8 50.83,94.85 50.9,94.93 50.99,94.93 51.08,94.84 51.08,94.78 51.13,94.73 51.23,94.73 51.33,94.62 51.33,94.39 51.23,94.29 51.23,94.22 51.33,94.12 51.33,94.04 51.28,93.98 v1(51.08,93.98)
42_M1_DATA0: length 27.1
  L7-SIG w0.064: v1(44.56,92.88) 44.63,92.95 44.79,92.95 44.85,92.88 44.85,92.76 44.72,92.62 44.72,92.38 44.58,92.24 44.38,92.24 44.26,92.12 43.9,92.12 43.75,91.97 43.75,91.88 43.61,91.74 43.12,91.74 42.94,91.56 42.94,88.49 43.09,88.34 43.09,87.94 42.95,87.81 42.95,87.48 43.04,87.4 43.25,87.4 43.31,87.33 43.31,87.16 43.24,87.09 43.17,87.09 43.12,87.04 43.12,86.41 43.01,86.3 43.01,82.49 43.01,82.49 43.01,82.29 43.01,82.29 43.01,82.17 43.11,82.07 43.47,82.07 43.51,82.03 43.51,81.89 43.41,81.8 43.21,81.8 43.14,81.73 43.14,81.59 43.2,81.53 43.3,81.53 43.38,81.45 43.38,81.02 43.44,80.96 43.56,80.96 44.2,80.32 44.2,80.15 44.29,80.06 44.46,80.06 44.66,79.86 45.61,79.86 45.88,79.59 46.09,79.59 46.36,79.86 46.52,79.86 46.57,79.81 46.57,79.54 46.51,79.48 46.43,79.48 46.24,79.28 46.24,79.14 46.12,79.03 46.04,79.03 45.91,79.16 45.91,79.26 45.83,79.34 45.57,79.34 45.53,79.38 45.53,79.54 45.47,79.6 44.93,79.6 44.87,79.54 44.87,78.73 44.78,78.64 44.78,78.5 44.94,78.34 45.04,78.34 45.14,78.44 45.14,78.72 45.2,78.77 45.55,78.77 45.74,78.58 45.74,78.49 45.7,78.46 45.46,78.46 45.4,78.39 45.4,78.24 45.32,78.16 45.22,78.16 45.12,78.06 45.12,77.98 45.31,77.78 45.31,77.71 45.27,77.67 45.18,77.67 45.12,77.61 45.12,77.39 45.19,77.33 46.01,77.33 v6(46.06,77.27)
42_M1_DATA1: length 26.8
  L7-SIG w0.064: 44.72,78.8 44.72,79.6 44.4,79.92 44.32,79.92 44.17,79.76 44.03,79.76 43.96,79.83 43.96,80.01 44.05,80.09 44.05,80.27 43.51,80.81 43.11,80.81 43.05,80.87 43.05,81.07 43.11,81.14 43.19,81.14 43.24,81.19 43.24,81.31 43.16,81.39 43.06,81.39 42.95,81.49 42.95,81.89 42.71,82.13 42.71,87.77 42.47,88.01 42.47,88.12 42.52,88.17 42.6,88.17 42.74,88.03 42.84,88.03 42.93,88.12 42.93,88.25 42.75,88.43 42.43,88.43 42.38,88.47 42.38,88.62 42.44,88.68 42.65,88.68 42.71,88.74 42.71,88.87 42.64,88.94 42.44,88.94 42.38,88.99 42.38,89.13 42.46,89.21 42.7,89.21 42.78,89.29 42.78,89.44 42.7,89.52 42.29,89.52 42.1,89.71 42.1,89.84 42.19,89.92 42.33,89.92 42.4,89.84 42.73,89.84 42.78,89.9 42.78,90.1 42.71,90.17 42.43,90.17 42.38,90.21 42.38,90.41 42.46,90.49 42.73,90.49 42.78,90.55 42.78,90.76 42.72,90.82 42.46,90.82 42.35,90.71 42.25,90.71 42.1,90.86 42.1,90.95 42.4,91.24 42.5,91.24 42.68,91.07 42.73,91.07 42.78,91.12 42.78,91.32 42.71,91.4 42.71,91.56 43.39,92.24 43.71,92.24 43.75,92.27 44.13,92.27 44.2,92.35 44.2,92.59 44.31,92.69 44.31,92.82 44.25,92.88 v1(44.16,92.88)
  L7-SIG w0.081: 44.72,78.8 44.51,78.59 44.51,78.47 44.59,78.39 44.68,78.39 44.98,78.09 44.98,77.29 45.12,77.15 45.87,77.15 46.03,77 46.07,77 46.33,76.73 46.46,76.73 46.6,76.87 46.74,76.87 46.95,76.66 v6(46.95,76.44)
42_M1_DATA2: length 27.4
  L7-SIG w0.064: v1(45.6,93.35) 45.49,93.35 45.27,93.13 45.27,93.03 45.33,92.97 45.33,92.89 45.37,92.85 45.37,92.77 45.22,92.62 45.22,92.36 45.1,92.24 44.91,92.24 44.89,92.26 44.82,92.26 44.73,92.17 44.73,92.11 44.84,91.99 44.84,91.91 44.68,91.75 44.39,91.75 44.34,91.8 44.28,91.8 44.21,91.73 44.21,91.37 44.07,91.24 43.85,91.24 43.81,91.28 43.52,91.57 43.22,91.57 43.11,91.46 43.11,88.56 43.26,88.4 43.26,87.77 43.58,87.45 43.58,87.3 43.76,87.12 43.76,87.03 43.68,86.95 43.45,86.95 43.39,86.88 43.39,86.76 43.44,86.7 43.61,86.7 43.69,86.62 43.69,86.49 43.55,86.35 43.43,86.35 43.25,86.18 43.25,82.39 43.33,82.31 43.71,82.31 43.76,82.27 43.76,81.94 43.54,81.73 43.54,81.18 44.7,80.02 45.85,80.02 46.01,79.85 46.15,79.85 46.31,80.01 46.63,80.01 46.71,79.93 46.71,79.38 46.63,79.3 46.46,79.3 46.39,79.23 46.39,79.15 46.44,79.1 46.44,79 46.39,78.95 46.26,78.95 46.15,78.83 46.03,78.83 45.68,79.19 45.42,79.19 45.35,79.26 45.35,79.41 45.3,79.46 45.09,79.46 45.02,79.38 45.02,79.04 45.14,78.91 45.61,78.91 45.88,78.64 45.88,78.37 45.83,78.32 45.63,78.32 45.55,78.24 45.55,78.12 45.49,78.06 45.49,77.84 45.56,77.77 45.78,77.77 45.99,77.55 46.1,77.55 46.19,77.63 46.29,77.63 46.35,77.57 v6(46.35,77.05)
42_M1_DATA3: length 25.6
  L7-SIG w0.064: v6(46.95,76.97) 47.18,76.97 47.43,77.22 47.43,77.38 47.32,77.49 46.6,77.49 46.56,77.53 46.56,77.96 46.81,78.22 46.81,78.34 46.74,78.42 46.66,78.42 46.61,78.47 46.61,78.9 46.85,79.14 46.85,80.01 46.69,80.17 46.26,80.17 46.2,80.11 45.96,80.11 45.91,80.17 44.76,80.17 43.7,81.24 43.7,81.67 44.03,82 44.03,82.24 43.5,82.77 43.5,86.08 44.35,86.93 44.35,87.03 44.25,87.13 44.25,87.26 44.35,87.36 44.35,87.47 44.18,87.64 44.04,87.64 43.97,87.56 43.97,87.33 43.92,87.28 43.82,87.28 43.74,87.37 43.74,87.56 43.59,87.72 43.59,87.79 43.51,87.87 43.51,87.87 43.47,87.91 43.47,88.45 43.26,88.65 43.26,90.05 43.37,90.15 43.37,90.33 43.26,90.44 43.26,90.67 43.33,90.74 44.25,90.74 44.32,90.81 44.32,91.09 44.46,91.23 44.59,91.23 ; v1(45.18,93.39) 45.23,93.39 45.45,93.61 45.71,93.61 45.92,93.4 45.92,93.24 45.84,93.15 45.84,92.85 45.72,92.73 45.55,92.73 45.38,92.56 45.38,92.16 45.39,92.15 45.39,91.79 45.32,91.73 44.88,91.73 44.73,91.58 44.73,91.58
  L7-SIG w0.076: 44.73,91.58 44.73,91.37 44.59,91.23
42_M1_DATA4: length 25.9
  L7-SIG w0.06: 44.55,76.38 44.9,76.02 45.92,76.02 45.96,75.99 46.23,75.99 46.24,76 46.41,76 46.55,75.87 46.55,75.6 v6(46.57,75.58)
  L7-SIG w0.064: v1(44.49,93.58) 44.3,93.76 44.3,93.94 44.07,94.17 43.51,94.17 43.35,94.01 43.35,93.55 42.67,92.86 42.67,92.82 42.46,92.61 42.41,92.61 42.35,92.61 42.08,92.88 41.94,92.88 41.82,92.76 41.82,92.65 42.12,92.36 42.12,92.21 42.03,92.13 41.86,92.13 41.55,92.44 41.48,92.44 41.07,92.03 41.07,80.56 41.58,80.05 41.72,80.05 41.79,79.99 41.79,79.92 41.85,79.86 41.85,79.78 42.07,79.56 42.15,79.56 42.33,79.38 42.33,78.61 44.32,76.62 44.32,76.6 44.55,76.38
42_M1_DATA5: length 27.8
  L7-SIG w0.06: 45.63,76.28 45.84,76.28 46.02,76.46 46.16,76.46 46.3,76.6 46.41,76.6 46.56,76.46 46.56,76.15 v6(46.59,76.11)
  L7-SIG w0.064: 45.63,76.28 45.25,76.28 45.21,76.31 45.21,76.46 45.11,76.57 45.06,76.57 44.93,76.44 44.86,76.44 44.81,76.49 44.81,76.74 44.36,77.19 44.36,77.3 44.48,77.43 44.48,77.6 44.41,77.67 44.3,77.67 44.15,77.53 43.81,77.53 43.49,77.85 43.49,78.35 43.38,78.46 42.92,78.46 42.72,78.65 42.72,79.41 43.34,80.02 43.34,80.11 43.25,80.2 43.15,80.2 42.77,79.81 42.63,79.81 42.49,79.95 42.34,79.95 42.22,80.07 42.22,80.28 42.06,80.44 41.77,80.44 41.72,80.49 41.72,80.6 41.77,80.65 41.97,80.65 42.02,80.7 42.02,80.85 42.16,81 42.16,81.09 42.09,81.16 41.99,81.16 41.73,80.91 41.63,80.91 41.56,80.97 41.56,88.09 41.62,88.15 41.78,88.15 41.87,88.23 41.87,88.45 41.77,88.55 41.56,88.55 41.49,88.63 41.49,88.75 41.54,88.8 41.82,88.8 41.87,88.85 41.87,89.11 41.79,89.19 41.56,89.19 41.44,89.31 41.44,89.47 41.58,89.62 41.58,90.05 41.77,90.23 41.77,90.43 41.56,90.64 41.56,91.14 41.73,91.31 41.73,91.59 41.82,91.67 42.02,91.67 42.98,92.63 42.98,92.73 43.33,93.09 43.44,93.09 43.67,93.32 43.67,93.37 43.87,93.58 v1(44.11,93.58)
  BOTTOM w0.203: U1701.K16 44.31,93.28
42_M1_DATA6: length 27.5
  L7-SIG w0.06: 44.72,76.02 44.84,75.9 45.87,75.9 45.91,75.87 46.26,75.87 v6(46.33,75.8)
  L7-SIG w0.064: 40.89,89.64 40.89,89.47 40.74,89.31 40.74,89.14 40.92,88.97 40.92,88.88 40.74,88.71 40.74,88.63 40.92,88.46 40.92,88.35 40.74,88.17 40.74,88.05 40.83,87.96 40.83,80.46 41.52,79.76 41.66,79.76 41.81,79.62 41.81,79.54 41.74,79.47 41.74,79.4 41.83,79.31 41.91,79.31 42.01,79.41 42.09,79.41 42.15,79.35 42.15,79.24 42.09,79.18 42.09,79.05 42.15,78.99 42.15,78.87 42.15,78.59 44.72,76.02 ; 40.92,90.19 40.92,90.37 40.74,90.54 40.74,90.64 40.89,90.79 40.89,90.87 40.74,91.02 40.74,91.15 40.89,91.3 40.89,91.4 40.74,91.55 40.74,91.63 40.87,91.75 40.87,91.87 40.81,91.93 40.81,92.02 41.4,92.62 41.59,92.62 41.65,92.67 41.65,92.86 41.96,93.18 42.06,93.18 42.39,92.84 42.47,92.84 42.51,92.89 42.51,92.93 42.63,93.05 42.63,93.07 42.29,93.41 42.29,93.5 42.44,93.65 42.51,93.65 42.83,93.33 42.91,93.33 43.03,93.45 43.03,93.55 42.88,93.71 42.88,93.79 42.96,93.88 43.07,93.88 43.1,93.91 43.1,94.02 43.41,94.32 44.14,94.32 44.53,93.94 v1(44.58,93.94)
  L7-SIG w0.081: 40.89,89.64 40.74,89.79 40.74,90.01 40.92,90.19
42_M1_DATA7: length 25.6
  L7-SIG w0.06: 44.66,76.59 44.66,76.44 44.96,76.14 45.99,76.14 v6(46.04,76.19)
  L7-SIG w0.064: 44.66,76.59 44.66,76.68 44.43,76.91 44.23,76.91 44.13,77.01 44.13,77.31 44.05,77.39 43.75,77.39 43.24,77.9 43.24,78.04 43.35,78.15 43.35,78.25 43.29,78.32 43.14,78.32 43.04,78.21 42.93,78.21 42.47,78.67 42.47,78.95 42.58,79.06 42.58,79.2 42.47,79.31 42.47,79.43 42.58,79.55 42.58,79.66 42.45,79.79 42.28,79.79 42.2,79.71 42.12,79.71 41.97,79.86 41.97,79.91 41.94,79.94 41.94,79.97 42.07,80.09 42.07,80.23 42,80.3 41.68,80.3 41.32,80.66 41.32,87.91 41.23,87.99 41.23,88.2 41.4,88.37 41.4,88.48 41.23,88.65 41.23,88.77 41.43,88.97 41.43,89.09 41.23,89.29 41.23,89.49 41.4,89.66 41.4,89.83 41.23,90 41.23,90.1 41.45,90.32 41.45,90.46 41.41,90.51 41.28,90.51 41.23,90.56 41.23,90.81 41.28,90.86 41.36,90.86 41.4,90.91 41.4,91.05 41.23,91.22 41.23,91.4 41.28,91.45 41.51,91.45 41.57,91.5 41.57,91.62 41.5,91.69 41.32,91.69 41.23,91.78 41.23,91.97 41.45,92.18 41.52,92.18 41.87,91.83 41.96,91.83 42.27,92.14 42.27,92.39 42.34,92.46 42.59,92.46 42.82,92.69 42.82,92.8 43.27,93.24 43.37,93.24 43.51,93.38 43.51,93.6 43.56,93.65 43.72,93.65 v1(43.98,93.91)
42_M1_DATA8: length 35.6
  L7-SIG w0.064: v1(44.63,97.55) 44.29,97.88 42.95,97.88 42.44,98.39 40.39,98.39 40.15,98.15 40.15,95.91 37.73,93.49 37.73,78.48 40.43,75.78 40.43,75.71 42.23,73.9 45.54,73.9 v6(45.72,74.08)
42_M1_DATA9: length 35.3
  L7-SIG w0.06: 44.6,75.74 44.72,75.62 45.92,75.62 v6(46.03,75.51)
  L7-SIG w0.064: v1(45.55,97.47) 45.55,98.09 45.55,98.09 45.55,98.41 45.01,98.96 45.01,99.14 45.32,99.44 45.5,99.44 45.83,99.11 45.83,97.62 46.31,97.14 46.31,96.91 46.82,96.4 46.82,95.45 46.34,94.97 45.99,94.97 45.75,94.73 44.48,94.73 44.41,94.65 44.27,94.65 44.26,94.65 43.29,94.65 42.95,94.32 42.44,94.32 41.24,93.12 41.24,92.91 40.87,92.54 40.77,92.54 40.62,92.69 40.51,92.69 40.44,92.62 40.44,92.51 40.62,92.34 40.62,92.29 40.23,91.9 40.23,80.23 41.87,78.59 41.87,78.47 44.6,75.74
42_M1_DATA10: length 34.9
  L7-SIG w0.06: 44.43,74.54 44.5,74.61 45.12,74.61 45.13,74.6 45.8,74.6 45.88,74.53 46.03,74.53 v6(46.11,74.44)
  L7-SIG w0.064: v1(44.59,96.98) 44.4,96.98 44.36,97.01 44.36,97.23 44.28,97.31 44.22,97.31 44.13,97.22 43.99,97.22 43.92,97.22 43.73,97.41 42.49,97.41 41.75,96.67 41.75,96.04 41.61,95.9 41.1,95.9 38.41,93.21 38.41,78.76 39.87,77.31 40.15,77.31 40.33,77.13 40.76,76.69 41.2,76.69 41.26,76.63 41.26,76.54 41.2,76.48 40.93,76.48 40.86,76.41 40.86,76.32 40.93,76.25 41.21,76.25 41.29,76.17 41.29,76.09 41.23,76.02 41.08,76.02 41.02,75.96 41.02,75.83 41.08,75.77 41.23,75.77 41.29,75.71 41.29,75.44 42.38,74.35 43.24,74.35 43.55,74.66 43.6,74.66 43.9,74.35 44.33,74.35 44.38,74.4 44.38,74.49 44.43,74.54
42_M1_DATA11: length 36.3
  L7-SIG w0.064: v1(45.01,97.48) 45.01,97.59 44.55,98.05 43.14,98.05 43.01,98.18 43.01,98.94 43.14,99.07 44.58,99.07 45.33,98.32 45.33,97.88 45.31,97.86 45.31,96.04 45.13,95.86 44.97,95.86 44.84,95.74 44.23,95.74 44.19,95.69 43.99,95.69 43.83,95.54 43.83,95.38 43.69,95.23 43.41,95.23 43.13,95.51 42.49,95.51 41.95,94.97 41.95,94.85 41.7,94.6 41.7,94.59 39.74,92.63 39.74,80.02 41.6,78.16 41.78,78.16 44.6,75.34 45.6,75.34 v6(45.66,75.29)
  BOTTOM w0.203: U1701.B14 45.31,97.28
42_M1_DATA12: length 35
  L7-SIG w0.06: 44.64,75.5 45.74,75.5 45.93,75.31 46.34,75.31 46.39,75.25 v6(46.92,75.25)
  L7-SIG w0.064: 44.64,75.5 41.8,78.34 41.77,78.34 39.99,80.12 39.99,92.66 40.36,93.03 40.41,93.03 40.59,92.84 40.7,92.84 40.77,92.92 40.77,93.02 40.62,93.18 40.62,93.29 40.7,93.37 40.85,93.37 40.96,93.26 41.04,93.26 41.12,93.35 41.12,93.41 40.97,93.56 40.97,93.64 41.05,93.72 41.19,93.72 41.36,93.55 41.44,93.55 41.57,93.68 41.57,93.81 41.4,93.97 41.4,94.07 41.51,94.18 41.6,94.18 41.79,93.99 41.88,93.99 42.01,94.12 42.01,94.22 41.89,94.35 41.89,94.55 41.95,94.61 42.08,94.61 42.24,94.45 42.32,94.45 42.39,94.52 42.39,94.62 42.19,94.83 42.19,94.99 42.25,95.05 42.46,95.05 42.52,95.11 42.52,95.32 42.56,95.36 43.06,95.36 43.33,95.09 43.33,94.88 43.4,94.81 43.75,94.81 43.82,94.88 43.82,95.11 43.9,95.19 44.38,95.19 44.41,95.21 44.93,95.21 45.05,95.33 45.89,95.33 45.98,95.24 46.22,95.24 46.34,95.36 46.34,96.28 46.38,96.32 46.38,96.55 46.19,96.73 45.83,96.73 v1(45.58,96.98)
42_M1_DATA13: length 35.5
  L7-SIG w0.06: v6(46.87,74.75) 46.68,74.75 46.48,74.55 46.3,74.55 46.2,74.65 45.92,74.65 45.85,74.72 45.18,74.72 45.17,74.73 44.35,74.73 44.3,74.68 ; 40.26,77.51 40.28,77.49 40.37,77.49 40.43,77.56 40.52,77.56 40.6,77.48 40.6,77.39 40.54,77.33 40.54,77.24 40.62,77.16 40.71,77.16 40.77,77.22 40.86,77.22 40.94,77.14 40.94,77.05 40.88,76.99 40.88,76.9 40.91,76.87 41.2,76.87 41.41,76.66 41.41,75.54 42.46,74.49 42.59,74.49
  L7-SIG w0.064: 42.59,74.49 43.18,74.49 43.47,74.78 43.47,74.94 43.54,75.01 43.62,75.01 43.85,74.78 43.85,74.6 43.96,74.49 44.19,74.49 44.23,74.53 44.23,74.61 44.3,74.68 ; 40.26,77.51 38.64,79.14 38.64,93.12 39.25,93.73 39.25,93.79 39.35,93.89 39.44,93.89 39.52,93.81 39.6,93.81 39.69,93.9 39.69,93.99 39.62,94.07 39.62,94.16 39.71,94.25 39.8,94.25 39.87,94.17 39.96,94.17 40.05,94.26 40.05,94.35 39.98,94.43 39.98,94.52 40.07,94.61 40.16,94.61 40.23,94.53 40.32,94.53 40.41,94.62 40.41,94.71 40.34,94.79 40.34,94.88 40.43,94.97 40.52,94.97 40.59,94.89 40.68,94.89 40.77,94.98 40.77,95.07 40.7,95.15 40.7,95.24 41.22,95.76 41.69,95.76 41.89,95.96 41.89,96.49 42.65,97.25 43.67,97.25 43.94,96.98 v1(44.08,96.98)
  BOTTOM w0.203: v1(44.08,96.98) 44.31,96.78
42_M1_DATA14: length 35.7
  L7-SIG w0.06: v6(46.63,74.38) 46.39,74.38 46.24,74.24 46.03,74.24 45.86,74.41 45.33,74.41 45.12,74.2 44.95,74.2 44.85,74.3 44.78,74.3
  L7-SIG w0.064: v1(44.02,97.45) 43.9,97.57 42.02,97.57 41.61,97.16 41.61,96.89 41.53,96.81 41.23,96.81 41.14,96.72 41.14,96.6 41.23,96.51 41.53,96.51 41.59,96.45 41.59,96.21 41.46,96.08 41.14,96.08 40.93,96.3 40.72,96.3 40.6,96.19 40.6,95.72 38.19,93.3 38.19,78.67 40.08,76.77 40.39,76.77 40.46,76.7 40.46,76.25 40.55,76.16 40.78,76.16 40.87,76.07 40.87,75.98 40.76,75.88 40.76,75.79 42.34,74.21 43.32,74.21 43.54,74.43 43.62,74.43 43.85,74.21 44.51,74.21 44.6,74.3 44.78,74.3
  BOTTOM w0.203: U1701.B16 44.31,97.28
42_M1_DATA15: length 35.2
  L7-SIG w0.06: v6(46.87,74.14) 46.32,74.14 46.29,74.12 45.98,74.12 45.81,74.29 45.48,74.29 45.33,74.14
  L7-SIG w0.064: v1(45.01,97.03) 44.82,97.22 44.63,97.22 44.13,97.72 41.9,97.72 40.37,96.19 40.37,95.81 37.96,93.4 37.96,78.58 40.56,75.98 40.56,75.82 42.3,74.08 45.27,74.08 45.33,74.14
42_M1_DATA16: length 36.2
  L5-SIG w0.06: v6(48.05,74.08) 47.51,73.55 45.02,73.55 44.68,73.89
  L5-SIG w0.109: 40.55,96.15 43.87,96.15 v1(44.08,95.94) ; 41.58,74.74 42.43,73.89 44.68,73.89
  L5-SIG w0.127: 41.58,74.74 36.27,80.05 36.27,91.87 40.55,96.15
42_M1_DATA17: length 37.1
  L5-SIG w0.109: v1(44.55,95.46) 44.55,95.7 44.62,95.77 44.81,95.77 44.91,95.67 44.91,95.24 44.78,95.11 43.99,95.11 43.51,95.59 42.19,95.59 42.01,95.42 41.66,95.42 41.49,95.59 41.17,95.59 40.7,95.12 40.7,94.82 40.58,94.7 40.28,94.7 39.57,93.99 ; v6(47.13,74.35) 46.79,74.35 46.73,74.29 46.73,74.04 46.65,73.96 46.54,73.96 46.46,74.04 46.46,74.35 46.35,74.47 46.24,74.47 46.14,74.36 46.14,74.06 46.04,73.96 45.88,73.96 45.81,74.04 45.81,74.36 45.7,74.47 42.85,74.47 41.87,75.44
  L5-SIG w0.127: 41.87,75.44 41.87,75.89 41.68,76.09 41.41,76.09 40.81,76.69 40.81,77.13 40.69,77.25 40.25,77.25 39.1,78.41 39.1,78.69 38.94,78.86 38.65,78.86 37.11,80.4 37.11,81.18 37.3,81.37 37.3,81.53 37.11,81.72 37.11,91.52 39.57,93.99
42_M1_DATA18: length 36.4
  L5-SIG w0.06: v6(47.75,74.99) 47.68,74.92 46.72,74.92 46.53,75.1 46.41,75.1
  L5-SIG w0.076: v1(45.17,95.58) 45.17,95.89 45.27,95.99 45.35,95.99 45.49,95.85 45.89,95.85 45.97,95.77 45.97,94.92 45.48,94.44 45.28,94.44
  L5-SIG w0.109: 43.86,75.29 44.06,75.1 46.41,75.1 ; 45.28,94.44 43.49,94.44 43.27,94.22 42.17,94.22 42.05,94.1 41.81,94.1 41.65,94.26 41.19,94.26 40.74,93.8 40.74,93.7 40.84,93.59 40.96,93.59 41.3,93.93 41.39,93.93 41.51,93.81 41.51,93.63 40.9,93.02 40.75,93.02 40.62,93.15 40.62,93.28 40.48,93.42 40.37,93.42 40.19,93.24 40.19,93.1 40.36,92.93 40.36,92.79 40.21,92.63 39.99,92.63 39.34,91.98
  L5-SIG w0.127: 43.86,75.29 43.86,75.4 41.87,77.39 41.87,77.74 40.48,79.13 40.48,79.56 39.31,80.73 39.31,81.42 38.36,82.36 38.36,91 39.34,91.98
42_M1_DATA19: length 35.8
  L5-SIG w0.06: v6(48.57,75.21) 48.95,75.21 49.02,75.14 49.02,75.08 49.21,74.89 49.21,74.8 49.1,74.7 48.95,74.7 48.71,74.94 48.46,74.94 48.37,75.03 48.02,75.03 47.84,75.21 47.68,75.21 47.51,75.04 46.77,75.04 46.54,75.27 46.49,75.27
  L5-SIG w0.109: 44.12,75.43 44.28,75.27 46.49,75.27 ; 40.13,92.37 40.56,92.37 42.1,93.91 42.26,93.91 42.36,94.01 42.52,94.01 42.62,93.91 42.71,93.91 42.78,93.91 42.88,94.01 43.06,94.01 43.16,93.91 43.36,93.91 43.44,93.99 43.44,94.13 43.56,94.24 45.53,94.24 46.14,94.85 46.14,95.84 46.03,95.94 46.03,96.05 46.14,96.15 46.14,96.32 46.07,96.39 45.94,96.39 45.66,96.1 v1(45.59,96.1)
  L5-SIG w0.127: 40.13,92.37 38.64,90.89 38.64,82.48 39.59,81.53 39.59,80.85 40.76,79.68 40.76,79.24 42.06,77.94 42.06,77.49 44.12,75.43
42_M1_DATA20: length 35.8
  L5-SIG w0.06: 46.88,75.41 47,75.29 47.38,75.29 47.62,75.53 v6(47.69,75.53)
  L5-SIG w0.109: 42.48,78.31 42.48,77.56 44.41,75.62 46.67,75.62 46.88,75.41 ; 40.45,91.95 40.66,91.95 42.25,93.54 42.56,93.54 43.52,93.54 43.81,93.83 45.64,93.83 46.51,94.7 46.51,94.7 46.51,97.42 46.08,97.85 45.3,97.85 44.83,97.38 44.83,96.95 44.99,96.79 45.36,96.79 45.56,96.59 v1(45.56,96.59)
  L5-SIG w0.127: 42.48,78.31 41.32,79.48 41.32,79.91 40.14,81.08 40.14,81.77 39.2,82.71 39.2,90.65 39.97,91.42 40.02,91.42 40.22,91.62 40.22,91.72 40.45,91.95
42_M1_DATA21: length 36.6
  L5-SIG w0.06: 47.92,74.28 47.97,74.33 48.1,74.33 48.51,73.91 48.7,73.91 48.81,74.03 48.81,74.29 48.68,74.42 v6(48.37,74.42)
  L5-SIG w0.076: 47.92,74.28 47.88,74.24 47.7,74.24 47.56,74.38 47.47,74.38 47.3,74.21 47.3,73.98 47.11,73.8 45.23,73.8 44.9,74.12
  L5-SIG w0.109: 40.88,95.69 40.97,95.78 43.64,95.78 43.88,95.53 43.98,95.53 v1(44.08,95.43) ; 41.6,75.44 42.81,74.23 44.8,74.23 44.9,74.12
  L5-SIG w0.127: 40.88,95.69 36.83,91.64 36.83,80.28 41.6,75.51 41.6,75.44
42_M1_DATA22: length 36.5
  L5-SIG w0.06: 41.74,74.97 42.66,74.06 44.75,74.06 45.14,73.67 47.31,73.67 47.51,73.87 v6(47.51,74.12)
  L5-SIG w0.076: 43.58,95.96 43.72,95.96 43.98,95.7 44.18,95.7 44.32,95.84 44.32,96.04 44.2,96.16 44.2,96.27 44.28,96.35 44.53,96.35 44.62,96.27 v1(44.62,96.03)
  L5-SIG w0.109: 40.48,95.69 40.76,95.96 43.58,95.96
  L5-SIG w0.127: 40.48,95.69 36.55,91.75 36.55,80.17 41.74,74.97
42_M1_DATA23: length 35
  L5-SIG w0.06: v6(48.07,75.28) 47.94,75.28 47.89,75.33 47.62,75.33 47.45,75.16 46.88,75.16 46.76,75.28
  L5-SIG w0.076: v1(45.04,96.12) 44.89,96.27 44.89,96.45 44.97,96.53 45.25,96.53 45.43,96.34 45.66,96.34 45.83,96.52 45.83,96.74
  L5-SIG w0.109: 46.76,75.28 46.59,75.45 44.35,75.45 42.26,77.54 42.26,78.14 ; 45.83,96.74 45.83,96.83 45.96,96.96 46.19,96.96 46.32,96.83 46.32,94.77 45.57,94.02 43.74,94.02 43.44,93.72 42.63,93.72 42.17,93.72 40.6,92.15 40.3,92.15
  L5-SIG w0.127: 42.26,78.14 41.04,79.36 41.04,79.79 39.86,80.97 39.86,81.65 38.92,82.59 38.92,90.77 40.3,92.15
42_M1_DATA24: length 28.2
  L5-SIG w0.109: 42.96,87.81 42.96,88.3 42.5,88.76 42.3,88.76 42.22,88.83 42.22,89.18 42.27,89.23 42.61,89.23 42.71,89.32 42.79,89.32 42.84,89.27 42.84,89.09 42.75,89 42.75,88.9 42.97,88.69 43.14,88.69 43.16,88.7 43.16,88.71 43.35,88.9 43.35,89.05 43.16,89.23 43.16,89.4 42.96,89.6 42.96,89.73 43.14,89.91 43.14,90.03 43.26,90.15 43.26,90.28 43.14,90.4 43.14,90.76 43.01,90.89 43.01,91.06 43.3,91.34 43.3,91.64 43.37,91.72 43.73,91.72 43.89,91.87 v1(44,91.87) ; v6(47.49,76.96) 47.49,77.04 47.4,77.13 47.31,77.13 47.2,77.24 47.06,77.24 46.83,77.01 45.09,77.01 44.78,77.31 44.78,77.62 44.65,77.75 44.34,77.75 43.97,78.12 43.97,78.92 43.22,79.67 43.22,79.94 43.03,80.13 43.03,81.73 42.92,81.85
  L5-SIG w0.127: 42.92,81.85 42.63,82.13 42.63,84.27 42.52,84.38 42.52,84.53 42.63,84.64 42.63,85.72 42.54,85.82 42.41,85.82 42.31,85.71 42.19,85.71 42.07,85.84 42.07,86.08 42.19,86.21 42.39,86.21 42.5,86.32 42.5,86.48 42.39,86.59 42.22,86.59 42.09,86.72 42.09,86.87 42.22,87 42.69,87 42.94,86.75 43.13,86.75 43.26,86.88 43.26,87.13 43.04,87.34 42.22,87.34 42.09,87.47 42.09,88.24 42.2,88.35 42.35,88.35 42.46,88.24 42.46,87.81 42.59,87.69 42.84,87.69 42.96,87.81
  BOTTOM w0.203: U1701.N16 43.86,92.19
42_M1_DATA25: length 29.2
  L5-SIG w0.06: v6(47.49,75.83) 47.49,75.57 47.34,75.42 47.13,75.42 46.95,75.59
  L5-SIG w0.076: 45.98,93.35 45.98,92.82 v1(45.65,92.49)
  L5-SIG w0.109: 41.64,79.48 42.71,78.4 42.71,77.56 44.49,75.79 46.75,75.79 46.95,75.59 ; 45.98,93.35 45.98,93.6 45.93,93.65 43.92,93.65 43.63,93.35 42.48,93.35 42.33,93.35 40.7,91.73 40.7,91.62 39.74,90.65
  L5-SIG w0.127: 39.74,90.65 39.58,90.5 39.58,82.87 40.53,81.92 40.53,81.24 41.64,80.12 41.64,79.48
42_M1_DATA26: length 28.2
  L5-SIG w0.076: 45.79,93.18 45.83,93.14 45.83,92.9 45.68,92.75 45.57,92.75 45.4,92.58 45.4,92.2 45.18,91.98 v1(45.14,91.98)
  L5-SIG w0.109: 45.79,93.18 45.51,93.46 44,93.46 43.71,93.17 42.4,93.17 40.92,91.68 40.92,91.57 40.02,90.67 40.02,90.64 39.86,90.49 ; v6(47.23,75.62) 46.89,75.96 44.56,75.96 42.88,77.63 42.88,78.47 42.07,79.29 42.07,79.34
  L5-SIG w0.127: 42.07,79.34 42.07,79.38 41.85,79.59 41.85,80.32 40.8,81.37 40.8,82.04 39.86,82.98 39.86,90.49
42_M1_DATA27: length 26.8
  L5-SIG w0.06: 46.89,78.04 47.24,78.04 47.87,77.42 47.92,77.42 48.01,77.33 48.01,77.28 48.37,76.91 48.53,76.91 48.66,77.04 48.77,77.04 48.84,76.97 48.84,76.87 48.65,76.67 48.65,76.19 48.75,76.09 48.75,75.9 48.57,75.72 48.57,75.52 48.53,75.48 48.37,75.48 v6(48.32,75.53)
  L5-SIG w0.076: v1(44.46,91.49) 44.5,91.45 44.95,91.45 45.03,91.37 45.03,91.19 44.97,91.12 44.4,91.12 44.32,91.05 44.32,90.87
  L5-SIG w0.109: 43.59,82.52 43.81,82.29 43.81,79.96 44.52,79.26 45.07,79.26 45.18,79.14 45.33,79.14 45.44,79.26 45.78,79.26 45.83,79.21 45.83,79.13 45.53,78.83 45.37,78.83 45.12,78.58 45.12,78.57 45.12,78.57 45.12,78.29 45.33,78.09 45.73,78.09 45.8,78.16 45.8,78.3 45.81,78.3 45.81,78.34 45.87,78.4 46.02,78.4 46.07,78.35 46.07,78.15 46.14,78.09 46.3,78.09 46.36,78.14 46.36,78.44 46.41,78.49 46.56,78.49 46.64,78.42 46.64,78.12 46.72,78.04 46.89,78.04 ; 44.06,87.85 44.29,88.08 44.29,88.44 44.92,89.07 44.92,89.31 44.84,89.39 44.35,89.39 44.27,89.47 44.27,89.65 44.35,89.72 44.81,89.72 44.9,89.82 44.9,90.04 44.81,90.13 44.48,90.13 44.41,90.2 44.41,90.34 44.5,90.44 44.76,90.44 44.83,90.51 44.83,90.68 44.78,90.74 44.45,90.74 44.32,90.87
  L5-SIG w0.127: 44.06,87.85 44.06,83.44 43.53,82.9 43.53,82.58 43.59,82.52
42_M1_DATA28: length 27.9
  L5-SIG w0.06: 46.77,76.3 47.25,76.3 47.35,76.2 47.35,76.09 47.4,76.03 47.66,76.03 v6(47.75,76.11)
  L5-SIG w0.076: v1(44.97,92.51) 45.11,92.36 45.2,92.36 45.25,92.41 45.25,92.65 45.33,92.74 45.33,92.97 45.19,93.11 44.42,93.11 44.36,93.04
  L5-SIG w0.109: 44.36,93.04 44.12,92.8 43.73,92.8 43.47,92.54 43.26,92.54 43.01,92.8 42.56,92.8 42.15,92.39 42.15,92.18 41.97,92.01 41.77,92.01 41.29,91.53 41.29,91.27 41.08,91.06 40.94,91.06 40.41,90.54 40.41,89.26 40.48,89.18 40.69,89.18 40.8,89.08 40.8,88.92 40.73,88.86 40.52,88.86 40.42,88.75 40.42,88.64 40.59,88.47 40.59,88.35 40.52,88.28 ; 42.44,79.62 42.44,79.4 43.22,78.63 43.22,77.77 44.7,76.3 46.77,76.3
  L5-SIG w0.127: 40.52,88.28 40.42,88.18 40.42,84.24 40.47,84.19 40.89,84.19 41.25,83.83 41.25,83.53 41.02,83.3 41.02,83.12 41.36,82.78 41.36,81.6 42.27,80.7 42.27,79.81 42.45,79.63 42.44,79.62
42_M1_DATA29: length 27.5
  L5-SIG w0.06: v6(48.02,76.96) 47.92,76.86 47.81,76.86 47.69,76.98 47.69,77.05 47.65,77.08 47.65,77.08 47.61,77.13 47.61,77.15 47.61,77.15 47.61,77.16 47.61,77.27 47.53,77.35
  L5-SIG w0.109: 43.3,87.81 43.5,87.81 43.59,87.9 43.59,88.04 43.5,88.13 43.24,88.13 43.17,88.2 43.17,88.45 43.64,88.92 43.64,89.05 43.35,89.34 43.35,89.47 43.24,89.58 43.24,89.75 43.36,89.86 43.36,89.97 43.47,90.08 43.58,90.08 43.68,90.18 43.68,90.29 43.35,90.62 43.35,90.81 43.27,90.89 43.27,91.05 43.48,91.27 43.48,91.45 43.55,91.52 43.66,91.52 43.79,91.4 43.87,91.4 v1(43.96,91.49) ; 47.53,77.35 47.38,77.35 47.31,77.42 47.31,77.6 47.18,77.73 47.04,77.73 46.96,77.65 46.96,77.38 46.77,77.19 45.15,77.19 44.95,77.38 44.95,77.71 45.02,77.78 45.02,77.92 44.91,78.02 44.77,78.02 44.67,77.92 44.44,77.92 44.16,78.21 44.16,78.98 43.96,79.17 43.96,79.34 43.84,79.45 43.68,79.45 43.39,79.74 43.39,79.93 43.47,80.01 43.47,80.19 43.41,80.25 43.29,80.25 43.2,80.33 43.2,80.45 43.29,80.53 43.38,80.53 43.47,80.63 43.47,80.76 43.38,80.85 43.28,80.85 43.2,80.93 43.2,81.05 43.28,81.13 43.41,81.13 43.47,81.19 43.47,81.33 43.41,81.4 43.28,81.4 43.2,81.48 43.2,81.59 43.28,81.67 43.39,81.67 43.47,81.75 43.47,81.97 43.34,82.1 43.16,82.1
  L5-SIG w0.127: 43.3,87.81 43.24,87.75 43.24,87.55 43.37,87.42 43.52,87.42 43.58,87.37 43.58,86.58 43.45,86.46 42.9,86.46 42.78,86.34 42.78,86.17 42.9,86.05 43.37,86.05 43.5,85.92 43.5,85.78 43.37,85.65 43.03,85.65 42.92,85.53 42.92,85.37 43.03,85.26 43.39,85.26 43.5,85.16 43.5,85.01 43.39,84.91 43.03,84.91 42.92,84.81 42.92,84.68 43.04,84.56 43.43,84.56 43.5,84.49 43.5,84.27 43.43,84.2 43.04,84.2 42.93,84.09 42.93,83.93 43.04,83.82 43.33,83.82 43.42,83.72 43.42,83.6 43.31,83.48 43.04,83.48 42.91,83.35 42.91,82.25 43.07,82.1 43.16,82.1
42_M1_DATA30: length 27.6
  L5-SIG w0.109: 40.2,90.38 40.2,90.59 40.86,91.25 40.98,91.25 41.1,91.37 41.1,91.6 41.69,92.19 41.84,92.19 41.89,92.19 41.96,92.26 41.96,92.46 42.48,92.98 43.08,92.98 43.3,92.77 43.43,92.77 43.65,92.98 43.94,92.98 44,93.05 44,93.2 44.08,93.28 45.43,93.28 45.58,93.12 v1(45.58,92.99) ; v6(47.14,76.1) 47.11,76.13 44.63,76.13 43.05,77.7 43.05,78.56 42.26,79.35
  L5-SIG w0.127: 40.2,90.38 40.14,90.32 40.14,84 40.27,83.87 40.8,83.87 40.93,83.74 40.93,83.62 40.8,83.49 40.27,83.49 40.14,83.36 40.14,83.11 40.33,82.92 40.82,82.92 41.08,82.66 41.08,81.48 42.05,80.51 42.05,79.7 42.26,79.5 42.26,79.35
42_M1_DATA31: length 28.2
  L5-SIG w0.06: 46.76,77.49 46.76,77.73 46.9,77.87 47.24,77.87 47.81,77.3 v6(47.81,77.21)
  L5-SIG w0.076: v1(44.49,92) 44.66,92 44.71,92.05 44.71,92.16 44.79,92.24 44.87,92.24 44.89,92.21 44.89,91.89 44.99,91.78 44.99,91.65 44.95,91.6 44.73,91.6 44.6,91.73 44.31,91.73 44.22,91.64 44.22,91.33 44.13,91.24
  L5-SIG w0.109: 43.39,82.32 43.64,82.06 43.64,79.73 43.75,79.62 43.91,79.62 44.13,79.41 44.13,79.24 44.32,79.05 45.02,79.05 45.09,78.98 45.09,78.85 44.99,78.75 44.43,78.75 44.33,78.64 44.33,78.28 44.51,78.09 44.6,78.09 44.68,78.18 44.68,78.38 44.76,78.46 44.87,78.46 44.95,78.38 44.95,78.22 45.26,77.91 46.01,77.91 46.09,77.83 46.09,77.68 46.03,77.63 45.73,77.63 45.65,77.56 45.65,77.45 45.73,77.38 46.65,77.38 46.76,77.49 ; 44.13,91.24 44.05,91.17 44.05,91.07 44.13,90.99 44.13,90.84 44.03,90.74 43.92,90.74 43.82,90.84 43.82,91.02 43.74,91.1 43.64,91.1 43.54,91 43.54,90.69 43.8,90.43 44.1,90.43 44.22,90.31 44.22,90.05 44.15,89.98 43.74,89.98 43.53,89.77 43.53,89.42 43.74,89.21 44.58,89.21 44.64,89.14 44.64,89.05 44.33,88.74 44.16,88.74 44.06,88.84 43.82,88.84 43.57,88.59 43.57,88.43 43.64,88.36 44.01,88.36 44.1,88.27 44.1,88.15 44.01,88.06 43.91,88.06 43.78,87.93 43.78,87.59
  L5-SIG w0.127: 43.39,82.32 43.25,82.46 43.25,83.02 43.78,83.55 43.78,87.59
42_M1_DATA32: length 22.8
  L5-SIG w0.06: v6(49.71,76.4) 49.71,76.31 49.56,76.16 49.54,76.16 49.29,75.91 49.21,75.91 49.15,75.97 49.15,76.05 49.3,76.2 49.3,76.51 49.45,76.66 49.72,76.66 49.78,76.72 49.78,76.78 49.74,76.83 49.64,76.83 49.61,76.86 49.61,76.91 49.88,77.18 49.88,77.44 49.66,77.66 49.54,77.66 49.51,77.63 49.4,77.63 49.32,77.71 49.32,77.82 49.41,77.91 49.41,78.14 49.34,78.21
  L5-SIG w0.109: 44.73,81.86 44.65,81.78 44.65,80.32 44.8,80.16 47.65,80.16 48.14,79.67 48.53,79.67 49.04,79.15 49.04,78.8 49.34,78.5 49.34,78.21 ; 45.66,88.31 45.81,88.46 45.81,89.47 45.99,89.65 45.99,89.83 45.81,90.01 45.81,90.14 45.9,90.24 46.01,90.24 46.3,89.94 46.49,89.94 46.57,90.02 46.57,90.12 46.27,90.42 46.27,90.67 46.47,90.87 v1(46.6,90.87)
  L5-SIG w0.127: 44.73,81.86 45.66,82.8 45.66,88.31
42_M1_DATA33: length 23.3
  L5-SIG w0.06: 49.84,77.76 49.84,77.67 50,77.51 50,77.12 49.91,77.03 49.91,76.17 50.04,76.04 50.04,75.71 v6(49.78,75.45)
  L5-SIG w0.109: v1(46.6,90.46) 46.78,90.46 46.85,90.38 46.85,89.89 46.72,89.75 46.36,89.75 46,89.39 46,88.06 45.94,88.01 45.94,87.77 ; 45.8,82.46 45.66,82.46 44.86,81.67 44.86,81.47 45.09,81.24 45.09,81.01 44.86,80.79 44.86,80.5 45.03,80.33 47.78,80.33 48.25,79.87 48.57,79.87 49.51,78.93 49.51,78.29 49.56,78.24 49.56,78.04 49.84,77.76
  L5-SIG w0.127: 45.94,87.77 45.94,84.76 46.07,84.63 46.78,84.63 46.88,84.52 46.88,84.07 46.77,83.95 46.46,83.95 46.39,84.02 46.39,84.2 46.32,84.27 46.03,84.27 45.94,84.18 45.94,82.55 45.85,82.46 45.8,82.46
  BOTTOM w0.06: v6(49.78,75.45) 49.75,75.49 U2400.BD48
42_M1_DATA34: length 23.1
  L5-SIG w0.06: v6(51.18,76.13) 51.18,76.29 51.23,76.34 51.23,76.44 51.2,76.48 51.07,76.48 50.98,76.57 50.98,76.8 51.05,76.86 51.14,76.86 51.18,76.91 51.18,76.99 51.15,77.03 51.03,77.03 50.84,77.22 50.84,77.59 50.94,77.69
  L5-SIG w0.076: v1(47.57,90.99) 47.64,91.05 47.64,91.17 47.55,91.25 47.44,91.25 47.35,91.16 47.27,91.16 47.21,91.21 47.21,91.72 47.36,91.86 47.36,92.24 47.44,92.32 47.55,92.32 47.61,92.26 48.12,92.26 48.31,92.07 48.63,92.07 48.73,91.97 48.73,90.26 48.73,90.25
  L5-SIG w0.109: 49.74,81.55 49.74,81.24 49.8,81.18 49.93,81.18 49.99,81.23 50.1,81.23 50.36,81.49 50.51,81.49 50.62,81.38 50.62,81.16 50.68,81.1 50.85,81.1 50.94,81.01 50.94,80.7 50.82,80.58 50.82,80.29 50.94,80.17 50.94,79.99 50.73,79.79 50.73,79.6 50.94,79.39 50.94,79.12 50.81,78.99 50.81,78.8 50.94,78.67 50.94,77.69 ; 48.95,87.9 48.95,89.06 48.73,89.29 48.73,90.25
  L5-SIG w0.127: 48.95,87.9 48.95,87.62 49.03,87.54 49.03,82.16 49.16,82.03 50.11,82.03 50.22,81.93 50.22,81.78 50.11,81.68 49.87,81.68 49.74,81.55
42_M1_DATA35: length 23.2
  L5-SIG w0.06: v6(50.35,76.36) 50.28,76.44 50.28,76.83 50.36,76.92 50.36,78.26 50.3,78.32
  L5-SIG w0.109: 50.3,78.32 50.02,78.6 50.02,79.14 49.37,79.78 49.37,80 49.27,80.1 49.05,80.1 48.3,80.86 45.83,80.86 45.71,80.98 45.71,81.69 45.92,81.91 46.74,81.91 ; v1(47.62,90.48) 47.62,90.21 47.52,90.11 47.52,89.59 47.78,89.33 47.78,89.24 47.7,89.16 46.69,89.16 46.57,89.05 46.57,88.38 47.04,87.91 47.07,87.91
  L5-SIG w0.127: 46.74,81.91 46.92,82.09 47.29,82.09 47.76,82.56 47.76,85.37 47.68,85.46 47.47,85.46 47.37,85.56 47.37,85.68 47.77,86.08 47.77,86.29 47.66,86.4 47.24,86.4 47.07,86.57 47.07,86.8 47.28,87.01 47.28,87.26 47.36,87.34 47.72,87.34 47.78,87.4 47.78,87.84 47.71,87.91 47.07,87.91
  BOTTOM w0.203: U1701.T9 47.36,90.69
42_M1_DATA36: length 23.8
  L5-SIG w0.06: v6(50.3,75.78) 50.3,75.95 50.03,76.22 50.03,76.93 50.12,77.02 50.12,77.57 50.05,77.64 50.05,77.76 49.86,77.95 49.86,78.27 49.68,78.44
  L5-SIG w0.109: 49.68,78.44 49.68,79 48.61,80.07 48.28,80.07 47.85,80.5 45.5,80.5 45.29,80.72 45.29,81.85 45.7,82.27 46.33,82.27 46.39,82.33
  L5-SIG w0.127: 46.39,82.33 46.42,82.36 46.42,82.49 46.22,82.69 46.22,83.54 46.35,83.67 46.57,83.67 46.7,83.54 46.7,82.77 46.82,82.65 47.04,82.65 47.16,82.77 47.16,84.8 47.04,84.93 46.35,84.93 46.22,85.05 46.22,88.1 46.19,88.13 46.19,89.26 46.48,89.55 46.99,89.55 47.1,89.66 v1(47.1,90.47)
  BOTTOM w0.203: U1701.T10 46.86,90.69
42_M1_DATA37: length 23.6
  L5-SIG w0.076: 48.41,92.46 48.21,92.66 47.72,92.66 47.57,92.81 47.47,92.81 47.2,92.54 46.89,92.54 46.84,92.49 46.84,91.84 46.69,91.7 46.69,91.56 46.65,91.52 46.52,91.52 46.35,91.35 46.35,91.12 46.39,91.09 46.5,91.09 46.56,91.15 46.56,91.25 46.61,91.3 46.71,91.3 46.76,91.24 46.76,91.16 46.82,91.11 46.88,91.11 47.06,91.29 47.06,91.44 v1(46.96,91.54)
  L5-SIG w0.109: 49.33,89.28 49.09,89.52 49.09,92.31 49,92.4 48.47,92.4 48.41,92.46 ; 50.74,82.04 51.28,81.5 51.28,81.31 51.42,81.17 51.42,80.01 51.28,79.87 51.28,79.66 51.42,79.52 51.42,79.25 51.28,79.11 51.28,77.46 v6(51.16,77.35)
  L5-SIG w0.127: 49.33,89.28 49.49,89.13 49.49,87.65 49.62,87.52 49.62,84.88 49.73,84.76 49.91,84.76 50.02,84.65 50.02,84.49 49.93,84.4 49.67,84.4 49.59,84.32 49.59,84.23 49.7,84.12 49.7,83.96 49.59,83.85 49.59,83.7 49.66,83.63 49.86,83.63 50.03,83.8 50.18,83.8 50.33,83.65 50.95,83.65 51.03,83.57 51.03,83.38 50.74,83.09 50.74,82.04
42_M1_DATA38: length 23.8
  L5-SIG w0.06: v6(51.23,76.68) 51.3,76.75 51.3,77.05 51.21,77.15 51.08,77.15 50.96,77.27 50.96,77.48 51.03,77.54
  L5-SIG w0.076: v1(47.11,91.96) 46.99,92.08 46.99,92.32 47.06,92.39 47.27,92.39 47.46,92.59 47.56,92.59 47.72,92.43 47.83,92.43 47.91,92.51 48.1,92.51 48.38,92.23 48.86,92.23 48.9,92.18 48.9,89.42 49.13,89.19
  L5-SIG w0.109: 50.04,82.33 50.04,82.3 50.11,82.22 50.42,82.22 50.47,82.17 50.47,81.81 50.57,81.71 50.82,81.71 50.94,81.58 50.94,81.36 51.11,81.19 51.11,81 51.25,80.86 51.25,80.72 51.11,80.58 51.11,80.43 51.21,80.33 51.21,80.09 51.11,79.99 51.11,77.62 51.03,77.54
  L5-SIG w0.127: 50.04,82.33 50.04,82.43 50.11,82.5 50.39,82.5 50.46,82.58 50.46,82.68 50.39,82.76 50.1,82.76 50.02,82.84 50.02,82.96 50.1,83.04 50.37,83.04 50.46,83.13 50.46,83.26 50.37,83.35 49.78,83.35 49.71,83.28 49.71,82.33 49.59,82.22 49.43,82.22 49.31,82.33 49.31,87.54 49.24,87.61 49.24,87.62 49.23,87.63 49.23,89.1 49.13,89.19
42_M1_DATA39: length 24.1
  L5-SIG w0.06: v6(50.83,75.8) 50.48,76.15 50.27,76.15 50.15,76.27 50.15,76.88 50.24,76.97 50.24,77.67 50.2,77.71
  L5-SIG w0.076: v1(47.1,90.99) 47.03,90.92 47.03,90.79 47.11,90.71 47.31,90.71 47.38,90.64 47.38,90.31
  L5-SIG w0.109: 46.5,88.17 46.39,88.29 46.39,89.16 46.58,89.35 47.23,89.35 47.32,89.44 47.32,90.26 47.38,90.31 ; 46.57,82.1 45.82,82.1 45.5,81.78 45.5,80.81 45.63,80.69 48.23,80.69 48.27,80.64 48.27,80.32 48.35,80.25 48.67,80.25 49.85,79.07 49.85,78.5 50.2,78.15 50.2,77.71
  L5-SIG w0.127: 46.57,82.1 46.8,82.32 47.12,82.32 47.45,82.65 47.45,85.07 47.14,85.38 46.99,85.38 46.83,85.22 46.56,85.22 46.5,85.27 46.5,85.43 46.66,85.59 46.66,85.71 46.5,85.87 46.5,86.11 46.56,86.17 46.74,86.17 46.81,86.24 46.81,86.45 46.71,86.55 46.58,86.55 46.5,86.63 46.5,86.95 46.58,87.03 46.87,87.03 47,87.16 47,87.42 46.87,87.54 46.63,87.54 46.5,87.67 46.5,88.17
42_M1_DATA40: length 25.4
  L7-SIG w0.06: 50.04,79.31 50.19,79.16 50.19,78.3 50.07,78.18 50.07,78.18 50.07,78.05 50.29,77.83 50.29,77.74 50.44,77.59 50.44,77.49 50.2,77.25 50.2,77.16 50.31,77.06 50.46,77.06 50.58,76.94 50.58,76.85 50.42,76.69 50.32,76.69 49.84,77.17 49.84,77.24 50.06,77.47 50.06,77.68 v6(50,77.75)
  L7-SIG w0.064: 50.04,79.31 49.84,79.51 48.34,79.51 48.22,79.38 48.22,79.26 48.09,79.13 48.01,79.13 47.58,79.55 47.58,80.37 47.86,80.65 47.86,80.73 47.81,80.78 47.71,80.78 47.66,80.73 47.51,80.73 47.41,80.63 47.25,80.63 46.94,80.93 46.08,80.93 45.98,81.03 45.98,81.59 45.93,81.64 45.7,81.64 45.65,81.69 45.65,81.91 45.85,82.1 45.85,82.23 46.01,82.4 46.01,82.6 45.87,82.74 45.87,82.82 45.96,82.92 46.15,82.92 46.24,83 46.24,83.56 46.46,83.78 46.46,83.88 46.36,83.98 45.59,83.98 45.52,84.06 45.52,84.29 45.58,84.35 45.76,84.35 45.8,84.39 45.8,85.58 45.7,85.68 45.57,85.68 45.52,85.73 45.52,85.89 45.57,85.94 45.72,85.94 45.8,86.02 45.8,87.35 45.9,87.46 45.9,87.53 45.85,87.59 45.85,87.72 45.97,87.85 46.11,87.85 46.24,87.72 46.37,87.72 46.47,87.82 46.47,87.96 46.15,88.27 46.06,88.27 45.65,87.87 45.53,87.87 44.94,88.46 44.94,89.07 45.17,89.3 45.17,90.05 45.38,90.25 45.38,90.39 v1(45.47,90.48)
42_M1_DATA41: length 25.5
  L7-SIG w0.064: v6(49.99,78.39) 50.06,78.46 50.06,78.91 49.87,79.1 49.87,79.23 49.74,79.36 48.54,79.36 48.11,78.93 48.01,78.93 47.42,79.51 47.42,80.39 47.34,80.48 47.2,80.48 46.9,80.77 45.87,80.77 45.83,80.81 45.83,81.39 45.75,81.47 45.34,81.47 45.29,81.52 45.29,81.58 45.5,81.8 45.5,82.05 45.58,82.13 45.58,82.33 45.69,82.44 45.69,82.54 45.51,82.72 45.51,82.81 45.99,83.29 45.99,83.58 45.87,83.7 45.71,83.7 45.35,83.35 45.35,83.04 45.27,82.96 45.2,82.96 45.11,83.05 45.11,83.19 45.04,83.26 44.82,83.26 44.76,83.32 44.76,83.52 44.8,83.57 45.17,83.57 45.27,83.68 45.27,84.16 45.22,84.21 45.14,84.21 44.97,84.03 44.75,84.03 44.59,84.2 44.59,84.46 44.67,84.55 45.47,84.55 45.56,84.64 45.56,84.78 45.47,84.87 44.65,84.87 44.59,84.93 44.59,85.28 44.62,85.31 44.73,85.31 44.84,85.2 45.41,85.2 45.5,85.29 45.5,85.43 45.41,85.52 44.9,85.52 44.84,85.58 44.84,85.71 44.94,85.81 45.09,85.81 45.17,85.88 45.17,86.44 45.25,86.52 45.4,86.52 45.59,86.71 45.59,87.59 44.76,88.42 44.76,89.34 45.01,89.59 ; v1(45.53,90.88) 45.42,90.88 45.22,90.68
  L7-SIG w0.076: 45.01,89.59 45.01,90.11 45.22,90.31 45.22,90.68
42_M1_DATA42: length 25.8
  L7-SIG w0.064: v1(45.58,91.48) 45.72,91.48 45.8,91.4 45.8,91.28 45.72,91.2 44.99,91.2 44.86,91.07 44.86,90.91 44.68,90.74 44.53,90.74 44.43,90.64 44.43,90.41 44.24,90.23 43.67,90.23 43.42,89.98 43.42,88.72 43.63,88.52 43.63,88.06 43.87,87.82 44.23,87.82 44.56,87.49 44.56,86.86 43.83,86.13 43.83,82.91 44.37,82.37 44.37,82.11 43.85,81.59 43.85,81.29 44.81,80.32
  L7-SIG w0.081: v6(49.49,77.81) 49.36,77.69 49.36,77.57 49.45,77.48 49.45,77.31 49.39,77.25 49.23,77.25 49.16,77.18 49.16,77.06 49.34,76.89 49.34,76.79 49.26,76.72 49.16,76.72 48.95,76.92 48.92,76.92 48.81,77.03 48.81,77.03 48.69,77.15 48.24,77.15 48.14,77.25 48.14,77.31 48.26,77.43 48.26,77.6 47.93,77.94 47.78,77.94 47.73,77.89 47.73,77.63 47.63,77.54 47.52,77.54 47.4,77.66 46.8,77.66 46.71,77.74 46.71,77.87 46.8,77.96 47.12,77.96 47.19,78.04 47.19,78.19 47.14,78.24 47.02,78.24 46.96,78.3 46.96,78.47 47.02,78.52 47.12,78.52 47.22,78.62 47.22,79.03 47.14,79.11 47.07,79.11 47,79.17 47,80.07 46.74,80.32 44.81,80.32
42_M1_DATA43: length 25
  L7-SIG w0.06: v6(49.75,77.53) 49.79,77.58 49.79,77.85 49.92,77.98 49.92,78.16 49.79,78.3 49.78,78.3 49.78,78.47 49.92,78.61 49.92,78.82 49.88,78.86
  L7-SIG w0.064: v1(44.97,90.46) 44.83,90.32 44.83,89.63 44.61,89.41 44.61,88.96 44.46,88.82 44.19,88.82 44.09,88.93 44.09,89.01 44.27,89.2 44.27,89.27 44.19,89.35 43.83,89.35 43.73,89.25 43.73,88.84 43.96,88.61 43.96,88.35 44.15,88.15 44.26,88.15 44.33,88.22 44.33,88.5 44.39,88.56 44.53,88.56 44.61,88.48 44.61,88.28 45.3,87.59 45.3,86.85 44.84,86.39 44.84,86.06 44.66,85.89 44.41,85.89 44.33,85.81 44.33,84.1 44.51,83.93 44.51,83.48 44.36,83.33 44.36,83.09 44.69,82.76 45.06,82.76 45.34,82.48 45.34,81.89 45.09,81.64 44.81,81.64 44.74,81.57 44.74,81.36 44.81,81.29 45.6,81.29 45.68,81.21 45.68,81.01 45.6,80.93 45.35,80.93 45.26,80.84 45.26,80.72 45.35,80.63 46.85,80.63 47.28,80.19 47.28,79.46 48.01,78.72 48.11,78.72 48.6,79.22 49.06,79.22 49.12,79.16 49.12,78.95 49.19,78.88 49.33,78.88 49.4,78.95 49.4,79.16 49.45,79.21 49.66,79.21 49.71,79.15 49.71,79.03 49.88,78.86
  BOTTOM w0.203: U1701.T14 44.86,90.69
42_M1_DATA44: length 26.1
  L7-SIG w0.06: v6(50.88,78.76) 50.95,78.84 50.95,79.42 50.79,79.58
  L7-SIG w0.064: 50.79,79.58 49.67,80.7 49.67,81.74 49.47,81.95 49.34,81.95 49.23,82.05 49.23,82.18 49.09,82.32 49.09,87.59 48.96,87.73 48.61,87.73 48.56,87.78 48.56,88.12 47.86,88.83 46.97,88.83 46.85,88.94 46.85,89.07 46.94,89.15 47.08,89.15 47.17,89.24 47.17,89.41 47.08,89.49 46.94,89.49 46.85,89.57 46.85,89.74 46.94,89.83 47.08,89.83 47.17,89.91 47.17,90.08 47.08,90.16 46.94,90.16 46.85,90.24 46.85,91.14 46.94,91.23 47.66,91.23 47.76,91.33 47.76,91.67 47.67,91.76 47.52,91.76 47.38,91.9 47.38,92.39 46.85,92.92 46.85,93.35 46.7,93.5 46.7,93.63 46.79,93.73 47.01,93.73 47.07,93.66 47.07,93.51 47.15,93.43 47.25,93.43 47.33,93.51 47.33,94.16 47.26,94.22 47.15,94.22 47.07,94.14 47.07,94.07 47.01,94.01 46.59,94.01 46.24,93.66 46.24,93.55 46.5,93.29 46.5,92.85 46.6,92.75 46.68,92.75 46.99,92.43 46.99,92.26 46.86,92.13 46.86,92 46.72,91.86 46.3,91.86 46.17,91.73 45.96,91.73 45.87,91.82 45.87,91.94 45.96,92.03 v1(46.08,92.03)
42_M1_DATA45: length 25.2
  L7-SIG w0.06: v6(51.11,77.81) 51.11,78.15 50.96,78.31 50.96,78.56 51.08,78.68 51.08,79.27 51.31,79.5 51.31,79.58 51.22,79.67 50.92,79.67
  L7-SIG w0.064: v1(46.62,92.1) 46.42,92.3 45.99,92.3 45.89,92.4 45.89,92.54 45.99,92.64 46.21,92.64 46.34,92.77 46.34,93.22 46.04,93.53 46.04,93.76 46.43,94.15 46.43,94.82 46.76,95.16 46.97,95.16 47.5,94.62 47.5,93.39 47.18,93.07 47.18,92.84 47.87,92.14 47.87,91.91 47.95,91.83 47.95,91.24 47.84,91.13 47.84,90.85 47.72,90.73 47.43,90.73 47.37,90.67 47.37,90.12 47.34,90.09 47.34,89.32 47.56,89.11 47.82,89.11 49.34,87.58 49.34,82.57 49.45,82.47 49.45,82.29 49.82,81.92 49.82,80.77 50.92,79.67
42_M1_DATA46: length 25.8
  L7-SIG w0.06: v6(50.87,77.54) 50.78,77.62 50.78,77.89 50.69,77.98 50.69,78.17 50.84,78.32 50.84,78.51 50.67,78.68 50.67,78.85 50.83,79.01 50.83,79.34 50.65,79.52
  L7-SIG w0.064: 48.11,87.89 48.03,87.81 48.03,87.6 48.08,87.54 48.65,87.54 48.84,87.34 48.84,87.23 48.76,87.15 48.44,87.15 48.36,87.06 48.36,86.9 48.44,86.82 48.76,86.82 48.84,86.74 48.84,86.62 48.79,86.57 48.57,86.57 48.51,86.51 48.51,86.4 48.56,86.34 48.77,86.34 48.84,86.27 48.84,85.33 48.76,85.25 48.67,85.25 48.57,85.15 48.57,85.02 48.67,84.92 48.76,84.92 48.84,84.84 48.84,84.68 48.76,84.6 48.71,84.6 48.62,84.51 48.62,84.35 48.71,84.27 48.76,84.27 48.84,84.19 48.84,84.03 48.76,83.95 48.51,83.95 48.42,83.85 48.42,83.72 48.51,83.62 48.76,83.62 48.84,83.54 48.84,83.38 48.76,83.3 48.48,83.3 48.4,83.21 48.4,83.05 48.48,82.97 48.76,82.97 48.84,82.89 48.84,82.73 48.76,82.64 48.71,82.64 48.62,82.56 48.62,82.24 48.24,81.85 ; v1(46.08,91.48) 46.14,91.48 46.36,91.7 46.64,91.7 46.71,91.63 46.71,91.26 46.65,91.2 46.43,91.2 46.36,91.13 46.36,90.36 46.5,90.22 46.65,90.22 46.79,90.08 46.79,89.9 46.68,89.79 46.68,89.64 46.61,89.58 46.11,89.58 45.95,89.42 45.95,89.24 46,89.19 46.61,89.19 46.69,89.11 46.69,88.81 46.84,88.66 47.29,88.66 47.37,88.58 47.37,88.2 47.46,88.12 47.62,88.12 47.7,88.2 47.7,88.6 47.75,88.66 47.81,88.66 48.39,88.07 48.39,87.94 48.34,87.89
  L7-SIG w0.081: 48.24,81.85 48.24,81.75 48.34,81.65 48.44,81.65 48.81,82.02 48.96,82.02 49.21,81.77 49.39,81.77 49.51,81.64 49.51,80.45 49.64,80.32 49.85,80.32 50.65,79.52 ; 48.11,87.89 48.34,87.89
42_M1_DATA47: length 25.9
  L7-SIG w0.06: v6(49.72,78.72) 49.66,78.67 49.66,78.25 49.67,78.25 49.75,78.16 49.75,78.09 49.7,78.03 49.49,78.03 49.27,78.25 49.12,78.25 49.02,78.14 48.84,78.14 48.64,78.35
  L7-SIG w0.064: 48.64,78.35 48.64,78.51 48.9,78.77 48.9,78.93 48.75,79.08 48.67,79.08 48.14,78.55 47.99,78.55 47.14,79.4 47.14,80.13 46.79,80.48 45.2,80.48 45.12,80.55 45.12,81.03 45.04,81.11 44.89,81.11 44.81,81.03 44.81,80.83 44.74,80.75 44.58,80.75 44.43,80.9 44.43,81.03 44.59,81.19 44.59,81.44 44.5,81.52 44.39,81.52 44.31,81.44 44.31,81.29 44.26,81.24 44.1,81.24 44.03,81.31 44.03,81.57 44.28,81.82 44.48,81.82 44.53,81.87 44.53,82.12 44.62,82.2 44.73,82.2 44.81,82.12 44.81,81.9 44.9,81.82 45.01,81.82 45.09,81.9 45.09,82.38 44.97,82.51 44.8,82.51 44.79,82.5 44.58,82.5 44.1,82.98 44.1,83.42 44.26,83.57 44.26,83.84 44.08,84.01 44.08,86.02 44.58,86.52 44.69,86.52 45.12,86.95 45.12,87.51 44.64,87.99 44.03,87.99 43.78,88.24 43.78,88.58 43.59,88.78 43.59,89.85 43.66,89.93 43.79,89.93 43.84,89.87 43.84,89.62 43.89,89.57 44.01,89.57 44.33,89.88 44.33,90.08 44.73,90.48 44.73,90.56 44.76,90.59 44.76,90.59 45.06,90.89 45.06,90.91 v1(45.1,90.95)
42_M1_DATA48: length 26.5
  L7-SIG w0.06: v6(51.43,77.57) 51.52,77.66 51.52,77.85 51.49,77.88 51.34,77.88 51.24,77.98 51.24,78.18 51.37,78.31 51.37,78.49 51.32,78.53 51.32,79.16 51.6,79.44
  L7-SIG w0.064: 51.6,79.44 51.6,79.67 51.32,79.94 51.09,79.94 50.15,80.88 50.15,81.47 50.2,81.52 50.48,81.52 50.58,81.62 50.58,81.77 50.81,82 50.81,82.18 50.76,82.23 50.3,82.23 50.22,82.3 50.22,82.48 50.34,82.6 50.67,82.6 50.75,82.68 50.75,82.85 50.67,82.93 50.36,82.93 50.3,82.99 50.3,83.2 50.36,83.25 50.67,83.25 50.75,83.33 50.75,83.5 50.67,83.58 50.39,83.58 50.3,83.66 50.3,83.82 50.39,83.9 50.67,83.9 50.75,83.98 50.75,87.34 50.84,87.43 51.51,87.43 51.62,87.53 51.62,87.68 51.56,87.74 50.8,87.74 50.72,87.82 50.72,87.99 50.79,88.06 51.96,88.06 52.48,88.58 ; 50.46,88.53 49.91,87.98 49.55,87.98 49.18,88.34 49.04,88.34 48.39,88.99 48.39,89.16 48.47,89.24 48.7,89.24 48.79,89.34 48.79,89.49 48.7,89.58 48.19,89.58 48.1,89.67 48.1,89.85 48.48,90.23 48.68,90.23 48.82,90.37 48.82,90.58 48.96,90.73 48.96,90.73 v1(49.11,90.87) ; 50.9,88.35 51.74,88.35 52.26,88.86
  L7-SIG w0.081: 52.26,88.86 52.4,88.86 52.48,88.78 52.48,88.58 ; 50.46,88.53 50.71,88.53 50.9,88.35
42_M1_DATA49: length 27.6
  L7-SIG w0.06: v6(51.7,78.37) 51.66,78.41 51.66,79.01 51.72,79.07
  L7-SIG w0.064: v1(49.53,90.9) 49.53,90.89 49.31,90.66 49.31,89.85 49.18,89.72 49.18,89.62 49.92,88.88 49.92,88.81 49.61,88.51 49.61,88.4 49.7,88.32 49.79,88.32 50.51,89.04 50.66,89.04 51.03,88.67 ; 52.81,88.41 52.61,88.22 52.61,87.81 51.84,87.04 51.84,86.77 51.76,86.69 51.55,86.69 51.5,86.64 51.5,86.41 51.54,86.36 51.76,86.36 51.84,86.28 51.84,86.12 51.76,86.04 51.58,86.04 51.5,85.96 51.5,85.8 51.59,85.71 51.76,85.71 51.84,85.63 51.84,85.47 51.76,85.39 51.58,85.39 51.5,85.31 51.5,85.15 51.59,85.06 51.76,85.06 51.84,84.98 51.84,84.82 51.76,84.74 51.58,84.74 51.5,84.66 51.5,84.5 51.59,84.41 51.76,84.41 51.84,84.33 51.84,84.17 51.76,84.09 51.58,84.09 51.5,84.01 51.5,83.85 51.59,83.76 51.76,83.76 51.84,83.68 51.84,83.52 51.76,83.44 51.58,83.44 51.5,83.36 51.5,83.2 51.59,83.11 51.76,83.11 51.84,83.03 51.84,82.87 51.75,82.78 51.57,82.78 51.49,82.7 51.49,82.36 51.41,82.28 51.24,82.28 51.16,82.21 51.16,82.1 51.24,82.03 51.41,82.03 51.49,81.95 51.49,81.6 51.44,81.54 51.28,81.54 51.23,81.49 51.23,81.4 51.32,81.32 51.47,81.32 51.51,81.27 51.51,81.21 51.41,81.11 51.41,80.69 51.34,80.63 51.25,80.63 51.15,80.73 51.15,81.14 51.06,81.24 50.7,81.24 50.54,81.08 50.54,80.96 50.61,80.89 50.81,80.89 50.86,80.84 50.86,80.64 51.13,80.37 51.37,80.37 52,79.74 52,79.61 52.11,79.5 52.11,79.18 52,79.07 51.72,79.07
  L7-SIG w0.081: 52.81,88.41 52.81,90.22 52.75,90.27 52.15,90.27 52.11,90.23 52.11,89.16 51.61,88.67 51.03,88.67
42_M1_DATA50: length 25.7
  L7-SIG w0.06: v6(52.86,77.81) 52.86,78.16 52.69,78.33 52.69,78.52
  L7-SIG w0.064: 52.69,78.52 52.69,78.77 52.76,78.84 52.76,78.96 52.85,79.05 52.85,80.23 52.4,80.69 52.4,80.97 52.78,81.35 53.05,81.35 53.23,81.53 53.23,81.97 53.99,82.73 53.99,82.91 54.1,83.03 54.26,83.03 54.37,83.13 54.37,83.28 54.26,83.39 54.1,83.39 54,83.5 54,83.65 54.1,83.75 54.49,83.75 54.57,83.83 54.57,84 54.49,84.08 54.09,84.08 54.01,84.16 54.01,84.39 54.11,84.49 54.49,84.49 54.58,84.58 54.58,86.79 54.34,87.03 54.34,87.27 54.53,87.47 54.53,87.85 54.34,88.04 54.34,88.29 54.54,88.5 54.54,88.72 54.34,88.93 54.34,89.18 54.54,89.39 54.54,89.66 54.58,89.7 54.58,92.53 54.43,92.67 53.12,92.67 52.99,92.79 52.99,93.37 52.8,93.56 52.28,93.56 52.15,93.43 52.15,92.08 51.83,91.75 50.31,91.75 50.25,91.81 49.76,91.81 v1(49.59,91.98)
42_M1_DATA51: length 27
  L7-SIG w0.06: 51.49,78.7 51.49,78.24 51.44,78.2 v6(51.44,78.1)
  L7-SIG w0.064: 50.39,88.69 49.86,88.16 49.6,88.16 49.35,88.4 49.35,88.49 49.69,88.83 49.69,88.88 49.5,89.07 49.36,89.07 49.25,88.95 49.25,88.72 49.15,88.62 49,88.62 48.69,88.94 48.69,89.01 48.8,89.12 49.08,89.12 49.18,89.21 49.18,89.39 49.12,89.44 49.03,89.44 48.95,89.52 48.95,89.67 48.88,89.74 48.47,89.74 48.4,89.8 48.4,89.95 48.48,90.03 48.73,90.03 48.94,90.23 49.05,90.23 49.12,90.31 49.12,90.42 v1(49.07,90.48) ; 52.65,88.48 52.38,88.21 52.38,87.94 52.32,87.88 51.98,87.88 51.92,87.82 51.92,87.48 51.62,87.18 51.07,87.18 50.98,87.09 50.98,86.96 51.07,86.87 51.18,86.87 51.27,86.78 51.27,86.66 51.18,86.57 51.08,86.57 50.98,86.47 50.98,86.34 51.08,86.24 51.21,86.24 51.25,86.2 51.25,85.98 51.19,85.92 51.07,85.92 50.98,85.82 50.98,85.69 51.07,85.59 51.17,85.59 51.25,85.52 51.25,85.34 51.17,85.27 51.07,85.27 50.98,85.17 50.98,85.04 51.07,84.94 51.21,84.94 51.25,84.9 51.25,84.68 51.18,84.62 51.08,84.62 50.98,84.52 50.98,84.39 51.08,84.29 51.18,84.29 51.28,84.2 51.28,84.06 51.18,83.97 51.08,83.97 51,83.88 51,83.72 51.08,83.64 51.17,83.64 51.25,83.56 51.25,83.4 51.17,83.32 51.08,83.32 51,83.23 51,83.07 51.08,82.99 51.17,82.99 51.25,82.91 51.25,82.75 51.17,82.67 51.08,82.67 51,82.58 51,81.53 50.88,81.41 50.68,81.41 50.61,81.33 50.42,81.33 50.33,81.24 50.33,80.96 51.16,80.12 51.34,80.12 51.82,79.64 51.82,79.36 51.69,79.23 51.61,79.23 51.49,79.1 51.49,78.7
  L7-SIG w0.081: 52.65,88.48 52.65,90.02 52.6,90.07 52.36,90.07 52.3,90.01 52.3,89.13 51.68,88.51 50.96,88.51 50.78,88.69 50.39,88.69
42_M1_DATA52: length 27.4
  L7-SIG w0.06: v6(51.73,77.79) 51.8,77.86 51.8,78.18 51.93,78.31 51.93,78.46 51.81,78.58 51.81,78.82 51.93,78.95 52.15,78.95 52.23,79.02
  L7-SIG w0.064: 52.23,79.02 52.23,79.56 52.18,79.61 52.18,79.79 51.67,80.3 51.67,81.37 51.72,81.42 51.89,81.42 51.94,81.47 51.94,81.57 51.89,81.62 51.74,81.62 51.67,81.69 51.67,81.83 51.72,81.88 51.92,81.88 52.01,81.97 52.01,82.08 51.96,82.14 51.8,82.14 51.74,82.2 51.74,82.41 51.79,82.46 52.16,82.46 52.25,82.54 52.25,82.86 52.08,83.03 52.08,83.13 52.15,83.2 52.67,83.2 52.76,83.29 52.76,83.43 52.67,83.52 52.15,83.52 52.1,83.58 52.1,83.8 52.14,83.85 52.52,83.85 52.6,83.93 52.6,84.09 52.52,84.17 52.13,84.17 52.1,84.21 52.1,84.46 52.13,84.5 52.52,84.5 52.6,84.58 52.6,84.78 52.55,84.82 52.14,84.82 52.1,84.87 52.1,85.1 52.15,85.15 52.58,85.15 52.62,85.19 52.62,85.43 52.57,85.47 52.15,85.47 52.1,85.52 52.1,85.74 52.16,85.8 52.56,85.8 52.6,85.84 52.6,86.07 52.54,86.12 52.14,86.12 52.1,86.17 52.1,86.42 52.13,86.45 52.56,86.45 52.6,86.49 52.6,86.68 52.52,86.76 52.21,86.76 52.15,86.82 52.15,86.99 52.19,87.03 52.55,87.03 52.6,87.08 52.6,87.41 52.86,87.67 52.86,87.88 52.99,88.01 52.99,90.54 ; v1(49.55,90.48) 49.47,90.4 49.47,89.56 50.04,88.99 50.17,88.99 50.5,89.31 50.61,89.31 51.1,88.83
  L7-SIG w0.081: 52.99,90.54 52.92,90.6 52.82,90.6 52.66,90.45 52,90.45 51.94,90.4 51.94,89.22 51.55,88.83 51.1,88.83
