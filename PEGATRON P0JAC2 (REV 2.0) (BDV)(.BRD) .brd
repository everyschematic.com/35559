# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_SIGNAL: length 28.4
  L5-SIG w0.152: v3(58.32,38.83) 58.31,38.83 58.04,38.56 58.04,38.14 58.31,37.86 58.31,37.32 v6(57.93,36.94)
  L5-SIG w0.203: v3(64.92,35.49) 64.82,35.39 64.01,35.39 63.37,34.76 62.1,34.76 61.91,34.95 v6(60.72,34.95) ; v6(60.67,34.1) 60.76,34.1 60.96,33.89 60.96,33.58 v6(60.72,33.34) 60.82,33.23 61.62,33.23 v3(62,32.85) ; v6(57.12,32.94) 55.13,32.94 55.07,32.88 54.56,32.88 v3(54.51,32.83)
  L5-SIG w0.508: v3(54.51,32.83) 54.51,30.71 53.01,29.21 53.01,26.9 53.65,26.26 54.61,26.26 57.08,23.79 57.08,21.96 v3(56.52,21.4)
  L6-GND w0.203: v6(56.71,36.54) 56.71,36.54 56.2,37.04 v3(55.8,37.04)
  L6-GND w0.254: v3(56.52,21.4) 56.27,21.4 v1(55.96,21.08)
V3.3_LVDS_AVDD:
  vias: v2(53.82,11.85) v2(54.46,11.85) v2(60.86,7.32) v2(60.86,6.64)
VBAT_SENSE_BUF: length 17.6
  L5-SIG w0.06: v6(59.52,34.54) 59.76,34.29 60,34.29 60.29,34 60.29,32.57 61.64,31.23
  L5-SIG w0.102: v3(73.38,31.89) 72.63,32.63 70.66,32.63 69.13,31.1 61.76,31.1 61.64,31.23
  L6-GND w0.102: v1(72.92,32.12) 73.15,32.12 v3(73.38,31.89)
VDD_3V3_EDID: length 7.4
  L7-SIG w0.254: v1(64.85,9.03) 64.54,9.33 63.91,9.33 v1(63.42,8.85) 63.25,8.67 v1(62.69,8.67) 60.96,8.67 60.16,7.87 v1(60.16,5.92)
VDD_WL_PA: length 19.6
  L5-SIG w1.016: 15.67,92.85 4.45,92.85
  BOTTOM w0.203: R5415.1 1.87,84 1.27,84.6 1.27,85.65 1.48,85.86 2.24,85.86 2.67,86.29 R5418.1 3.22,86.29 3.43,86.5 3.43,88.68 3.23,88.88 R5424.2
  vias: v1(2.64,93.02) v1(2.64,92.72) v1(2.95,93.03) v1(2.95,92.72) v1(16.1,91.81) v1(16.1,91.48) v1(16.46,91.81) v1(16.49,91.48) v3(2.82,93.46) v3(3.4,92.85) v3(16.02,91.02) v3(16.58,91.02) v4(2.64,93.02) v4(2.64,92.72) v4(2.95,93.03) v4(2.95,92.72) v4(16.1,91.81) v4(16.1,91.48) v4(16.46,91.81) v4(16.49,91.48) v9(3.02,93.53)
42_M0_CA0: length 44.3
  L2-SIG w0.081: v8(58.83,76.08) 58.62,75.87 58.62,75.6 58.73,75.49 59.15,75.49 59.32,75.66 59.32,75.96 59.43,76.07 59.59,76.07 59.7,75.96 59.7,75.55 59.78,75.47 59.93,75.47 60.03,75.58 60.03,75.97 60.16,76.1 60.78,76.1 65.28,80.61 65.28,89.66 68.17,92.55 68.17,93.71 68.44,93.98 68.44,94.35 68.31,94.48 68.12,94.48 67.93,94.28 67.93,93.88 67.87,93.82 v8(67.4,93.82) 67.65,94.07 67.65,94.48 68.43,95.25 68.43,97.53 68.39,97.56 68.39,98.01 68.46,98.07 68.46,99.34 v8(67.41,100.39)
  L3-GND w0.06: v8(58.83,76.08) 58.81,76.1 v3(58.47,76.1)
  L3-GND w0.076: v8(67.4,93.82) v3(67.4,94.19)
  L3-GND w0.102: v3(67.29,100.75) 67.41,100.62 v8(67.41,100.39)
  L6-GND w0.06: v6(58.26,76.4) 58.47,76.19 v3(58.47,76.1)
  L6-GND w0.076: v4(67.4,94.58) v3(67.4,94.19)
  L6-GND w0.102: v3(67.29,100.75) 67.18,100.85 v1(67.18,101.11)
  L7-SIG w0.076: v1(68.86,92.95) 69.24,92.95 69.33,93.03 69.33,93.16 69.24,93.24 68.72,93.24 68.61,93.34 68.61,94.07 68.45,94.24 68.17,94.24 68.01,94.39 67.65,94.39 67.47,94.58 v4(67.4,94.58) 67.35,94.63 67.35,95.35 67.39,95.4 67.39,95.74 67.91,96.26 67.91,96.73 67.82,96.82 67.82,96.82 67.79,96.85 67.79,96.98 67.79,97.11 67.42,97.48 v1(67.36,97.48)
  BOTTOM w0.203: v1(67.36,97.48) 67.59,97.28
42_M0_CA1: length 48
  L2-SIG w0.081: v8(63.37,100.42) 64.85,98.94 67.11,98.94 67.44,98.61 67.44,97.53 67.78,97.18 67.78,95.81 67.57,95.6 66.24,95.6 v8(66.24,95.6) 66.04,95.4 65.72,95.4 65.22,94.9 64.9,94.9 64.54,94.55 63.68,94.55 62.11,92.98 62.11,87.7 60.78,86.36 58.5,86.36 58.24,86.1 58.24,82.11 58.55,81.8 58.55,80.64 58.92,80.26 59.22,80.26 59.34,80.14 59.34,79.39 58.8,78.85 58.8,78.63 58.65,78.48 58.43,78.48 58.33,78.38 58.23,78.38 58.1,78.5 58.1,79.35 58,79.45 57.85,79.45 57.74,79.35 57.74,77.88 57.84,77.78 57.98,77.78 58.07,77.87 58.07,77.94 58.12,77.99 58.29,77.99 58.38,77.89 58.38,77.63 58.15,77.4 v8(58.06,77.4)
  L3-GND w0.06: v8(58.06,77.4) 58.06,76.98 v3(58.11,76.94)
  L3-GND w0.076: v8(66.24,95.6) 66.27,95.63 v3(66.6,95.63)
  L3-GND w0.102: v8(63.37,100.42) v3(63.37,100.77)
  L6-GND w0.06: v3(58.11,76.94) 58.11,76.79 v6(57.93,76.61)
  L6-GND w0.076: v3(66.6,95.63) v4(66.96,95.48)
  L6-GND w0.102: v3(63.37,100.77) 63.55,100.95 v1(63.55,101.11)
  L7-SIG w0.076: v1(68.36,92.98) 68.36,93.09 68.12,93.34 68.12,93.57 67.96,93.72 67.22,93.72 66.6,94.34 66.6,94.64 66.69,94.73 66.69,94.87 66.96,95.14 v4(66.96,95.48) 66.75,95.48 66.51,95.24 66.39,95.24 66.32,95.31 66.32,95.43 66.64,95.76 66.98,95.76 67.01,95.79 67.13,95.91 67.13,96.12 67.21,96.2 67.42,96.2 67.6,96.38 67.6,96.59 67.49,96.71 67.15,96.71 67.1,96.76 67.1,96.87 67.21,96.98 v1(67.36,96.98)
42_M0_CA2: length 45.1
  L2-SIG w0.081: v8(65.76,100.37) 65.76,99.7 65.91,99.55 67.21,99.55 67.97,98.79 67.97,97.45 68.11,97.31 68.11,95.47 v8(66.32,93.68) 66.32,93.45 66.42,93.35 66.73,93.35 66.86,93.22 66.86,93.05 66.73,92.93 66.66,92.93 66.55,92.82 66.55,92.67 66.66,92.56 66.79,92.56 66.83,92.51 66.83,92.24 66.79,92.19 66.41,92.19 66.34,92.12 66.34,91.92 66.4,91.86 66.54,91.86 66.63,91.77 66.63,91.64 66.54,91.55 66.31,91.55 66.18,91.42 66.18,91.3 66.01,91.13 65.89,91.13 65.82,91.21 65.7,91.21 65.53,91.03 65.53,90.92 65.61,90.84 65.61,90.73 65.43,90.55 65.3,90.55 65.24,90.61 64.73,90.61 64.62,90.51 64.62,90.36 64.73,90.26 64.87,90.26 64.97,90.16 64.97,90.02 64.87,89.92 64.73,89.92 64.6,89.79 64.6,89.55 64.68,89.47 64.73,89.47 64.82,89.39 64.82,89.14 64.73,89.06 64.68,89.06 64.6,88.98 64.6,88.74 64.68,88.66 64.73,88.66 64.82,88.57 64.82,88.33 64.73,88.25 64.68,88.25 64.6,88.17 64.6,87.92 64.68,87.84 64.73,87.84 64.82,87.76 64.82,87.52 64.73,87.44 64.68,87.44 64.6,87.35 64.6,87.11 64.68,87.03 64.73,87.03 64.82,86.95 64.82,86.7 64.73,86.62 64.68,86.62 64.6,86.54 64.6,86.3 64.68,86.22 64.73,86.22 64.82,86.14 64.82,85.89 64.73,85.81 64.68,85.81 64.6,85.73 64.6,85.49 64.68,85.4 64.73,85.4 64.82,85.32 64.82,85.08 64.73,85 64.68,85 64.6,84.92 64.6,84.67 64.68,84.59 64.73,84.59 64.82,84.51 64.82,84.27 64.73,84.18 64.68,84.18 64.6,84.1 64.6,83.86 64.68,83.78 64.73,83.78 64.82,83.7 64.82,83.45 64.73,83.37 64.68,83.37 64.6,83.29 64.6,83.05 64.68,82.97 64.73,82.97 64.82,82.88 64.82,82.64 64.73,82.56 64.68,82.56 64.6,82.48 64.6,82.23 64.68,82.15 64.73,82.15 64.82,82.07 64.82,81.83 64.73,81.75 64.68,81.75 64.6,81.67 64.6,81.42 64.73,81.29 64.73,80.71 63.78,79.77 62.17,78.15 61.14,77.12 61.06,77.12 60.86,77.33 60.71,77.33 60.66,77.28 60.66,76.67 60.58,76.59 60.38,76.59 60.29,76.68 60.29,77.16 60.19,77.26 v8(59.03,77.26)
  L3-GND w0.06: v3(58.55,77.28) 58.57,77.26 v8(59.03,77.26)
  L3-GND w0.076: v3(66.28,94.06) 66.28,93.72 v8(66.32,93.68)
  L3-GND w0.102: v8(65.76,100.37) 65.76,100.7 v3(65.74,100.72)
  L6-GND w0.06: v3(58.55,77.28) 58.55,76.74 v6(58.54,76.74)
  L6-GND w0.076: v4(66.29,94.42) 66.28,94.41 v3(66.28,94.06)
  L6-GND w0.102: v3(65.74,100.72) 65.71,100.75 v1(65.71,101.11)
  L7-SIG w0.076: v1(67.34,96.46) 67.23,96.46 67.01,96.24 66.77,96.24 66.6,96.08 66.6,95.93 66.07,95.39 66.07,94.65 v4(66.29,94.42) 66.14,94.27 66.14,94.12 66.3,93.96 66.48,93.96 66.56,94.04 66.67,94.04 66.78,93.94 66.78,93.83 66.73,93.77 66.73,93.67 67.16,93.23 67.77,93.23 67.86,93.13 v1(67.86,93.01)
42_M0_CA3: length 47.1
  L2-SIG w0.081: v8(62.48,100.36) 62.48,100.12 64.3,98.3 64.3,98.22 64.61,97.91 67.11,97.91 67.25,97.76 67.25,97.45 67.54,97.17 v8(67.54,95.91) 66.17,95.91 65.88,95.62 65.39,95.62 64.49,94.73 63.45,94.73 61.88,93.15 61.88,88.38 61.6,88.1 61.6,87.99 61.71,87.87 61.71,87.76 61.6,87.64 61.48,87.64 61.37,87.76 61.25,87.76 61.14,87.64 61.14,87.53 61.25,87.41 61.25,87.3 61.14,87.18 61.02,87.18 60.91,87.3 60.79,87.3 60.68,87.18 60.68,87.07 60.79,86.95 60.79,86.84 60.68,86.72 60.56,86.72 60.45,86.84 60.33,86.84 60.1,86.61 58.09,86.61 57.99,86.51 57.99,81.64 58.08,81.56 58.22,81.56 58.3,81.48 58.3,81.23 58.22,81.15 58.08,81.15 57.99,81.07 57.99,80.91 58.08,80.83 58.23,80.83 58.31,80.75 58.31,80.63 58.23,80.54 58.1,80.54 57.99,80.44 57.99,80.27 58.07,80.2 58.3,80.2 58.38,80.12 58.38,79.79 58.45,79.72 58.64,79.72 58.71,79.79 58.71,79.95 58.78,80.02 59.02,80.02 59.08,79.96 59.08,79.39 58.89,79.2 58.49,79.2 58.32,79.03 58.32,78.96 v8(58.54,78.75)
  L3-GND w0.06: v8(58.54,78.75) 58.51,78.72 v3(58.18,78.72)
  L3-GND w0.076: v3(67.94,96.07) 67.7,96.07 v8(67.54,95.91)
  L3-GND w0.102: v8(62.48,100.36) 62.56,100.44 v3(62.56,100.77)
  L6-GND w0.06: v3(58.18,78.72) 58.18,78.44 v5(58.24,78.38)
  L6-GND w0.076: v4(68.3,96.28) 68.1,96.28 67.94,96.12 v3(67.94,96.07)
  L6-GND w0.102: v1(62.81,101.11) 62.56,100.86 v3(62.56,100.77)
  L7-SIG w0.06: v5(58.24,78.38) 58.52,78.1 v6(58.52,77.81)
  L7-SIG w0.076: v1(66.86,97.48) 66.86,97.56 66.8,97.62 66.6,97.62 66.52,97.71 66.52,97.84 66.6,97.93 67.51,97.93 68.1,97.34 68.1,96.98 68.12,96.95 68.12,96.95 68.21,96.86 68.21,96.36 v4(68.3,96.28) 68.3,96.2 68.12,96.02 68.12,95.38 68.27,95.24 68.67,95.24 69.1,94.8 69.1,93.72 v1(68.86,93.48)
  BOTTOM w0.203: v1(66.86,97.48) 67.09,97.28
42_M0_CA4: length 46.7
  L2-SIG w0.081: v8(57.15,76.33) 57.14,76.32 57.14,75.85 57.3,75.7 57.46,75.7 57.56,75.79 57.56,76.12 57.65,76.22 57.79,76.22 57.89,76.12 57.89,76.03 58.02,75.89 58.29,75.89 58.36,75.97 58.36,76.24 58.51,76.39 60.73,76.39 63.94,79.59 63.94,79.59 64.75,80.41 65.05,80.71 65.05,89.74 67.06,91.75 67.06,92.1 67.16,92.2 67.46,92.2 68.01,92.75 68.01,93.2 67.84,93.37 67.57,93.37 67.45,93.25 67.45,92.64 67.34,92.53 67.19,92.53 67.08,92.64 67.08,93.59 66.98,93.69 v8(66.84,93.69) 66.84,93.89 68.27,95.32 68.27,97.43 68.23,97.48 68.23,98.87 67.24,99.86 66.55,99.86 66.45,99.96 v8(66.45,100.31)
  L3-GND w0.06: v3(56.84,76.07) 56.89,76.07 v8(57.15,76.33)
  L3-GND w0.076: v8(66.84,93.69) 66.84,93.69 v3(66.84,94.07)
  L3-GND w0.102: v8(66.45,100.31) v3(66.45,100.7)
  L6-GND w0.06: v6(57.39,76.11) 57.34,76.07 v3(56.84,76.07)
  L6-GND w0.076: v4(66.84,94.44) v3(66.84,94.07)
  L6-GND w0.102: v1(66.45,101.11) v3(66.45,100.7)
  L7-SIG w0.076: v1(66.86,96.98) 66.99,96.98 67.23,97.22 67.46,97.22 67.64,97.05 67.64,97.04 67.64,96.78 67.76,96.67 67.76,96.32 67.24,95.8 67.24,95.46 67.19,95.42 67.19,95.11 66.84,94.76 v4(66.84,94.44) 66.99,94.59 67.09,94.59 67.12,94.55 67.12,94.33 67.03,94.24 67.03,94.13 67.29,93.88 67.57,93.88 67.62,93.92 67.62,94.01 67.57,94.06 67.43,94.06 67.36,94.13 67.36,94.21 67.44,94.29 67.54,94.29 67.59,94.24 67.95,94.24 68.1,94.08 68.1,93.9 68.26,93.74 68.4,93.74 68.46,93.68 68.46,93.51 68.38,93.43 v1(68.36,93.43)
42_M0_CA5: length 45.9
  L2-SIG w0.076: 64.06,98.21 64.06,97.9 64.22,97.75 66.43,97.75 67.1,97.08 67.1,96.8 v8(66.73,96.44)
  L2-SIG w0.081: 64.06,98.21 61.98,100.29 v8(61.9,100.29) ; v8(66.73,96.44) 66.73,96.69 66.65,96.78 64.8,96.78 64.6,96.58 64.6,96.43 64.81,96.22 64.81,96.07 64.72,95.97 64.47,95.97 64.3,96.15 64.13,96.15 64.04,96.05 64.04,95.31 63.9,95.17 63.16,95.17 61.41,93.42 61.41,89.05 61.28,88.92 61.16,88.92 61.09,89 60.97,89 60.86,88.88 60.86,88.77 60.96,88.67 60.96,88.53 60.84,88.41 60.75,88.41 60.63,88.54 60.51,88.54 60.4,88.42 60.4,88.31 60.47,88.23 60.47,88.12 60.36,88 60.24,88 60.17,88.08 60.05,88.08 59.94,87.96 59.94,87.85 60.01,87.77 60.01,87.66 59.9,87.54 59.78,87.54 59.71,87.62 59.59,87.62 59.48,87.5 59.48,87.39 59.55,87.31 59.55,87.2 59.45,87.09 59.19,87.09 59.1,87.17 59.1,87.54 59.01,87.64 58.87,87.64 58.78,87.54 58.78,87.17 58.7,87.09 57.59,87.09 57.5,86.99 57.5,77.52 57.67,77.35 v8(57.68,77.35)
  L3-GND w0.06: v8(57.68,77.35) 57.53,77.2 v3(57.53,76.97)
  L3-GND w0.076: v8(66.73,96.44) v3(67.11,96.44)
  L3-GND w0.102: v8(61.9,100.29) v3(61.9,100.7)
  L5-SIG w0.076: v1(65.36,96.98) 65.18,96.98 65.13,97.04 65.13,97.21 65.69,97.78 66.34,97.78 66.66,97.46 66.66,96.89 v3(67.11,96.44) 67.35,96.2 67.35,95.63 67.73,95.24 68.08,95.24 68.45,95.61 68.62,95.61 68.72,95.51 68.72,95.35 68.36,95 v1(68.36,94.98)
  L6-GND w0.06: v3(57.53,76.97) 57.53,76.75 v6(57.41,76.63)
  L6-GND w0.102: v1(62.08,101.11) 62.08,100.87 v3(61.9,100.7)
42_M0_CA6: length 45.9
  L2-SIG w0.081: v8(64.26,100.34) 65.41,99.2 67.21,99.2 67.69,98.71 67.69,97.5 67.95,97.24 67.95,95.75 67.64,95.44 66.91,95.44 v8(66.52,95.05) 66.6,94.97 67.09,94.97 67.14,94.92 67.14,94.77 66.85,94.48 66.25,94.48 66.06,94.29 66.06,93.15 66.12,93.09 66.29,93.09 66.35,93.03 66.35,92.89 66.26,92.81 66.13,92.81 66.06,92.73 66.06,92.02 65.95,91.91 65.95,91.78 66.05,91.69 66.05,91.6 65.97,91.52 65.85,91.52 65.76,91.61 65.65,91.61 64.95,90.92 64.51,90.92 64.37,90.77 64.37,80.69 63.84,80.16 63.7,80.02 61.83,78.15 61.22,77.53 58.59,77.53 58.45,77.39 58.45,77.12 58.58,76.99 59.44,76.99 59.54,76.89 59.54,76.75 59.44,76.64 58.32,76.64 58.19,76.77 58.19,76.85 58.06,76.98 57.36,76.98 57.27,76.89 57.27,76.65 57.33,76.59 57.93,76.59 v8(58.1,76.42)
  L3-GND w0.06: v3(57.9,76.12) 57.9,76.22 v8(58.1,76.42)
  L3-GND w0.076: v3(66.09,95.17) 66.21,95.05 v8(66.52,95.05)
  L3-GND w0.102: v8(64.26,100.34) v3(64.26,100.75)
  L5-SIG w0.076: v1(67.85,94.98) 67.85,94.73 67.77,94.65 67.54,94.65 67.46,94.73 67.46,95.05 67.22,95.29 66.56,95.29 66.53,95.26 66.18,95.26 v3(66.09,95.17)
  L6-GND w0.06: v3(57.9,76.12) 57.67,76.36 v6(57.67,76.4)
  L6-GND w0.076: v3(66.09,95.17) 66.03,95.11 65.36,95.11 v4(65.34,95.14)
  L6-GND w0.102: v1(64.26,101.11) v3(64.26,100.75)
  L7-SIG w0.076: v4(65.34,95.14) 65.1,95.37 65.1,96.33 65.2,96.43 v1(65.38,96.43)
42_M0_CA7: length 41.7
  L2-SIG w0.081: v8(67.01,97.66) 67.01,97.47 67.26,97.22 67.26,96.61 66.84,96.19 66.46,96.19 66.4,96.26 65.77,96.26 64.42,94.9 63.22,94.9 61.64,93.33 61.64,88.86 60.87,88.09 60.87,87.97 60.93,87.91 60.93,87.8 60.82,87.68 60.7,87.68 60.64,87.74 60.53,87.74 60.41,87.62 60.41,87.51 60.47,87.45 60.47,87.34 60.36,87.22 60.24,87.22 60.18,87.28 60.07,87.28 59.63,86.84 57.85,86.84 57.75,86.74 57.75,80.03 58.32,79.46 v8(58.77,79.46)
  L3-GND w0.06: v8(58.77,79.46) 58.54,79.23 v3(58.5,79.23)
  L3-GND w0.076: v8(67.01,97.66) 66.91,97.76 v3(66.91,98.03)
  L5-SIG w0.16: v3(66.91,98.03) 66.91,98.28 65,100.19 v3(65,100.72)
  L6-GND w0.06: v5(58.59,78.9) 58.5,78.99 v3(58.5,79.23)
  L6-GND w0.102: v1(64.97,101.11) 64.97,100.75 v3(65,100.72) ; v3(66.91,98.03) 66.95,98.07 66.95,98.33 v4(67.01,98.39)
  L7-SIG w0.06: v5(58.59,78.9) 58.57,78.88 v6(58.57,78.36)
  L7-SIG w0.076: 68.52,98.21 68.63,98.09 68.62,98.08 68.62,97.88 68.76,97.74 68.95,97.74 69.1,97.58 69.1,95.72 v1(68.86,95.48)
  L7-SIG w0.081: v1(64.86,97.48) 65.33,97.95 65.33,98.91 65.44,99.02 66.06,99.02 66.14,98.94 66.14,98.57 66.23,98.49 66.39,98.49 66.47,98.57 66.47,98.94 66.55,99.02 66.88,99.02 67.01,98.89 v4(67.01,98.39) 67.01,98.39 67.01,98.38 67.26,98.62 68.06,98.62 68.17,98.51 68.22,98.51 68.52,98.21
42_M0_CA8: length 40.5
  L2-SIG w0.081: v8(57.98,75.25) 60.26,75.25 65.52,80.51 65.52,89.65 68.33,92.46 68.33,93.54 68.64,93.85 v8(68.64,97.65)
  L3-GND w0.06: v3(57.66,75.43) 57.84,75.25 v8(57.98,75.25)
  L3-GND w0.076: 68.56,98.21 68.56,98.11 68.64,98.03 v8(68.64,97.65)
  L3-GND w0.102: v3(68.57,98.39) 68.56,98.37 68.56,98.21
  L5-SIG w0.16: v3(68.57,98.39) 67.97,98.99 v3(67.97,100.64)
  L6-GND w0.06: v6(57.62,75.77) 57.62,75.47 v3(57.66,75.43)
  L6-GND w0.102: v4(67.73,98.32) 67.8,98.39 v3(68.57,98.39) ; v3(67.97,100.64) 67.89,100.72 v1(67.89,101.11)
  L7-SIG w0.076: v1(64.86,96.98) 65.62,97.74 65.76,97.74 65.76,97.74 65.96,97.74 66.08,97.74 66.44,98.09 67.1,98.09 67.21,98.21 ; 68.1,98.07 68.1,97.9 68.28,97.72 68.46,97.72 68.62,97.57 68.62,95.74 v1(68.36,95.48)
  L7-SIG w0.081: 67.21,98.21 67.33,98.32 v4(67.73,98.32) 67.85,98.32 68.1,98.07
42_M0_CA9: length 41.4
  L2-SIG w0.081: v8(57.13,77.84) 57.23,77.94 57.23,87.15 57.97,87.89 59.49,87.89 59.6,88.01 59.6,88.12 59.37,88.35 59.37,88.47 59.49,88.58 59.6,88.58 59.83,88.35 59.95,88.35 60.06,88.47 60.06,88.58 59.84,88.81 59.84,88.93 59.95,89.04 60.07,89.04 60.29,88.81 60.41,88.81 60.78,89.19 60.78,93.13 64.64,96.98 v8(66.86,96.98)
  L3-GND w0.06: v3(57.2,77.43) 57.2,77.77 57.13,77.84 v8(57.13,77.84)
  L3-GND w0.076: v3(67.23,96.98) v8(66.86,96.98)
  L5-SIG w0.076: v1(64.86,96.48) 64.86,97.17 65.64,97.95 66.4,97.95 66.89,97.47 66.89,97.33 v3(67.23,96.98) 68.43,96.98 68.53,96.88 68.53,96.59 68.45,96.51 67.64,96.51 67.59,96.45 67.59,95.62 67.73,95.48 v1(67.86,95.48)
  L5-SIG w0.16: v3(68.53,100.57) 68.53,99.17 69.08,98.63 69.08,98.27 68.18,97.38 67.63,97.38 v3(67.23,96.98)
  L6-GND w0.06: v6(57.06,76.94) 57.2,77.08 v3(57.2,77.43)
  L6-GND w0.102: v3(68.53,100.57) 68.63,100.67 v1(68.63,101.11)
42_M0_CKE0: length 31
  L2-SIG w0.081: v8(64.97,94.4) 64.77,94.19 63.94,94.19 62.65,92.9 62.65,86.89 61.64,85.89 59.95,85.89 59.83,85.76 59.83,85.51 59.7,85.38 59.47,85.38 59.41,85.32 59.41,85.2 59.49,85.13 59.74,85.13 59.83,85.04 59.83,84.93 59.74,84.84 59.25,84.84 59.17,84.76 59.17,84.6 59.25,84.52 59.74,84.52 59.83,84.44 59.83,84.27 59.74,84.19 59.25,84.19 59.17,84.11 59.17,83.95 59.25,83.87 59.74,83.87 59.83,83.79 59.83,83.62 59.74,83.54 59.25,83.54 59.17,83.46 59.17,83.3 59.25,83.22 59.74,83.22 59.83,83.14 59.83,82.97 59.74,82.89 59.25,82.89 59.17,82.81 59.17,82.65 59.25,82.57 59.74,82.57 59.83,82.49 59.83,82.19 59.7,82.07 59.22,82.07 59.14,81.98 59.14,81.74 59.22,81.66 59.74,81.66 59.83,81.58 59.83,81.33 59.74,81.25 59.22,81.25 59.14,81.17 59.14,80.93 59.22,80.85 59.74,80.85 59.83,80.77 59.83,79.47 59.8,79.44 v8(59.8,79.25)
  L3-GND w0.06: v3(59.7,78.9) 59.7,79.16 v8(59.8,79.25)
  L3-GND w0.076: v8(64.97,94.4) 65.17,94.59 65.3,94.59 v3(65.32,94.61)
  L6-GND w0.06: v6(59.37,78.77) 59.57,78.77 v3(59.7,78.9)
  L6-GND w0.076: v3(65.32,94.61) 65.32,94.6 65.31,94.59 v4(64.94,94.59)
  L7-SIG w0.076: v4(64.94,94.59) 65.28,94.59 65.59,94.89 65.59,95.86 65.6,95.88 65.6,96.22 v1(66.36,96.98)
42_M0_CKE1: length 30.6
  L2-SIG w0.081: v8(61.62,79.05) 61.66,79.02 62.11,79.02 62.31,79.22 62.31,82.16 62.41,82.26 62.67,82.26 62.72,82.21 62.72,80.92 62.79,80.85 63.02,80.85 63.13,80.96 63.13,82.15 63.23,82.25 63.38,82.25 63.48,82.15 63.48,80.87 63.53,80.83 63.78,80.83 63.9,80.95 63.9,91.61 64.09,91.8 64.6,91.8 64.68,91.88 64.68,92.06 64.58,92.16 64.58,92.29 64.85,92.57 64.85,92.77 64.75,92.87 64.75,93.02 64.83,93.1 65.19,93.1 65.25,93.17 65.25,93.85 65.36,93.96 65.52,93.96 65.63,93.85 65.63,92.68 65.51,92.56 v8(65.35,92.56)
  L3-GND w0.06: v8(61.62,79.05) 61.29,79.05 v3(61.27,79.08)
  L3-GND w0.076: v8(65.35,92.56) 65.35,92.65 65.36,92.66 v3(65.36,92.93)
  L5-SIG w0.076: v3(65.36,92.93) 65.36,92.99 65.7,93.34 67.36,93.34 67.77,93.74 68.11,93.74 68.35,93.98 v1(68.36,93.98)
  L6-GND w0.06: v6(60.74,78.42) 60.74,78.66 61.16,79.08 v3(61.27,79.08)
42_M0_CKE2: length 30.9
  L2-SIG w0.081: v8(59.48,77.88) 59.34,77.73 59.18,77.73 59.13,77.78 v3(59.13,77.96) 59.05,78.04 58.93,78.04 58.78,77.89 58.71,77.89 58.57,78.03 58.57,78.14 58.95,78.52 59.06,78.52 59.32,78.26 59.58,78.26 60.08,78.76 60.08,79.31 60.08,79.31 60.08,85.37 60.37,85.65 61.39,85.65 61.52,85.52 61.52,85.41 61.65,85.28 62.14,85.28 62.25,85.39 62.25,85.55 62.18,85.61 61.99,85.61 61.93,85.67 61.93,85.82 62.28,86.17 62.44,86.17 62.56,86.06 62.56,84.86 62.68,84.75 62.84,84.75 62.95,84.86 62.95,92.74 63.95,93.74 64.82,93.74 v8(65,93.91)
  L3-GND w0.06: v8(59.48,77.88) 59.4,77.96 v3(59.13,77.96)
  L3-GND w0.076: v8(65,93.91) 65.21,93.91 v3(65.34,94.05)
  L6-GND w0.06: v6(58.8,78.1) 58.93,77.96 v3(59.13,77.96)
  L6-GND w0.076: v3(65.34,94.05) v4(64.96,94.05)
  L7-SIG w0.076: v4(64.96,94.05) 65.76,94.85 65.76,96.17 66.08,96.48 v1(66.36,96.48)
42_M0_CKE3: length 30.9
  L2-SIG w0.081: v8(60.91,79.38) 60.91,79.11 60.97,79.05 61.21,79.05 61.27,79.11 61.27,79.28 61.37,79.38 62,79.38 62.04,79.43 62.04,79.61 61.99,79.66 60.9,79.66 60.81,79.75 60.81,79.96 60.9,80.04 61.91,80.04 62.04,80.17 62.04,80.32 61.91,80.45 60.91,80.45 60.81,80.55 60.81,80.76 60.91,80.86 61.91,80.86 62.04,80.98 62.04,81.14 61.99,81.18 61.91,81.26 60.94,81.26 60.81,81.39 60.81,81.54 60.94,81.67 61.94,81.67 62.06,81.79 62.06,81.96 61.94,82.08 60.94,82.08 60.81,82.2 60.81,82.37 60.94,82.49 63.54,82.49 63.67,82.62 63.67,91.66 64.51,92.51 64.51,93.36 64.67,93.52 64.87,93.52 v8(64.98,93.4)
  L3-GND w0.06: v3(60.65,79.12) v8(60.91,79.38)
  L3-GND w0.076: v3(65.35,93.49) 65.26,93.4 v8(64.98,93.4)
  L5-SIG w0.076: v3(65.35,93.49) 65.37,93.51 67.25,93.51 67.71,93.98 v1(67.86,93.98)
  L6-GND w0.06: v6(60.5,78.74) 60.65,78.89 v3(60.65,79.12)
42_M0_CS0_N: length 34.3
  L2-SIG w0.081: v8(59.32,78.64) 59.53,78.85 59.53,79.63 59.59,79.69 59.59,80.22 59.25,80.55 59.09,80.55 58.88,80.76 58.88,82 58.82,82.07 58.8,82.08 58.72,82.08 58.6,82.2 58.6,82.37 58.72,82.49 58.8,82.49 58.88,82.57 58.88,82.82 58.8,82.9 58.6,82.9 58.52,82.98 58.52,83.22 58.6,83.3 58.8,83.3 58.88,83.38 58.88,83.63 58.8,83.71 58.57,83.71 58.49,83.79 58.49,84.03 58.57,84.12 58.8,84.12 58.88,84.2 58.88,84.44 58.8,84.52 58.57,84.52 58.49,84.6 58.49,84.85 58.57,84.93 58.8,84.93 58.88,85.01 58.88,85.25 58.8,85.33 58.65,85.33 58.58,85.4 58.58,85.68 58.65,85.74 58.8,85.74 58.88,85.82 58.88,85.94 58.98,86.04 59.13,86.04 59.23,85.94 59.23,85.72 59.32,85.63 59.45,85.63 59.55,85.72 59.55,86 59.67,86.13 61.54,86.13 61.64,86.23 61.64,86.35 61.49,86.5 61.49,86.62 61.6,86.73 61.72,86.73 61.81,86.64 62.05,86.64 62.39,86.98 62.39,92.95 63.82,94.37 64.59,94.37 64.95,94.73 65.46,94.73 v8(65.67,94.94)
  L3-GND w0.06: v8(59.32,78.64) 59.53,78.43 v3(59.53,78.35)
  L3-GND w0.076: v3(65.89,94.65) 65.67,94.86 v8(65.67,94.94)
  L6-GND w0.06: v3(59.53,78.35) 59.18,78.35 v6(59.12,78.42)
  L6-GND w0.076: v4(65.87,94.29) 65.89,94.3 v3(65.89,94.65)
  L7-SIG w0.076: v1(66.91,96.49) 66.78,96.61 66.66,96.61 66.6,96.56 66.6,96.38 66.58,96.36 66.58,96.36 66.47,96.24 66.13,96.24 65.91,96.02 65.91,94.76 65.59,94.44 65.59,94.34 65.64,94.29 v4(65.87,94.29) 65.87,94.1 66.46,93.52 66.59,93.52 67.12,92.99 67.12,92.88 67.26,92.74 67.94,92.74 68.1,92.91 68.1,93.13 67.86,93.37 v1(67.86,93.48)
42_M0_CS2_N: length 35.3
  L2-SIG w0.081: v8(61.68,78.54) 61.68,78.64 61.82,78.79 62.14,78.79 62.51,79.16 62.51,79.36 62.61,79.46 62.76,79.46 62.84,79.54 62.84,79.61 62.76,79.69 62.66,79.69 62.59,79.76 62.59,79.92 62.64,79.97 63.25,79.97 63.33,80.06 63.33,80.18 63.25,80.27 62.74,80.27 62.65,80.37 62.65,80.51 62.74,80.61 63.96,80.61 64.13,80.78 64.13,91.42 64.27,91.56 64.38,91.56 64.51,91.43 64.51,91.2 64.56,91.15 64.83,91.15 64.9,91.22 64.9,92.21 65,92.31 65.14,92.31 65.25,92.21 65.25,91.84 65.35,91.73 65.5,91.73 65.61,91.84 65.61,92.23 65.84,92.47 65.84,94.05 65.71,94.17 65.34,94.17 65.23,94.29 65.23,94.44 65.34,94.56 65.87,94.56 66.04,94.73 v8(66.67,94.73)
  L3-GND w0.06: v8(61.68,78.54) 61.48,78.35 v3(61.37,78.35)
  L3-GND w0.076: v3(67.09,94.94) 66.88,94.94 v8(66.67,94.73)
  L6-GND w0.06: v6(61.06,78.11) 61.31,78.35 v3(61.37,78.35)
  L6-GND w0.076: v3(67.09,94.94) 67.29,95.13 67.46,95.13 v4(67.59,95.25)
  L7-SIG w0.076: v1(68.86,93.98) 68.94,94.06 68.94,94.12 68.85,94.21 68.72,94.21 68.62,94.3 68.62,94.58 68.76,94.72 68.81,94.72 68.83,94.75 68.83,94.86 68.71,94.98 68.66,94.98 68.6,94.93 68.6,94.88 68.46,94.74 68.27,94.74 68.08,94.55 67.71,94.55 67.65,94.61 67.65,94.7 67.69,94.74 67.95,94.74 68.11,94.9 68.11,95.16 68.03,95.24 67.61,95.24 v4(67.59,95.25) 67.54,95.3 67.54,95.67 68.06,96.19 68.06,96.8 67.97,96.89 67.95,96.91 67.95,97.24 67.46,97.72 67.26,97.72 67.12,97.58 67.12,97.4 66.96,97.24 66.6,97.24 v1(66.36,97.48)
  BOTTOM w0.203: v1(66.36,97.48) 66.59,97.28
42_M0_DATA0: length 34.1
  L5-SIG w0.109: 69.54,92.04 67.89,92.04 v1(67.86,92.01)
  L5-SIG w0.127: v6(59.37,74.03) 59.55,73.85 64.34,73.85 64.45,73.73 67.81,73.73 68.04,73.96 68.04,74.2 68.27,74.43 68.51,74.43 68.76,74.68 68.76,74.92 68.99,75.15 69.23,75.15 69.47,75.4 69.47,75.64 69.71,75.87 69.95,75.87 70.19,76.11 70.19,76.35 70.43,76.59 70.67,76.59 70.91,76.83 70.91,77.07 71.15,77.31 71.39,77.31 71.58,77.5 71.58,77.74 71.75,77.92 71.99,77.92 72.16,78.08 72.16,88.81 71.99,88.97 71.99,89.18 72.16,89.35 72.16,89.6 72.03,89.73 71.91,89.73 71.59,89.4 71.43,89.4 71.33,89.51 71.33,89.66 71.65,89.99 71.65,90.1 71.48,90.28 71.37,90.28 71.23,90.14 71.05,90.14 70.9,90.29 70.9,90.47 71,90.58 71,90.76 69.72,92.04 69.54,92.04
42_M0_DATA1: length 34.2
  L5-SIG w0.076: v6(58.3,75.3) 58.28,75.32
  L5-SIG w0.081: 58.28,75.32 58.28,75.66 58.2,75.73 58.07,75.73 58,75.66 58,75.22 57.66,74.88 57.66,74.36 57.92,74.1 58.02,74.1 58.12,74.2 58.12,74.28 58.01,74.39 58.01,74.75 58.15,74.88 58.36,74.88 58.43,74.81 58.61,74.81 58.61,74.81 58.62,74.81 58.72,74.92 58.9,74.92 58.96,74.85 59.2,74.85 59.28,74.94 59.34,74.94 59.34,74.94
  L5-SIG w0.109: v1(67.36,90.48) 67.52,90.64 68.28,90.64 68.36,90.56 68.36,90.33 68.51,90.18 68.68,90.18 68.7,90.16 68.73,90.16 69.76,89.13 69.76,88.37 69.84,88.28 69.96,88.28 70.05,88.37 70.05,88.53 70.13,88.61 70.27,88.61 70.36,88.52 70.36,88.1 70.15,87.89 69.82,87.89 69.8,87.87 ; 66.38,75.75 66.26,75.63 65.67,75.63 65.36,75.32 64.25,75.32 64.17,75.24 64.17,75.06 64.06,74.95 63.87,74.95 63.76,75.06 63.76,75.27 63.69,75.34 62.9,75.34 62.77,75.21 62.49,74.93 61.81,74.93 61.63,75.11 61.45,75.11 61.27,74.94 61.07,74.94 60.91,75.1 60.7,75.1 60.64,75.04 60.64,74.91 60.58,74.85 60.27,74.85 60.18,74.94 59.34,74.94
  L5-SIG w0.127: 69.8,87.87 69.67,87.74 69.67,81.24 69.87,81.04 69.87,80.79 69.67,80.59 69.67,79.51 69.76,79.42 70.09,79.42 70.21,79.29 70.21,79.06 70.1,78.95 69.63,78.95 67.98,77.29 67.98,76.75 66.98,75.75 66.38,75.75
42_M0_DATA2: length 34.1
  L5-SIG w0.06: 60.79,75.47 60.64,75.47 60.37,75.21 59.45,75.21 59.43,75.22 59.43,75.22 59.17,75.48 v6(59.05,75.48)
  L5-SIG w0.076: v1(67.36,90.85) 67.3,90.91 67.17,90.91 67.09,90.84 67.09,90.74 67.04,90.69 66.76,90.69 66.57,90.87 66.53,90.87 66.43,90.97 66.36,90.97 66.31,90.91 66.31,90.34 66.71,89.95 67.17,89.95
  L5-SIG w0.109: 60.79,75.47 61.87,75.47 62.05,75.29 62.37,75.29 62.8,75.73 64.55,75.73 65.65,76.83 ; 67.17,89.95 68.39,88.73 68.39,88.09 68.4,88.07
  L5-SIG w0.127: 65.65,76.83 65.82,76.83 65.95,76.96 65.95,77.44 66.07,77.56 66.23,77.56 66.35,77.44 66.35,76.98 66.48,76.85 66.68,76.85 67,77.17 67,77.35 66.58,77.77 66.58,77.94 66.76,78.12 66.94,78.12 67.36,77.71 67.54,77.71 67.72,77.89 67.72,78.07 67.3,78.48 67.3,78.66 67.48,78.84 67.66,78.84 68.08,78.43 68.26,78.43 68.44,78.61 68.44,78.79 67.98,79.24 67.71,79.24 67.59,79.37 67.59,80.19 67.71,80.31 67.88,80.31 68,80.19 68,79.93 68.13,79.8 68.29,79.8 68.42,79.67 68.42,79.52 68.8,79.15 68.98,79.15 69.1,79.27 69.1,79.46 68.85,79.71 68.85,79.95 69.1,80.2 69.1,87.37 68.4,88.07
42_M0_DATA3: length 33.4
  L5-SIG w0.06: 60.22,74.42 59.96,74.42 59.82,74.56 59.56,74.56 59.43,74.43 59.29,74.43 59.18,74.31 59,74.31 58.83,74.48 v6(58.55,74.48)
  L5-SIG w0.109: 71.25,87.87 71.25,88.45 68.97,90.73 68.97,91.19 68.74,91.42 68.2,91.42 68.03,91.24 67.93,91.24 67.75,91.42 67.43,91.42 v1(67.36,91.49) ; 64.88,74.53 64.88,74.72 64.81,74.78 64.58,74.78 64.48,74.68 64.48,74.51 64.38,74.42 63.44,74.42 63.37,74.49 63.37,74.64 63.26,74.75 63.07,74.75 62.97,74.65 62.97,74.5 62.89,74.42 60.22,74.42
  L5-SIG w0.127: 64.88,74.53 65,74.41 65.17,74.41 65.29,74.53 65.29,74.66 65.41,74.77 65.57,74.77 65.68,74.66 65.68,74.52 65.8,74.41 65.96,74.41 66.08,74.52 66.08,74.65 66.2,74.77 66.8,74.77 66.98,74.59 67.2,74.59 68.99,76.38 68.99,76.92 69.28,77.22 69.65,77.22 69.73,77.3 69.73,77.66 70.04,77.97 70.58,77.97 71.25,78.64 71.25,79.84 71.09,79.99 71.09,80.36 71.25,80.51 71.25,81.31 71.06,81.5 71.06,81.8 71.25,82 71.25,82.6 70.98,82.87 70.98,83.12 71.25,83.39 71.25,84 70.99,84.25 70.99,84.53 71.25,84.79 71.25,85.39 71.04,85.6 71.04,85.98 71.25,86.19 71.25,86.79 70.94,87.1 70.94,87.27 71.25,87.58 71.25,87.87
42_M0_DATA4: length 33.7
  L5-SIG w0.109: 69.54,92.32 67.57,92.32 v1(67.37,92.12)
  L5-SIG w0.127: 69.54,92.32 69.83,92.32 72.44,89.72 72.44,77.96 67.93,73.45 64.38,73.45 64.19,73.64 59.16,73.64 v6(58.78,74.02)
42_M0_DATA5: length 35.2
  L5-SIG w0.06: v6(58.8,75.27) 58.85,75.32 58.93,75.32 58.97,75.28 59.2,75.28 59.38,75.1 59.38,75.1 59.4,75.09 60.46,75.09 60.65,75.28 60.88,75.28
  L5-SIG w0.076: v1(66.86,90.39) 66.86,90.45 66.79,90.52 66.71,90.52 66.64,90.58 66.56,90.58 66.46,90.49 66.46,90.41 66.76,90.12 66.82,90.12 67.03,90.12
  L5-SIG w0.109: 60.88,75.28 61.82,75.28 61.98,75.12 62.43,75.12 62.83,75.51 64.76,75.51 64.84,75.6 64.84,75.78 64.97,75.9 65.08,75.9 65.15,75.83 65.15,75.64 65.21,75.58 65.37,75.58 65.54,75.76 ; 69.3,88.34 69.01,88.34 68.93,88.25 68.93,88.18 68.84,88.08 68.7,88.08 68.61,88.18 68.61,88.56 68.79,88.74 69.23,88.74 69.47,88.99 69.47,89.14 69.19,89.42 69.04,89.42 68.58,88.96 68.46,88.96 68.31,89.11 68.31,89.19 68.79,89.67 68.79,89.83 68.65,89.97 68.49,89.97 68,89.49 67.9,89.49 67.7,89.7 67.7,89.8 68.07,90.16 68.07,90.29 67.95,90.41 67.83,90.41 67.52,90.1 67.37,90.1 67.24,90.23 67.14,90.23 67.03,90.12
  L5-SIG w0.127: 65.54,75.76 65.54,76.43 65.65,76.54 65.81,76.54 65.91,76.43 65.91,76.01 66.02,75.91 66.17,75.91 66.27,76.01 66.27,76.45 66.37,76.55 66.51,76.55 66.61,76.45 66.61,76.13 66.7,76.05 66.88,76.05 67.18,76.35 67.18,76.53 67.05,76.65 67.05,76.82 67.17,76.94 67.34,76.94 67.44,76.85 67.57,76.85 67.7,76.97 67.7,77.41 69.38,79.09 69.38,87.49 69.2,87.67 69.2,87.87 69.38,88.06 69.38,88.26 69.3,88.34
  BOTTOM w0.203: U1601.T6 66.64,90.69
42_M0_DATA6: length 33.8
  L5-SIG w0.06: 60.8,75.67 60.66,75.67 60.32,75.33 59.5,75.33 59.45,75.37 59.45,75.37 59.03,75.79 58.98,75.79 58.91,75.85 58.86,75.85 58.73,75.73 58.73,75.67 58.84,75.57 58.84,75.5 58.81,75.47 58.72,75.47 58.62,75.37 58.55,75.37 58.51,75.32 58.51,75.21 58.38,75.09 58.38,75.05 58.48,74.94 58.55,74.94 58.56,74.95 58.56,74.95 58.68,75.06 59.06,75.06 v6(59.07,75.07)
  L5-SIG w0.076: 67.08,89.71 66.99,89.8 66.64,89.8 66.16,90.28 66.16,91.1 66.23,91.17 66.45,91.17 66.59,91.02 66.77,91.02 66.86,90.93 v1(66.86,90.93)
  L5-SIG w0.109: 65.57,77.05 64.42,75.9 62.7,75.9 62.26,75.47 62.11,75.47 61.92,75.67 60.8,75.67 ; 68.29,87.79 68.23,87.85 68.23,87.95 68.08,88.1 68.08,88.33 68.2,88.44 68.2,88.64 68.06,88.78 67.98,88.78 67.86,88.66 67.86,88.65 67.75,88.55 67.68,88.55 67.47,88.76 67.47,88.86 67.7,89.09 67.7,89.15 67.51,89.34 67.45,89.34 67.24,89.14 67.1,89.14 66.99,89.24 66.99,89.37 67.14,89.52 67.14,89.64 67.08,89.71
  L5-SIG w0.127: 68.29,87.79 68.82,87.26 68.82,82.45 68.7,82.32 68.46,82.32 68.33,82.19 68.33,81.94 68.46,81.82 68.7,81.82 68.82,81.69 68.82,81.21 68.58,80.97 68.58,80.78 68.82,80.54 68.82,80.36 68.67,80.21 68.38,80.21 68.23,80.36 68.23,80.48 68.1,80.6 67.81,80.6 67.68,80.73 67.68,80.96 67.81,81.09 68.18,81.09 68.31,81.22 68.31,81.45 68.07,81.69 67.83,81.69 67.31,81.17 67.31,79.06 65.57,77.33 65.57,77.05
42_M0_DATA7: length 34
  L5-SIG w0.076: 68.13,91.6 68.12,91.59 67.61,91.59 67.47,91.73 67.02,91.73 v1(66.86,91.57)
  L5-SIG w0.109: 69.54,91.27 69.51,91.24 69.51,90.75 69.42,90.67 69.3,90.67 69.17,90.79 69.17,91.48 69.04,91.6 68.13,91.6
  L5-SIG w0.127: 69.54,91.27 69.58,91.31 69.66,91.31 69.81,91.16 69.81,90.99 69.89,90.92 70.05,90.92 70.34,90.63 70.34,90.38 70.14,90.17 70.14,89.97 71.53,88.58 71.53,87.47 71.31,87.25 71.31,87.13 71.53,86.91 71.53,86.07 71.32,85.86 71.32,85.72 71.53,85.51 71.53,84.67 71.33,84.48 71.33,84.31 71.53,84.11 71.53,83.28 71.33,83.07 71.33,82.92 71.53,82.71 71.53,81.88 71.37,81.72 71.37,81.58 71.53,81.42 71.53,80.4 71.37,80.24 71.37,80.11 71.53,79.95 71.53,78.48 70.61,77.56 70.43,77.56 70.3,77.69 70.15,77.69 70.01,77.55 70.01,77.42 70.17,77.27 70.17,77.12 69.9,76.85 69.69,76.85 69.6,76.94 69.4,76.94 69.27,76.81 69.27,76.66 69.38,76.54 69.38,76.33 67.36,74.31 66.86,74.31 66.68,74.49 66.4,74.49 66.13,74.22 59.79,74.22 v6(59.65,74.35)
42_M0_DATA8: length 31
  L7-SIG w0.06: 63.58,74.06 61.33,74.06 61.27,74.13 61.15,74.13 v6(61.14,74.13)
  L7-SIG w0.064: 63.58,74.06 64.59,75.07 69.89,75.07 70.34,75.52 70.34,75.59 70.18,75.75 69.97,75.75 69.83,75.89 69.83,75.98 70.05,76.2 70.19,76.2 70.31,76.08 70.42,76.08 70.57,76.22 70.57,76.33 70.46,76.44 70.46,76.61 70.61,76.76 70.77,76.76 71.04,76.5 71.29,76.5 72.13,77.33 72.13,77.62 71.93,77.81 71.93,78.05 72.13,78.25 72.13,79.06 72.21,79.14 72.21,87.82 71.57,88.46 71.48,88.46 71.45,88.48 71.29,88.48 71.08,88.7 71.08,88.9 70.7,89.28 70.58,89.28 70.5,89.19 70.38,89.19 70.27,89.31 70.27,89.42 70.35,89.51 70.35,89.63 70.23,89.75 69.85,89.75 69.27,90.33 69.27,90.8 69.16,90.9 69.16,91.09 68.86,91.39 v1(68.86,91.48)
  BOTTOM w0.203: v1(68.86,91.48) 68.64,91.69
42_M0_DATA9: length 30
  L7-SIG w0.06: v6(60.84,75.51) 60.91,75.59 62.48,75.59 62.92,76.03
  L7-SIG w0.064: 66.12,78.27 67.87,80.02 67.97,80.02 68.15,79.84 68.3,79.84 68.46,80 68.46,87.86 67.01,89.31 66.74,89.31 65.94,90.12 65.94,91.15 66.1,91.32 66.1,91.47 66.1,91.48 66.1,91.68 66.11,91.69 66.11,92.65 65.43,93.33 65.43,93.53 65.63,93.74 65.87,93.74 66.24,93.37 66.52,93.37 66.97,92.92 66.97,92.82 67.2,92.59 68.91,92.59 69.01,92.49 69.01,92.29 68.97,92.25 68.47,92.25 68.38,92.16 v1(68.38,92.01) ; 62.92,76.03 65.16,78.27
  L7-SIG w0.081: 65.16,78.27 66.12,78.27
42_M0_DATA10: length 30.3
  L7-SIG w0.06: 63.7,74.63 63.37,74.3 61.43,74.3 61.27,74.46 60.85,74.46 v6(60.81,74.42)
  L7-SIG w0.064: 68.86,90.23 71.13,87.96 71.23,87.96 71.68,87.51 71.68,79.5 71.59,79.41 71.15,79.41 71.07,79.33 71.07,79.11 71.18,79 71.58,79 71.67,78.91 71.67,78.69 71.55,78.57 71.12,78.57 71.04,78.5 71.04,78.39 71.17,78.27 71.17,78.11 71.06,78 71.06,77.82 71.43,77.45 71.43,77.36 71.28,77.22 71.21,77.22 70.82,77.6 70.67,77.6 69.17,76.1 69.17,75.99 68.76,75.57 67.99,75.57 67.91,75.66 67.91,75.72 67.83,75.8 67.67,75.8 67.59,75.72 67.59,75.66 67.5,75.57 67.34,75.57 67.26,75.66 67.26,75.75 67.21,75.8 67.03,75.8 66.94,75.71 66.94,75.66 66.85,75.57 66.7,75.57 66.61,75.67 66.61,75.74 66.55,75.8 66.37,75.8 66.29,75.72 66.29,75.57 66.19,75.47 66.04,75.47 65.96,75.55 65.96,75.72 65.88,75.8 65.72,75.8 65.64,75.72 65.64,75.66 65.55,75.57 65.39,75.57 65.31,75.66 65.31,75.72 65.23,75.8 65.07,75.8 64.98,75.72 64.98,75.66 64.9,75.57 64.64,75.57 63.7,74.63
  L7-SIG w0.081: 68.86,90.23 v1(68.86,90.48)
  BOTTOM w0.203: v1(68.86,90.48) 68.64,90.69
42_M0_DATA11: length 30.8
  L7-SIG w0.06: v6(61.17,75.27) 61.22,75.32 62.71,75.32
  L7-SIG w0.064: 62.71,75.32 65.15,77.76 65.26,77.76 65.34,77.68 65.34,77.54 65.42,77.45 65.58,77.45 65.67,77.54 65.67,77.68 65.75,77.76 65.91,77.76 65.99,77.68 65.99,77.53 66.07,77.45 66.22,77.45 66.35,77.58 66.35,77.71 67.41,78.78 68.05,78.78 68.51,79.23 68.84,79.23 68.92,79.31 68.92,79.68 69.15,79.91 69.15,83.09 69.22,83.17 69.39,83.17 69.46,83.24 69.46,83.46 69.38,83.54 69.25,83.54 69.16,83.63 69.16,83.79 69.25,83.87 69.38,83.87 69.46,83.95 69.46,84.11 69.46,84.12 69.38,84.19 69.25,84.19 69.16,84.28 69.16,84.44 69.25,84.52 69.38,84.52 69.46,84.6 69.46,84.76 69.38,84.84 69.25,84.84 69.16,84.93 69.16,85.09 69.25,85.17 69.38,85.17 69.46,85.25 69.46,85.41 69.38,85.49 69.16,85.49 69.06,85.59 69.06,85.72 69.16,85.82 69.38,85.82 69.46,85.9 69.46,86.06 69.38,86.15 69.13,86.15 69.04,86.24 69.04,86.37 69.13,86.47 69.38,86.47 69.46,86.55 69.46,87.36 69.38,87.45 69.25,87.45 69.16,87.53 69.16,87.69 69.25,87.77 69.38,87.77 69.46,87.85 69.46,88.21 69.39,88.27 69.19,88.27 69,88.47 69,88.67 68.81,88.86 68.68,88.86 68.48,88.66 68.33,88.66 68.17,88.81 68.17,88.93 68.41,89.17 68.41,89.28 68.3,89.4 68.18,89.4 67.94,89.16 67.83,89.16 67.24,89.74 66.76,89.74 66.62,89.88 66.62,90.83 66.62,91.04 66.8,91.22 66.94,91.22 67.11,91.39 67.11,91.64 67.22,91.75 67.95,91.75 68.12,91.58 68.12,91.23 v1(68.36,90.98)
42_M0_DATA12: length 29.8
  L7-SIG w0.06: v6(59.93,75.27) 60.19,75.27 60.39,75.47 60.58,75.47 60.75,75.31 60.92,75.31 61.08,75.47 62.62,75.47
  L7-SIG w0.064: 62.62,75.47 65.16,78.01 ; v1(68.36,91.48) 68.54,91.48 68.6,91.55 68.6,91.66 68.5,91.75 68.23,91.75 68.11,91.87 68.11,92.12 68.11,92.12 68.22,92.23 68.22,92.35 68.15,92.41 67.25,92.41 67.09,92.26 66.7,92.26 66.62,92.18 66.62,92.08 66.62,92.08 66.62,91.33 66.53,91.24 66.27,91.24 66.11,91.09 66.11,90.36 66.27,90.21 66.27,90.01 66.7,89.58 67.13,89.58 68.39,88.32 68.5,88.32 68.5,88.33 68.66,88.48 68.73,88.48 68.91,88.3 68.91,88.17 68.99,88.09 69.09,88.09 69.15,88.03 69.15,87.92 69.08,87.84 68.95,87.84 68.69,87.58 68.69,79.7 68.5,79.51 68.41,79.51 68.17,79.27 68.08,79.27 68.02,79.33 68.02,79.56 67.97,79.61 67.82,79.61 67.67,79.46 67.67,79.33 67.77,79.23 67.77,79.13 67.66,79.02 67.49,79.02 67.44,79.07 67.33,79.07 66.38,78.12
  L7-SIG w0.081: 65.16,78.01 66.27,78.01 66.38,78.12
42_M0_DATA13: length 30.5
  L7-SIG w0.06: v6(59.88,74.7) 59.96,74.62 60.34,74.62 60.44,74.52 60.58,74.52 60.7,74.64 61.28,74.64 61.5,74.42 63.21,74.42 63.45,74.66
  L7-SIG w0.064: 63.45,74.66 64.85,76.06 65.09,76.06 65.17,76.14 65.17,76.21 65.25,76.29 65.42,76.29 65.5,76.2 65.5,76.14 65.58,76.06 65.74,76.06 65.83,76.14 65.83,76.2 65.91,76.29 66.07,76.29 66.15,76.2 66.15,76.14 66.23,76.06 68.67,76.06 70.82,78.2 70.82,79.49 70.85,79.52 70.85,79.52 71.3,79.97 71.3,79.97 71.45,80.12 71.45,84.39 71.36,84.48 71.01,84.48 70.93,84.56 70.93,84.8 71.01,84.88 71.36,84.88 71.44,84.96 71.44,85.21 71.36,85.29 71.01,85.29 70.93,85.37 70.93,85.61 71.01,85.7 71.36,85.7 71.44,85.78 71.44,86.02 71.36,86.1 71.01,86.1 70.93,86.19 70.93,86.42 71.01,86.51 71.36,86.51 71.44,86.59 71.44,86.79 71.36,86.87 71.25,86.87 71.17,86.95 71.17,87.11 71.25,87.19 71.36,87.19 71.44,87.27 71.44,87.41 71.34,87.51 71.22,87.51 71.13,87.41 71.02,87.41 70.92,87.51 70.92,87.93 v1(68.36,90.48)
  BOTTOM w0.203: v1(68.36,90.48) 68.14,90.69
42_M0_DATA14: length 30.7
  L7-SIG w0.06: 64.09,74.77 63.5,74.18 61.38,74.18 61.22,74.34 61.02,74.34 60.89,74.21 60.72,74.21 60.54,74.39 60.24,74.39 v6(60.22,74.42) ; 66.38,75.32 64.64,75.32 64.34,75.02
  L7-SIG w0.064: v1(68.86,90.98) 69.11,90.73 69.11,90.23 71.02,88.33 71.35,88.33 71.59,88.08 71.59,88.08 71.96,87.72 71.96,79.21 71.9,79.15 71.9,78.36 71.85,78.32 71.55,78.32 71.47,78.23 71.47,77.92 71.78,77.61 71.78,77.34 71.26,76.82 71.08,76.82 70.95,76.94 70.95,77.1 70.85,77.2 70.7,77.2 69.4,75.89 69.4,75.68 69.46,75.62 69.79,75.62 69.89,75.52 69.89,75.42 69.78,75.32 69.28,75.32 69.13,75.47 68.97,75.47 68.82,75.32 66.38,75.32 ; 64.09,74.77 64.34,75.02
  BOTTOM w0.203: v1(68.86,90.98) 68.64,91.19
42_M0_DATA15: length 30.5
  L7-SIG w0.06: 66.24,74.78 64.59,74.78 63.74,73.93 61.05,73.93 60.91,74.07 60.7,74.07 60.6,73.97 60.36,73.97 60.2,74.13 v6(59.93,74.13)
  L7-SIG w0.064: 66.24,74.78 69.95,74.78 72.35,77.19 72.35,78.96 72.44,79.05 72.44,87.91 70.45,89.9 70,89.9 69.43,90.47 69.43,91.05 69.12,91.36 69.12,91.73 v1(68.86,91.98)
42_M0_DATA16: length 24
  L7-SIG w0.06: v6(60.22,76.12) 60.34,76.12 60.37,76.16 60.52,76.16 60.73,76.36 60.9,76.36 61.06,76.21 61.47,76.21 61.65,76.39
  L7-SIG w0.064: 64.34,89.47 65.55,88.25 65.73,88.25 66,87.98 66,87.37 66.04,87.33 66.14,87.33 66.35,87.54 66.47,87.54 66.55,87.46 66.55,87.31 66.24,87 66.24,86.65 66.75,86.14 66.75,85.46 66.83,85.37 67.04,85.37 67.12,85.29 67.12,85.21 67.02,85.11 66.47,85.11 66.32,84.96 66.32,82.46 66.37,82.41 66.6,82.41 66.73,82.53 67.03,82.53 67.12,82.45 67.12,81.18 65.32,79.38 65.25,79.38 64.55,79.38 63.81,78.65 63.81,78.09 62.11,76.39 61.65,76.39
  L7-SIG w0.076: 64.08,90.21 64.08,90.7 63.98,90.8 63.98,91.08 63.83,91.23 63.62,91.23 v1(63.36,91.48)
  L7-SIG w0.081: 64.34,89.47 64.34,89.95 64.08,90.21
42_M0_DATA17: length 25
  L7-SIG w0.06: v6(60.18,75.55) 60.26,75.63 60.62,75.63 60.71,75.72 62.36,75.72 62.54,75.9
  L7-SIG w0.064: 62.54,75.9 65.14,78.49 65.85,78.49 68.15,80.79 68.15,87.69 66.19,89.65 66.02,89.65 65.89,89.53 65.78,89.53 65.71,89.6 65.71,89.82 65.76,89.87 65.76,91.05 65.62,91.19 65.62,92.02 65.2,92.44 64.68,92.44 64.48,92.24 64.1,92.24 v1(63.86,92)
42_M0_DATA18: length 24.7
  L7-SIG w0.06: 62.35,75.93 61.9,75.93 61.81,75.84 60.54,75.84 v6(60.54,75.83)
  L7-SIG w0.064: 62.35,75.93 64.65,78.23 64.65,78.44 64.93,78.72 65.73,78.72 67.9,80.89 67.9,87.56 67.29,88.17 67.06,88.17 66.92,88.31 66.92,88.54 66.83,88.63 66.58,88.63 66.45,88.76 66.45,89.13 66.24,89.34 66.05,89.34 66.01,89.29 66.01,89.04 65.92,88.96 65.69,88.96 65.46,89.19 65.46,89.57 65.36,89.67 64.98,89.67 64.91,89.75 64.91,90.03 64.96,90.08 65.05,90.08 65.21,90.23 65.21,91.2 65,91.4 65,91.74 65.11,91.84 65.11,92.17 65.01,92.26 64.73,92.26 v1(64.45,91.98)
42_M0_DATA19: length 23.9
  L7-SIG w0.064: v6(60.82,77.29) 60.82,77.52 61.28,77.98 61.28,78.2 61.21,78.27 61.21,78.47 61.28,78.54 61.28,78.93 61.48,79.13 61.48,79.51 61.4,79.59 61.4,80.23 62.61,81.44 63.18,81.44 63.25,81.52 63.25,81.77 63.36,81.87 63.53,81.87 63.64,81.77 63.64,81.67 63.71,81.59 64.58,81.59 64.67,81.69 64.67,81.88 64.58,81.97 64.09,81.97 63.99,82.08 63.99,82.3 64.09,82.41 64.49,82.41 64.58,82.49 64.58,82.79 64.49,82.87 64.09,82.87 64.01,82.95 64.01,83.2 64.09,83.28 64.59,83.28 64.67,83.36 64.67,83.6 64.59,83.69 64.09,83.69 64.01,83.77 64.01,84.01 64.09,84.09 64.59,84.09 64.67,84.17 64.67,84.42 64.59,84.5 64.09,84.5 64.01,84.58 64.01,84.82 64.09,84.91 64.59,84.91 64.67,84.99 64.67,85.23 64.59,85.31 64.09,85.31 64.01,85.39 64.01,85.61 64.09,85.69 64.59,85.69 64.67,85.77 64.67,85.91 64.29,86.29 63.43,86.29 63.37,86.35 63.37,86.54 63.42,86.6 63.63,86.6 63.66,86.63 63.66,87.12 63.19,87.59 63.19,88.96 62.76,89.39
  L7-SIG w0.081: 62.76,89.39 62.76,90.27 62.83,90.33 v1(62.83,90.48)
  BOTTOM w0.203: U1601.T14 62.64,90.69
42_M0_DATA20: length 24.5
  L7-SIG w0.06: 62.18,76.24 61.75,76.24 61.6,76.09 60.89,76.09 v6(60.82,76.16)
  L7-SIG w0.064: 62.18,76.24 64.09,78.14 64.09,78.6 64.64,79.14 65.15,79.14 65.15,79.14 65.42,79.14 67.38,81.1 67.38,82.69 67.3,82.78 66.79,82.78 66.71,82.86 66.71,83.09 66.8,83.18 67.3,83.18 67.38,83.26 67.38,83.51 67.3,83.59 66.79,83.59 66.68,83.7 66.68,83.88 66.8,84 67.3,84 67.38,84.08 67.38,84.32 67.3,84.4 66.79,84.4 66.71,84.49 66.71,84.74 66.78,84.81 67.3,84.81 67.38,84.89 67.38,85.36 67,85.74 67,87.42 65.97,88.45 65.62,88.45 64.57,89.5
  L7-SIG w0.076: 64.57,89.5 64.57,90.46 64.14,90.88 64.14,91.21 v1(63.86,91.48)
42_M0_DATA21: length 22.7
  L7-SIG w0.064: 62.58,90.58 62.86,90.86 v1(62.86,91.04) ; 62.61,90.08 62.61,89.16 62.56,89.11 62.21,89.11 62.13,89.03 62.13,88.91 62.21,88.83 62.8,88.83 62.87,88.76 62.87,87.46 63.14,87.2 63.14,86.01 62.91,85.78 62.91,85.58 62.99,85.5 63.61,85.5 63.69,85.42 63.69,85.18 63.61,85.1 63.05,85.1 62.97,85.02 62.97,84.77 63.05,84.69 63.61,84.69 63.69,84.61 63.69,84.37 63.61,84.28 63.05,84.28 62.97,84.2 62.97,83.96 63.05,83.88 63.61,83.88 63.69,83.8 63.69,83.55 63.61,83.47 63.05,83.47 62.97,83.39 62.97,83.15 63.05,83.07 63.61,83.07 63.69,82.98 63.69,82.74 63.61,82.66 63.05,82.66 62.95,82.55 62.95,81.75 62.84,81.64 62.54,81.64 61.25,80.35 61.25,79.49 60.99,79.23 60.13,79.23 59.69,78.8 59.69,77.73 59.93,77.49 v6(59.93,76.96)
  L7-SIG w0.081: 62.58,90.58 62.58,90.11 62.61,90.08
42_M0_DATA22: length 24.7
  L7-SIG w0.06: v6(59.93,76.41) 59.93,76.42 59.93,76.67 60.13,76.87 60.3,76.87 60.42,76.74 60.59,76.74 60.75,76.9 61.67,76.9 61.73,76.96
  L7-SIG w0.064: v1(63.33,90.48) 63.33,90.39 63.08,90.14 63.08,89.87 63.54,89.4 63.54,88.51 63.64,88.42 63.77,88.42 63.84,88.49 63.84,88.74 63.93,88.83 64.03,88.83 64.17,88.7 64.17,88.3 64.3,88.17 64.57,88.17 64.68,88.06 64.68,87.91 64.57,87.8 64.28,87.8 64.17,87.69 64.17,87.05 64.23,86.99 64.44,86.99 64.5,87.05 64.5,87.44 64.56,87.5 64.67,87.5 64.8,87.37 64.8,86.62 65.31,86.11 65.31,80.97 64.89,80.55 64.27,80.55 64.09,80.37 63.86,80.37 63.67,80.56 62.23,80.56 62.07,80.41 62.07,80.23 62,80.16 61.82,80.16 61.76,80.09 61.76,79.82 61.82,79.75 61.95,79.75 62.01,79.69 62.01,79.56 62.16,79.41 62.16,79.05 62.04,78.93 61.81,78.93 61.71,78.82 61.71,78.7 61.79,78.61 61.99,78.61 62.06,78.55 62.06,78.29 62.21,78.15 62.21,78.05 62.15,78 61.94,78 61.88,77.94 61.88,77.82 62.06,77.63 62.06,77.29 61.73,76.96
  BOTTOM w0.203: U1601.T13 63.14,90.69
42_M0_DATA23: length 23.6
  L7-SIG w0.064: v6(60.51,76.95) 60.59,77.03 61.51,77.03 61.53,77.05 61.53,77.05 61.78,77.3 61.78,77.61 61.65,77.73 61.52,77.73 61.44,77.81 61.44,78.01 61.49,78.06 61.7,78.06 61.76,78.12 61.76,78.4 61.56,78.6 61.56,78.94 61.83,79.21 61.83,79.43 61.56,79.7 61.56,80.15 62.16,80.75 62.65,80.75 62.73,80.84 62.73,81.14 62.83,81.24 62.97,81.24 63.08,81.14 63.08,80.81 63.16,80.73 63.33,80.73 63.42,80.81 63.42,81.21 63.52,81.31 63.67,81.31 63.77,81.21 63.77,80.79 63.85,80.71 64.05,80.71 64.13,80.79 64.13,81.24 64.23,81.34 64.37,81.34 64.47,81.24 64.47,80.91 64.57,80.81 64.81,80.81 65.01,81.01 65.01,85.98 64.39,86.6 64.04,86.6 63.92,86.72 63.92,87.31 63.79,87.43 63.69,87.43 63.58,87.54 63.58,87.69 63.69,87.79 63.94,87.79 64.07,87.92 64.07,88.1 63.94,88.22 63.55,88.22 63.35,88.43 63.35,88.82 63.35,89.34 62.92,89.77 62.92,90.2 63.09,90.37 63.09,90.84 63.24,90.98 v1(63.36,90.98)
42_M0_DATA24: length 23.9
  L5-SIG w0.06: 62.15,77.84 62.15,77.66 61.58,77.09 59.45,77.09 v6(59.34,76.98)
  L5-SIG w0.076: 64.19,90.03 64.08,90.14 64.08,90.46 64.23,90.6 64.36,90.6 64.42,90.66 64.42,90.72 64.55,90.85 64.55,90.94 64.49,90.99 v1(64.42,90.99)
  L5-SIG w0.109: 62.15,77.84 62.15,78.64 62.21,78.7 62.29,78.7 62.47,78.52 62.53,78.52 63.04,79.03 ; 64.6,88.28 64.48,88.28 64.19,88.57 64.19,90.03
  L5-SIG w0.127: 63.04,79.03 63.44,79.03 63.57,79.15 63.57,79.32 63.44,79.45 63.01,79.45 62.91,79.55 62.91,79.8 63.31,80.2 63.55,80.2 63.7,80.05 63.7,79.81 63.84,79.67 64.02,79.67 64.5,80.15 64.5,80.33 64.41,80.42 63.95,80.42 63.85,80.52 63.85,80.69 64.02,80.86 64.41,80.86 64.54,80.98 64.54,83.75 64.93,84.13 64.93,84.58 64.81,84.7 64.62,84.7 64.49,84.83 64.49,85.01 64.62,85.14 64.85,85.14 64.98,85.27 64.98,85.52 64.85,85.65 64.67,85.65 64.54,85.78 64.54,86.03 64.67,86.16 64.8,86.16 64.93,86.28 64.93,86.61 64.83,86.71 64.62,86.71 64.53,86.81 64.53,87.03 64.67,87.17 64.8,87.17 64.93,87.3 64.93,87.95 64.6,88.28
42_M0_DATA25: length 24.4
  L5-SIG w0.06: v6(59.4,75.89) 59.69,75.89 59.83,75.74 60.14,75.74 60.58,76.18 60.8,76.18
  L5-SIG w0.076: v1(65.47,90.95) 65.66,90.95 65.7,90.91 65.7,89.92 65.8,89.82 65.97,89.82 66.23,89.57 66.23,89.21 67.29,88.14 67.29,87.95
  L5-SIG w0.109: 60.8,76.18 60.81,76.18 62.23,76.18 62.5,76.45 62.53,76.45 62.53,76.45 63.5,76.45 63.61,76.56 63.61,76.69 63.43,76.87 63.43,77.09 63.52,77.17 63.92,77.17 63.97,77.12 63.97,76.58 64.07,76.49 64.19,76.49 64.45,76.74 64.45,76.87 64.3,77.02 64.3,77.12 64.5,77.33 64.6,77.33 64.75,77.17 64.88,77.17 64.98,77.27 64.98,77.8
  L5-SIG w0.127: 64.98,77.8 64.98,78.07 66.37,79.45 66.37,81.56 67.88,83.07 67.88,86.87 67.29,87.46 67.29,87.95
42_M0_DATA26: length 24.2
  L5-SIG w0.06: v6(59.63,75.65) 59.66,75.62 60.19,75.62 60.58,76.01 60.8,76.01
  L5-SIG w0.076: 66.51,89.24 66.51,89.5 65.86,90.15 65.86,91.09 65.61,91.33 65.61,92.02 65.45,92.19 65.07,92.19 v1(64.86,91.98)
  L5-SIG w0.109: 66.51,89.24 66.51,89.2 67.57,88.14 67.57,87.91 ; 65.17,77.17 64.26,76.26 62.54,76.26 62.3,76.01 60.8,76.01
  L5-SIG w0.127: 67.57,87.91 67.57,87.57 68.16,86.98 68.16,82.96 66.65,81.44 66.65,79.34 65.17,77.86 65.17,77.17
42_M0_DATA27: length 23.1
  L5-SIG w0.06: v6(58.52,75.58) 58.52,75.69 58.8,75.97 58.8,76.32 58.7,76.42 58.03,76.42 57.94,76.51 57.94,76.57 57.99,76.62 58.24,76.62 58.32,76.69 58.42,76.69 58.47,76.74 58.47,76.79 58.55,76.87 58.65,76.87 58.8,76.72 58.91,76.72 58.92,76.73 58.98,76.79 58.99,76.79 59.02,76.82 59.14,76.82 59.21,76.74 59.29,76.74
  L5-SIG w0.109: 63.39,78.65 63.23,78.65 63.13,78.75 63,78.75 62.89,78.63 62.89,78.31 62.74,78.16 62.64,78.16 62.46,78.34 62.4,78.34 62.32,78.26 62.32,77.96 62.45,77.84 62.45,77.6 61.78,76.93 60.06,76.93 59.99,76.86 59.56,76.86 59.44,76.74 59.29,76.74 ; v1(64.33,90.35) 64.33,90.35 64.4,90.28 64.4,88.63 64.54,88.48 64.68,88.48 65.21,87.96 65.21,87.79
  L5-SIG w0.127: 63.39,78.65 64.82,80.08 64.82,82.25 65.03,82.46 65.03,82.7 64.82,82.91 64.82,83.63 65.21,84.02 65.21,85.04 65.41,85.24 65.41,85.49 65.21,85.69 65.21,86.43 65.44,86.67 65.44,86.86 65.21,87.1 65.21,87.79
  BOTTOM w0.203: U1601.T11 64.14,90.69
42_M0_DATA28: length 23.9
  L5-SIG w0.06: 60.16,76.18 60.14,76.15 59.96,76.15 59.8,76.31 59.57,76.31 59.45,76.19 59.2,76.19 v6(59.12,76.11)
  L5-SIG w0.109: 64.45,78.33 64.45,77.77 64.28,77.61 64.16,77.61 64.08,77.68 64.08,77.97 64.01,78.04 63.88,78.04 63.74,77.91 63.74,77.7 63.65,77.61 63.53,77.61 63.43,77.7 63.43,77.88 63.31,78 63.21,78 63.11,77.9 63.11,77.6 62.96,77.45 62.96,77.05 62.82,76.91 62.42,76.91 62.03,76.52 60.51,76.52 60.16,76.18 ; v1(64.97,90.39) 64.97,89.97 65.01,89.92 65.01,88.93 65.3,88.63 66.04,88.63 66.09,88.58 66.24,88.58 66.35,88.48 66.35,88.38 66.09,88.12 66.09,88.02 66.17,87.94 66.35,87.94 66.5,88.1 66.6,88.1 66.68,88.02 66.68,87.79
  L5-SIG w0.127: 64.45,78.33 65.81,79.69 65.81,81.79 67.32,83.3 67.32,85.64 66.68,86.29 66.68,87.79
  BOTTOM w0.203: U1601.T10 64.64,90.69
42_M0_DATA29: length 23.2
  L5-SIG w0.06: 61.96,77.87 61.96,77.63 61.53,77.21 59.28,77.21 59.05,76.98 v6(58.88,76.98)
  L5-SIG w0.076: 63.98,89.88 63.98,90.01 63.93,90.05 63.93,90.52 64.18,90.76 64.18,91.18 64.25,91.25 64.36,91.25 64.39,91.28 64.39,91.37 64.44,91.42 64.51,91.42 64.64,91.29 64.75,91.29 64.85,91.2 64.85,91.09 v1(64.78,91.03)
  L5-SIG w0.109: 64.11,88.25 63.98,88.38 63.98,89.88 ; 61.96,77.87 61.96,78.77 61.82,78.91 61.82,79.5 61.92,79.6 62.06,79.6 62.16,79.5 62.16,79.06 62.36,78.87 62.36,78.87 62.44,78.79 62.56,78.79 62.83,79.05 62.83,79.19 62.75,79.26 62.61,79.26 62.52,79.35 62.52,79.75 63.37,80.6
  L5-SIG w0.127: 64.11,88.25 64.11,88 64.22,87.88 64.59,87.88 64.65,87.82 64.65,87.5 64.59,87.45 64.28,87.45 64.16,87.33 64.16,86.78 64.44,86.5 64.44,86.32 64.32,86.2 64.24,86.2 64.16,86.12 64.16,85.77 64.41,85.51 64.41,85.33 64.16,85.08 64.16,84.59 64.29,84.45 64.48,84.45 64.58,84.36 64.58,84.18 64.51,84.11 64.33,84.11 64.19,83.97 64.19,81.42 63.37,80.6
42_M0_DATA30: length 23.7
  L5-SIG w0.06: v6(59.66,76.11) 59.76,76 60.23,76 60.55,76.32
  L5-SIG w0.109: 67.01,88.14 66.35,88.8 66.12,88.8 66.04,88.88 66.04,89.47 65.93,89.58 65.78,89.58 65.68,89.47 65.68,88.99 65.55,88.87 65.36,88.87 65.23,89 65.23,89.66 65.28,89.71 65.38,89.71 65.49,89.82 65.49,89.98 65.38,90.09 65.31,90.09 65.23,90.16 65.23,90.37 65.33,90.47 v1(65.45,90.47) ; 60.55,76.32 60.58,76.35 62.13,76.35 62.49,76.71 63,76.71 63.14,76.84 63.14,77.3 63.26,77.43 64.35,77.43 64.6,77.67
  L5-SIG w0.127: 64.6,77.67 64.71,77.78 64.71,78.19 66.09,79.57 66.09,81.67 67.6,83.19 67.6,85.78 67.06,86.33 67.06,86.58 67.33,86.85 67.33,87.03 67.01,87.34 67.01,88.14
  BOTTOM w0.203: U1601.T9 65.14,90.69
42_M0_DATA31: length 24.1
  L5-SIG w0.076: 63.78,89.8 63.78,90.09 63.64,90.23 63.64,90.44 64.02,90.83 64.02,91.25 64.6,91.83 64.68,91.83 64.74,91.77 v1(64.74,91.53)
  L5-SIG w0.109: 63.78,88.23 63.78,89.8 ; 63.46,80.99 63.37,80.89 63.23,80.89 62.93,81.19 62.86,81.19 62.66,81 62.66,80.9 62.94,80.62 62.94,80.5 62.82,80.38 62.46,80.38 62.37,80.29 62.37,79.89 62.28,79.8 61.88,79.8 61.65,79.57 61.65,78.84 61.75,78.74 61.75,77.68 61.42,77.35 61.09,77.35 61.02,77.42 61.02,78.09 60.9,78.21 60.9,78.38 61.02,78.5 61.02,78.67 60.9,78.78 60.54,78.78 60.4,78.64 60.4,78.18 60.64,77.94 60.64,77.45 60.54,77.35 60.04,77.35 59.99,77.41 59.99,77.54 59.89,77.63 59.74,77.63 59.46,77.35 59.12,77.35 v6(59.08,77.31)
  L5-SIG w0.127: 63.78,88.23 63.88,88.13 63.88,83.09 63.73,82.94 63.73,82.8 63.9,82.63 63.9,81.7 63.75,81.55 63.43,81.55 63.31,81.42 63.31,81.28 63.46,81.13 63.46,80.99
