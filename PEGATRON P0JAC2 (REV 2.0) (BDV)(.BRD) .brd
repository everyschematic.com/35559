# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Text on the board (continued)
User.45: list("[Package] BOTTOM" "15.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2433.5 MIL" "-2433.50 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3178.39 5096.47) (-3078.42 5196.43))" list(-659.110000 4834.010000) nil)@@@list("kelly_lv" "2014/01/14 09:50:20" nil "PC-0005358" "5k-castle.105")@@@list("vincent_kuo" "2014/01/13 22:14:40" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "229.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2433.7 MIL" "-2433.70 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3178.59 5096.47) (-3078.62 5196.43))" list(-659.110000 4834.010000) nil)@@@list("bobo_dong" "2014/01/13 20:55:11" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "262.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2373.86 MIL" "-2373.86 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3118.39 5096.47) (-3018.42 5196.43))" list(-659.110000 4834.010000) nil)@@@list("bobo_dong" "2014/01/27 15:54:32" nil "s0dcoa89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "5.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2473.28 MIL" "-2473.28 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3218.39 5096.47) (-3118.42 5196.43))" list(-659.110000 4834.010000) nil)@@@list("vincent_kuo" "2014/01/14 11:44:15" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11")@@@list("vincent_kuo" "2014/01/14 11:45:17" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "197.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2572.73 MIL" "-2572.73 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3318.39 5096.47) (-3218.42 5196.43))" list(-659.110000 4834.010000) nil)@@@list("bobo_dong" "2014/01/27 15:54:14" nil "s0dcoa89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "206.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2672.43 MIL" "-2672.43 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3418.59 5096.47) (-3318.62 5196.43))" list(-659.110000 4834.010000) nil)@@@list("bobo_dong" "2014/01/13 20:54:57" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "210.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3171.95 MIL" "-3171.95 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.6 5051.45) (-3823.6 5241.45))" list(-659.110000 4834.010000) nil)@@@list("bobo_dong" "2014/01/13 20:54:59" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "74.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3171.75 MIL" "-3171.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.4 5051.45) (-3823.4 5241.45))" list(-659.110000 4834.010000) nil)@@@list("kelly_lv" "2014/01/14 09:49:47" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:52" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "78.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2672.23 MIL" "-2672.23 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3418.39 5096.47) (-3318.42 5196.43))" list(-659.110000 4834.010000) nil)@@@list("kelly_lv" "2014/01/14 09:49:50" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:56" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "114.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2373.86 MIL" "-2373.86 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3118.31 5096.46) (-3018.34 5196.42))" list(-659.030000 4834.000000) nil)@@@list("bobo_dong" "2014/02/26 15:15:20" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:56" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "3.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2473.28 MIL" "-2473.28 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3218.31 5096.46) (-3118.34 5196.42))" list(-659.030000 4834.000000) nil)@@@list("tank_tung" "2014/03/19 17:35:39" nil "P143000043-PC" "g1t-jct2_bdw_lpddr3.14")@@@list("vincent_kuo" "2014/03/19 17:38:01" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.20") | list("[Package] TOP" "1.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2672.23 MIL" "-2672.23 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-3418.31 5096.46) (-3318.34 5196.42))" list(-659.030000 4834.000000) nil)@@@list("tank_tung" "2014/03/19 17:35:37" nil "P143000043-PC" "g1t-jct2_bdw_lpddr3.14")@@@list("vincent_kuo" "2014/03/19 17:37:59" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.20") | list("[Package] TOP" "3.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3171.75 MIL" "-3171.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.32 5051.44) (-3823.32 5241.44))" list(-659.030000 4834.000000) nil)@@@list("bobo_dong" "2014/02/26 13:17:06" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:03" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "7.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2572.73 MIL" "-2572.73 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-3318.31 5096.46) (-3218.34 5196.42))" list(-659.030000 4834.000000) nil)@@@list("bobo_dong" "2014/02/26 13:17:13" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:06" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "108.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "281.1 MIL" "-81.10 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.AA9:<uTiL>cId4472<uTiL>.1 ((1493.43 2533.93) (-622.0 4766.0))" "[PinPair] <uTiL>cId4474<uTiL>.1:<uTiL>cId23<uTiL>.AB8 ((-622.0 4698.0) (1482.29 2522.79))" list(-622.000000 4698.000000) nil)@@@list("bobo_dong" "2014/02/26 15:14:10" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:50" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "261.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-659.74 2283.46) (-502.26 2724.4))" list(-502.260000 2284.090000) nil)@@@list("bobo_dong" "2014/01/27 15:54:30" nil "s0dcoa89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:54" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "124.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-659.74 2283.46) (-502.26 2724.4))" list(-502.260000 2284.080000) nil)@@@list("bobo_dong" "2014/02/26 15:15:17" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:03" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "110.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "245.53 MIL" "-45.53 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.W11:<uTiL>cId4473<uTiL>.1 ((1515.71 2556.21) (-224.0 4767.0))" "[PinPair] <uTiL>cId4475<uTiL>.1:<uTiL>cId23<uTiL>.V12 ((-260.5 4709.0) (1526.85 2567.35))" list(-260.500000 4709.000000) nil)@@@list("bobo_dong" "2014/02/26 15:14:13" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "34.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-281.91 4399.28) (19.9 4697.15))" list(-255.980000 4686.830000) nil)@@@list("bobo_dong" "2014/01/13 20:55:09" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:51" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "82.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-281.91 4399.28) (19.9 4697.15))" list(-255.980000 4686.830000) nil)@@@list("bobo_dong" "2014/01/13 20:54:54" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 14:59:59" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "33.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-122.5 4381.0) (-63.5 4409.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-281.91 4399.28) (19.9 4697.15))" list(-63.500000 4399.280000) nil)@@@list("bobo_dong" "2014/01/13 20:55:08" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:50" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "112.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-281.91 4399.28) (19.9 4697.15))" list(-39.820000 4697.150000) nil)@@@list("bobo_dong" "2014/02/26 15:15:23" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:55" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "1.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-281.91 4399.28) (19.9 4697.15))" list(-39.820000 4697.150000) nil)@@@list("bobo_dong" "2014/02/26 13:17:03" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:02" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "199.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-4.03 1468.59) (275.41 2165.25))" list(0.530000 1503.930000) nil)@@@list("bobo_dong" "2014/01/27 15:54:16" nil "s0dcoa89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:42" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "92.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-86.69 458.75) (275.42 1391.63))" list(0.530000 1356.290000) nil)@@@list("bobo_dong" "2014/01/13 20:57:05" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "89.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-39.47 271.73) (39.53 428.73))" list(0.530000 271.730000) nil)@@@list("bobo_dong" "2014/01/13 20:57:03" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:52" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "89.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-39.68 192.85) (39.32 507.85))" list(0.530000 192.850000) nil)@@@list("bobo_dong" "2014/01/13 20:55:03" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:05" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "17.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3350.28 MIL" "-3350.28 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3378.39 -786.99) (-3278.42 -687.03))" list(0.530000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:50:23" nil "PC-0005358" "5k-castle.105")@@@list("vincent_kuo" "2014/01/13 22:14:41" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "230.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3351.29 MIL" "-3351.29 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3378.59 -790.93) (-3278.62 -690.97))" list(0.530000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:55:12" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "8.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3389.44 MIL" "-3389.44 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3418.39 -786.99) (-3318.42 -687.03))" list(0.530000 0.630000) nil)@@@list("jennifer_hsu" "2014/01/14 11:36:51" nil "JENNIFER_H-PC" "g1t-p0jac_byt-t.11")@@@list("vincent_kuo" "2014/01/14 11:44:30" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "207.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3586.46 MIL" "-3586.46 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3618.59 -790.93) (-3518.62 -690.97))" list(0.530000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:54:57" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "211.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3878.41 MIL" "-3878.41 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.6 -835.95) (-3823.6 -645.95))" list(0.530000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:55:00" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "77.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3877.55 MIL" "-3877.55 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.4 -832.01) (-3823.4 -642.01))" list(0.530000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:49:49" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:55" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "81.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3585.51 MIL" "-3585.51 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3618.39 -786.99) (-3518.42 -687.03))" list(0.530000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:49:51" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:58" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "113.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-4.03 1468.59) (275.41 2165.25))" list(0.620000 1503.930000) nil)@@@list("bobo_dong" "2014/02/26 15:15:25" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:56" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "123.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-86.69 458.75) (275.42 1391.63))" list(0.620000 1356.290000) nil)@@@list("bobo_dong" "2014/02/26 15:15:16" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:02" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "121.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-39.47 271.73) (39.53 428.73))" list(0.620000 271.730000) nil)@@@list("bobo_dong" "2014/02/26 15:15:15" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:01" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "15.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-39.68 192.85) (39.32 507.85))" list(0.620000 192.850000) nil)@@@list("bobo_dong" "2014/02/26 15:15:09" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:16" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "117.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3389.45 MIL" "-3389.45 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3418.31 -787.0) (-3318.34 -687.04))" list(0.620000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 15:15:19" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:59" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "10.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3585.52 MIL" "-3585.52 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-3618.31 -787.0) (-3518.34 -687.04))" list(0.620000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 13:17:18" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:08" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "6.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3877.56 MIL" "-3877.56 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((-4013.32 -832.02) (-3823.32 -642.02))" list(0.620000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 13:17:12" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:05" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "61.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((120.08 3793.4) (163.38 3872.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((118.11 3790.44) (165.35 3875.52))" list(120.080000 3793.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:41" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:31" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "62.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((168.08 3793.4) (211.38 3872.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((166.11 3790.44) (213.35 3875.52))" list(168.080000 3793.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:41" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:31" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "74.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((279.75 4309.99) (379.71 4409.96))" list(279.750000 4369.250000) nil)@@@list("bobo_dong" "2014/01/13 20:56:50" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:38" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "85.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((419.48 1797.84) (482.48 1908.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((414.54 1821.83) (447.42 1854.71))" list(419.480000 1821.830000) nil)@@@list("bobo_dong" "2014/01/13 20:57:00" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:50" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "84.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((419.48 1797.84) (482.48 1908.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((449.54 1851.83) (482.42 1884.71))" list(449.540000 1851.830000) nil)@@@list("bobo_dong" "2014/01/13 20:56:59" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:49" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "87.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((663.23 1719.48) (688.23 1744.48))" "[Shape] Package Geometry/Place_Bound_Bottom ((654.23 1701.6) (697.23 1784.36))" list(663.230000 1719.480000) nil)@@@list("bobo_dong" "2014/01/13 20:57:01" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:51" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "51.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((740.56 2505.56) (773.44 2538.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((727.0 2508.5) (755.0 2567.5))" list(740.560000 2538.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:25" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "54.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((746.56 1561.56) (779.44 1594.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((748.0 1580.5) (776.0 1639.5))" list(748.000000 1594.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:28" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:00" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "59.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((746.56 1561.56) (779.44 1594.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((778.0 1580.5) (806.0 1639.5))" list(779.440000 1594.440000) nil)@@@list("bobo_dong" "2014/01/13 20:59:22" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:29" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "90.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((942.84 -39.63) (1257.84 39.37))" list(942.840000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:55:04" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:05" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "16.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((942.84 -39.63) (1257.84 39.37))" list(942.840000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 15:15:10" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:18" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "90.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((1022.67 -39.31) (1179.67 39.69))" list(1022.670000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:57:03" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "122.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((1022.67 -39.31) (1179.67 39.69))" list(1022.670000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 15:15:15" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:02" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "30.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "70.87 MIL" "-70.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1030.89 2382.08) (1780.19 3131.38))" "[Shape] Package Geometry/Place_Bound_Bottom ((92.53 2259.77) (1822.34 3152.99))" list(1030.890000 3131.340000) nil)@@@list("bobo_dong" "2014/01/13 20:55:06" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:42" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "32.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "70.87 MIL" "-70.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1030.89 2382.08) (1780.19 3131.38))" "[Shape] Package Geometry/Place_Bound_Bottom ((69.29 2236.54) (2521.28 4011.36))" list(1030.890000 3131.340000) nil)@@@list("bobo_dong" "2014/01/13 20:55:08" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:46" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "74.Propagation Delay" "::0.00 MIL:1600.00 MIL [PROPAGATION_DELAY]" "1602.61 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BK42:<uTiL>cId37<uTiL>.E16 ((1192.65 2879.27) (1036.51 3739.47))" " " list(1036.510000 3739.470000) nil)@@@list("bobo_dong" "2014/01/13 20:54:22" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:23" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "77.Propagation Delay" "::0.00 MIL:1600.00 MIL [PROPAGATION_DELAY]" "1603 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BP42:<uTiL>cId37<uTiL>.C14 ((1148.09 2879.27) (1075.88 3778.84))" " " list(1075.880000 3778.840000) nil)@@@list("bobo_dong" "2014/01/13 20:54:47" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:27" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "80.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1111.23 1092.6) (1154.23 1175.36))" "[Shape] Package Geometry/Place_Bound_Bottom ((1116.36 1110.76) (1149.24 1143.64))" list(1116.360000 1110.760000) nil)@@@list("bobo_dong" "2014/01/13 20:56:56" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:47" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "79.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1089.35 1299.98) (1172.11 1342.98))" "[Shape] Package Geometry/Place_Bound_Bottom ((1120.56 1303.56) (1153.44 1336.44))" list(1120.560000 1303.560000) nil)@@@list("bobo_dong" "2014/01/13 20:56:55" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:46" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "86.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1117.15 149.18) (1199.91 192.18))" "[Shape] Package Geometry/Place_Bound_Bottom ((1130.29 153.54) (1163.17 186.42))" list(1130.290000 153.540000) nil)@@@list("bobo_dong" "2014/01/13 20:57:01" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:50" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "82.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1129.23 1202.6) (1172.23 1285.36))" "[Shape] Package Geometry/Place_Bound_Bottom ((1134.29 1182.54) (1167.17 1215.42))" list(1134.290000 1202.600000) nil)@@@list("bobo_dong" "2014/01/13 20:56:58" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:48" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "186.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "12402.06 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId21<uTiL>.52:<uTiL>cId23<uTiL>.BK32 ((1994.0 2588.2) (1192.65 2767.87))" " " list(1192.650000 2767.870000) nil)@@@list("bobo_dong" "2014/01/13 20:53:58" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "185.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "12490.54 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId21<uTiL>.53:<uTiL>cId23<uTiL>.BJ30 ((1994.0 2603.95) (1203.79 2756.73))" " " list(1203.790000 2756.730000) nil)@@@list("bobo_dong" "2014/01/13 20:53:54" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "47.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1250.19 1502.56) (1367.81 1589.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1277.570000 1589.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:22" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:49" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "45.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1201.92 1411.54) (1319.54 1498.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1277.570000 1498.420000) nil)@@@list("bobo_dong" "2014/01/13 20:55:20" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:45" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "46.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1233.19 1311.56) (1350.81 1398.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1277.570000 1398.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:21" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:47" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "41.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1240.19 1160.56) (1357.81 1247.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1277.570000 1247.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:17" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:28" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "37.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "44.09 MIL" "-0.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1202.55 580.46) (1352.91 702.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1277.570000 702.500000) nil)@@@list("bobo_dong" "2014/01/13 20:55:14" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:19" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "81.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1274.62 882.5) (1357.38 925.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((1309.29 887.54) (1342.17 920.42))" list(1309.290000 887.540000) nil)@@@list("bobo_dong" "2014/01/13 20:56:57" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:47" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "38.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1304.44 763.67) (1443.02 850.29))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1336.600000 830.690000) nil)@@@list("bobo_dong" "2014/01/13 20:55:14" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:27" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "1.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" "[Shape] Package Geometry/Place_Bound_Bottom ((1414.19 1013.56) (1531.81 1100.44))" list(1414.190000 1076.770000) nil)@@@list("bobo_dong" "2014/02/26 15:38:16" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:03" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "48.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "70.87 MIL" "-70.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1470.05 1193.32) (1755.53 1478.8))" "[Shape] Package Geometry/Place_Bound_Bottom ((1293.3 1261.79) (2498.03 2070.85))" list(1470.050000 1431.090000) nil)@@@list("bobo_dong" "2014/01/13 20:55:23" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:51" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "50.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "24.41 MIL" "-24.41 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1470.05 1193.32) (1755.53 1478.8))" "[Shape] Package Geometry/Place_Bound_Bottom ((1490.05 1213.32) (1735.53 1458.8))" list(1490.050000 1213.320000) nil)@@@list("bobo_dong" "2014/01/13 20:55:24" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:52" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "107.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "241.31 MIL" "-41.31 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId4474<uTiL>.1:<uTiL>cId23<uTiL>.AB8 ((-622.0 4698.0) (1482.29 2522.79))" "[PinPair] <uTiL>cId23<uTiL>.AA9:<uTiL>cId4472<uTiL>.1 ((1493.43 2533.93) (-622.0 4766.0))" list(1493.430000 2533.930000) nil)@@@list("bobo_dong" "2014/02/26 15:14:15" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:48" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "109.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "276.35 MIL" "-76.35 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId4475<uTiL>.1:<uTiL>cId23<uTiL>.V12 ((-260.5 4709.0) (1526.85 2567.35))" "[PinPair] <uTiL>cId23<uTiL>.W11:<uTiL>cId4473<uTiL>.1 ((1515.71 2556.21) (-224.0 4767.0))" list(1515.710000 2556.210000) nil)@@@list("bobo_dong" "2014/02/26 15:14:12" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:52" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "83.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1530.35 808.48) (1613.11 851.48))" "[Shape] Package Geometry/Place_Bound_Bottom ((1530.29 790.54) (1563.17 823.42))" list(1530.350000 808.480000) nil)@@@list("bobo_dong" "2014/01/13 20:56:59" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:49" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "39.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1414.19 1013.56) (1531.81 1100.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1531.810000 1076.770000) nil)@@@list("bobo_dong" "2014/01/13 20:55:15" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:27" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "40.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1557.19 1012.56) (1674.81 1099.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1557.190000 1076.770000) nil)@@@list("bobo_dong" "2014/01/13 20:55:16" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:28" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "43.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "70.87 MIL" "-70.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1470.05 1193.32) (1755.53 1478.8))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(1631.870000 1193.320000) nil)@@@list("bobo_dong" "2014/01/13 20:55:18" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:44" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "75.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "8455.51 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BK34:<uTiL>cId4025<uTiL>.M5 ((1192.65 2790.15) (1675.78 1383.3))" " " list(1675.780000 1383.300000) nil)@@@list("bobo_dong" "2014/01/13 20:54:19" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:24" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "76.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "8321.02 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BR33:<uTiL>cId4025<uTiL>.M6 ((1136.95 2779.01) (1675.78 1367.56))" " " list(1675.780000 1367.560000) nil)@@@list("bobo_dong" "2014/01/13 20:54:20" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:26" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "75.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1715.62 811.5) (1798.38 854.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((1729.29 820.54) (1762.17 853.42))" list(1729.290000 820.540000) nil)@@@list("bobo_dong" "2014/01/13 20:56:51" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:38" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "49.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "70.87 MIL" "-70.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1470.05 1193.32) (1755.53 1478.8))" "[Shape] Package Geometry/Place_Bound_Bottom ((1293.3 436.99) (2498.03 1246.05))" list(1755.530000 1224.390000) nil)@@@list("bobo_dong" "2014/01/13 20:55:24" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:51" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "64.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1803.15 252.33) (1882.31 295.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((1800.19 250.36) (1885.27 297.6))" list(1803.150000 252.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:42" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:32" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "65.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1803.15 197.33) (1882.31 240.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((1800.19 195.36) (1885.27 242.6))" list(1803.150000 197.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:43" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:33" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "66.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1803.15 144.33) (1882.31 187.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((1800.19 142.36) (1885.27 189.6))" list(1803.150000 144.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:44" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:33" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "67.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1803.15 89.33) (1882.31 132.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((1800.19 87.36) (1885.27 134.6))" list(1803.150000 89.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:45" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:34" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "68.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1804.15 35.33) (1883.31 78.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((1801.19 33.36) (1886.27 80.6))" list(1804.150000 35.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:45" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:34" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "31.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-11.81 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1786.55 2294.52) (2089.45 2361.82))" "[Shape] Package Geometry/Place_Bound_Bottom ((69.29 2236.54) (2521.28 4011.36))" list(1811.120000 2361.820000) nil)@@@list("bobo_dong" "2014/01/13 20:55:07" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:43" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "36.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "22.44 MIL" "-22.44 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1878.48 4464.79) (2094.98 4681.29))" "[Shape] Package Geometry/Place_Bound_Bottom ((1958.48 4544.79) (2014.98 4601.29))" list(1958.480000 4544.790000) nil)@@@list("bobo_dong" "2014/01/13 20:55:10" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "42.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1884.19 1168.56) (2001.81 1255.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(2001.810000 1224.400000) nil)@@@list("bobo_dong" "2014/01/13 20:55:17" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:29" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "44.Pkg to Pkg Spacing" "43.31 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-3.93 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1885.19 1257.06) (2002.81 1343.94))" "[Shape] Package Geometry/Place_Bound_Bottom ((392.11 413.75) (2521.26 2094.09))" list(2002.810000 1283.440000) nil)@@@list("bobo_dong" "2014/01/13 20:55:19" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:45" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "78.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1993.35 1919.48) (2076.11 1962.48))" "[Shape] Package Geometry/Place_Bound_Bottom ((2044.56 1946.56) (2077.44 1979.44))" list(2076.110000 1962.480000) nil)@@@list("bobo_dong" "2014/01/13 20:56:54" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:46" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "76.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2071.28 1293.65) (2154.04 1336.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((2083.29 1300.54) (2116.17 1333.42))" list(2083.290000 1300.540000) nil)@@@list("bobo_dong" "2014/01/13 20:56:52" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:41" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "251.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1878.48 4464.79) (2094.98 4681.29))" "[Shape] Package Geometry/Place_Bound_Bottom ((2092.9 4517.8) (2151.9 4545.8))" list(2094.980000 4517.800000) nil)@@@list("bobo_dong" "2014/01/13 20:55:30" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "250.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1878.48 4464.79) (2094.98 4681.29))" "[Shape] Package Geometry/Place_Bound_Bottom ((2092.9 4488.8) (2151.9 4516.8))" list(2094.980000 4488.800000) nil)@@@list("bobo_dong" "2014/01/13 20:55:29" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "247.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1878.48 4464.79) (2094.98 4681.29))" "[Shape] Package Geometry/Place_Bound_Bottom ((2092.9 4459.8) (2151.9 4487.8))" list(2094.980000 4464.790000) nil)@@@list("bobo_dong" "2014/01/13 20:55:26" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "77.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2120.23 1083.6) (2163.23 1166.36))" "[Shape] Package Geometry/Place_Bound_Bottom ((2125.56 1119.56) (2158.44 1152.44))" list(2125.560000 1119.560000) nil)@@@list("bobo_dong" "2014/01/13 20:56:53" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:42" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "58.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2179.29 944.54) (2212.17 977.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((2153.73 936.48) (2181.73 995.48))" list(2179.290000 944.540000) nil)@@@list("bobo_dong" "2014/01/13 20:56:31" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:29" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "263.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "412.07 MIL" "-412.07 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2201.11 5096.47) (2301.08 5196.43))" list(2211.420000 4684.400000) nil)@@@list("bobo_dong" "2014/01/27 15:54:33" nil "s0dcoa89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "115.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "412.06 MIL" "-412.06 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((2201.19 5096.46) (2301.16 5196.42))" list(2211.500000 4684.400000) nil)@@@list("bobo_dong" "2014/02/26 15:15:21" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:57" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "57.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2179.29 944.54) (2212.17 977.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((2196.73 911.48) (2224.73 970.48))" list(2212.170000 944.540000) nil)@@@list("bobo_dong" "2014/01/13 20:56:32" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:28" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "26.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "413.95 MIL" "-413.95 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2261.11 5096.47) (2361.08 5196.43))" list(2221.720000 4684.400000) nil)@@@list("bobo_dong" "2014/01/13 20:55:11" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:40" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "6.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "419.65 MIL" "-419.65 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2301.11 5096.47) (2401.08 5196.43))" list(2221.720000 4684.400000) nil)@@@list("jennifer_hsu" "2014/01/14 11:36:49" nil "JENNIFER_H-PC" "g1t-p0jac_byt-t.11")@@@list("vincent_kuo" "2014/01/14 11:45:18" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "198.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "449.42 MIL" "-449.42 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2401.11 5096.47) (2501.08 5196.43))" list(2221.720000 4684.400000) nil)@@@list("bobo_dong" "2014/01/27 15:54:15" nil "s0dcoa89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "79.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "497.86 MIL" "-497.86 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2501.11 5096.47) (2601.08 5196.43))" list(2221.720000 4684.400000) nil)@@@list("bobo_dong" "2014/01/13 20:54:56" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 14:59:57" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "4.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "419.64 MIL" "-419.64 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((2301.19 5096.46) (2401.16 5196.42))" list(2221.800000 4684.400000) nil)@@@list("tank_tung" "2014/03/19 17:35:38" nil "P143000043-PC" "g1t-jct2_bdw_lpddr3.14")@@@list("vincent_kuo" "2014/03/19 17:38:02" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.20") | list("[Package] TOP" "2.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "497.85 MIL" "-497.85 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2501.19 5096.46) (2601.16 5196.42))" list(2221.800000 4684.400000) nil)@@@list("tank_tung" "2014/03/19 17:35:37" nil "P143000043-PC" "g1t-jct2_bdw_lpddr3.14")@@@list("vincent_kuo" "2014/03/19 17:38:00" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.20") | list("[Package] TOP" "8.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "449.42 MIL" "-449.42 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2401.19 5096.46) (2501.16 5196.42))" list(2221.800000 4684.400000) nil)@@@list("bobo_dong" "2014/02/26 13:17:15" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:07" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "88.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((1991.02 -17.58) (2398.76 238.25))" list(2398.760000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:57:02" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:51" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "120.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((1991.02 -17.58) (2398.76 238.25))" list(2398.760000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 15:15:14" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:00" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "79.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "10173.77 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BP34:<uTiL>cId4358<uTiL>.D2 ((1148.09 2790.15) (2401.47 259.84))" " " list(2401.470000 259.840000) nil)@@@list("bobo_dong" "2014/01/13 20:54:48" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:28" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "78.Propagation Delay" "::0 mil:8000 mil [PROPAGATION_DELAY]" "10112.58 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BT32:<uTiL>cId4358<uTiL>.D1 ((1125.81 2767.87) (2401.47 240.16))" " " list(2401.470000 240.160000) nil)@@@list("bobo_dong" "2014/01/13 20:54:48" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:28" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "60.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2425.56 1817.56) (2458.44 1850.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((2404.57 1755.06) (2475.43 1960.94))" list(2425.560000 1817.560000) nil)@@@list("bobo_dong" "2014/01/13 20:56:40" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:30" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "53.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2437.29 927.54) (2470.17 960.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((2437.23 942.98) (2496.23 970.98))" list(2437.290000 960.420000) nil)@@@list("bobo_dong" "2014/01/13 20:55:27" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:17:59" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "88.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((1127.62 4148.51) (2457.84 4455.45))" list(2446.270000 4393.070000) nil)@@@list("bobo_dong" "2014/01/13 20:55:03" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:04" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "14.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((1127.62 4148.51) (2457.84 4455.45))" list(2446.270000 4393.060000) nil)@@@list("bobo_dong" "2014/02/26 15:15:08" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:10" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "16.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "687.66 MIL" "-687.66 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2461.11 -786.99) (2561.08 -687.03))" list(2511.100000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:50:21" nil "PC-0005358" "5k-castle.105")@@@list("vincent_kuo" "2014/01/13 22:14:41" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "231.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "691.6 MIL" "-691.60 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2461.11 -790.93) (2561.08 -690.97))" list(2511.100000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:55:13" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "200.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "687.66 MIL" "-687.66 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2501.11 -786.99) (2601.08 -687.03))" list(2551.100000 0.630000) nil)@@@list("bobo_dong" "2014/01/27 15:54:17" nil "s0dcoa89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/14 11:45:20" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "116.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "687.66 MIL" "-687.66 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((2501.19 -787.0) (2601.16 -687.04))" list(2551.180000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 15:15:18" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:58" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "198.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5425.1 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BK26:<uTiL>cId2265<uTiL>.8 ((1192.65 2723.31) (2694.89 3093.03))" " " list(2694.890000 3093.030000) nil)@@@list("bobo_dong" "2014/01/13 20:54:51" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "81.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5819.77 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BP24:<uTiL>cId2265<uTiL>.7 ((1148.09 2701.03) (2694.89 3057.6))" " " list(2694.890000 3057.600000) nil)@@@list("bobo_dong" "2014/01/13 20:54:50" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:30" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "80.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5700.89 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BL25:<uTiL>cId2265<uTiL>.5 ((1181.51 2712.17) (2694.89 2986.73))" " " list(2694.890000 2986.730000) nil)@@@list("bobo_dong" "2014/01/13 20:59:20" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:08:29" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "199.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5697.34 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BN25:<uTiL>cId2265<uTiL>.3 ((1159.23 2712.17) (2694.89 2915.86))" " " list(2694.890000 2915.860000) nil)@@@list("bobo_dong" "2014/01/13 20:54:51" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "200.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5835.64 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BU25:<uTiL>cId2265<uTiL>.2 ((1113.21 2710.71) (2694.89 2880.43))" " " list(2694.890000 2880.430000) nil)@@@list("bobo_dong" "2014/01/13 20:54:52" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "201.Propagation Delay" "::0 mil:5000 mil [PROPAGATION_DELAY]" "5760.66 MIL" "" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.BJ25:<uTiL>cId2265<uTiL>.1 ((1203.79 2712.17) (2694.89 2845.0))" " " list(2694.890000 2845.000000) nil)@@@list("bobo_dong" "2014/01/13 20:54:53" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] BOTTOM" "63.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2721.15 2232.33) (2800.31 2275.63))" "[Shape] Package Geometry/Place_Bound_Bottom ((2718.19 2230.36) (2803.27 2277.6))" list(2721.150000 2232.330000) nil)@@@list("bobo_dong" "2014/01/13 20:56:42" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:32" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "69.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2722.85 1809.4) (2802.01 1852.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((2719.89 1807.43) (2804.97 1854.67))" list(2722.850000 1809.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:46" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:35" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "70.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2722.85 1689.4) (2802.01 1732.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((2719.89 1687.43) (2804.97 1734.67))" list(2722.850000 1689.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:47" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:35" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "71.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2722.85 1565.4) (2802.01 1608.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((2719.89 1563.43) (2804.97 1610.67))" list(2722.850000 1565.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:48" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:36" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "72.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2722.85 1443.4) (2802.01 1486.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((2719.89 1441.43) (2804.97 1488.67))" list(2722.850000 1443.400000) nil)@@@list("bobo_dong" "2014/01/13 20:56:49" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:37" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Electrical] ALL" "187.Max Via Count" "12 [MAX_VIA_COUNT]" "15" "-3.00 MIL" "DRC ERROR CLASS/ALL" "[B/BVia] HDMI_DATA2_DP_CON (VIA10D4A24-L7-BOT) (2785.07 1698.25)" "[XNET] DDI0_TX0_DP " list(2785.070000 1698.250000) nil)@@@list("bobo_dong" "2014/01/13 20:54:16" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "208.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "691.6 MIL" "-691.60 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2701.11 -790.93) (2801.08 -690.97))" list(2796.520000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:54:58" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "212.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "679.69 MIL" "-679.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((3006.09 -835.95) (3196.09 -645.95))" list(2796.520000 0.630000) nil)@@@list("bobo_dong" "2014/01/13 20:55:00" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "76.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "675.95 MIL" "-675.95 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((3006.09 -832.01) (3196.09 -642.01))" list(2796.520000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:49:48" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:54" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "80.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "687.66 MIL" "-687.66 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2701.11 -786.99) (2801.08 -687.03))" list(2796.520000 0.630000) nil)@@@list("kelly_lv" "2014/01/14 09:49:50" nil "PC-0005358" "5k-castle.105")@@@list("doris_chen" "2014/01/16 14:59:58" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "5.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "675.95 MIL" "-675.95 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((3006.17 -832.02) (3196.17 -642.02))" list(2796.600000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 13:17:10" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:05" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "9.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "687.66 MIL" "-687.66 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2701.19 -787.0) (2801.16 -687.04))" list(2796.600000 0.620000) nil)@@@list("bobo_dong" "2014/02/26 13:17:17" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:07" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Electrical] ALL" "188.Max Via Count" "12 [MAX_VIA_COUNT]" "15" "-3.00 MIL" "DRC ERROR CLASS/ALL" "[B/BVia] HDMI_DATA2_DN_CON (VIA10D4A24-L7-BOT) (2820.73 1723.98)" "[XNET] DDI0_TX0_DN " list(2820.730000 1723.980000) nil)@@@list("bobo_dong" "2014/01/13 20:54:16" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "190.Max Via Count" "12 [MAX_VIA_COUNT]" "15" "-3.00 MIL" "DRC ERROR CLASS/ALL" "[B/BVia] HDMI_DATA0_DN_CON (VIA18D8A26-L3-L6) (2845.98 1603.98)" "[XNET] DDI0_TX2_DN " list(2845.980000 1603.980000) nil)@@@list("bobo_dong" "2014/01/13 20:54:18" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Electrical] ALL" "189.Max Via Count" "12 [MAX_VIA_COUNT]" "15" "-3.00 MIL" "DRC ERROR CLASS/ALL" "[B/BVia] HDMI_DATA0_DP_CON (VIA18D8A26-L3-L6) (2845.98 1579.98)" "[XNET] DDI0_TX2_DP " list(2845.980000 1579.980000) nil)@@@list("bobo_dong" "2014/01/13 20:54:17" nil "S0DCOA89102" "g1t-p0jac.11")@@@nil | list("[Package] TOP" "87.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2892.92 4545.6) (3028.38 4624.34))" list(3028.380000 4568.490000) nil)@@@list("bobo_dong" "2014/01/13 20:55:02" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:04" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "13.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2892.92 4545.6) (3028.38 4624.34))" list(3028.380000 4568.420000) nil)@@@list("bobo_dong" "2014/02/26 13:17:22" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:10" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "75.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "414.29 MIL" "-414.29 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((3006.09 5051.45) (3196.09 5241.45))" list(3064.690000 4637.160000) nil)@@@list("bobo_dong" "2014/01/13 20:54:58" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 14:59:53" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "4.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "414.29 MIL" "-414.29 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((3006.17 5051.44) (3196.17 5241.44))" list(3064.770000 4637.150000) nil)@@@list("bobo_dong" "2014/02/26 13:17:07" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:04" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "83.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((3068.02 4290.55) (3261.72 4446.45))" "[Shape] Package Geometry/Place_Bound_Top ((2867.7 3985.9) (3183.29 4302.67))" list(3068.020000 4290.550000) nil)@@@list("bobo_dong" "2014/01/13 20:54:54" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:00" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "91.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2902.94 1348.52) (3326.96 1741.24))" list(3165.950000 1384.800000) nil)@@@list("bobo_dong" "2014/01/13 20:55:05" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:06" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "142.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2902.94 1348.52) (3326.96 1741.24))" list(3165.950000 1384.790000) nil)@@@list("bobo_dong" "2014/02/26 15:15:13" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:27" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "86.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((3024.96 1985.64) (3309.06 2421.28))" list(3177.920000 2008.030000) nil)@@@list("bobo_dong" "2014/01/13 20:55:01" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:04" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "2.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((3024.96 1985.64) (3309.06 2421.28))" list(3177.920000 2008.020000) nil)@@@list("bobo_dong" "2014/02/26 13:17:05" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:03" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "35.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2867.7 3985.9) (3183.29 4302.67))" list(3183.290000 4273.030000) nil)@@@list("bobo_dong" "2014/01/13 20:55:10" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:14:52" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] TOP" "84.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((2867.7 3985.9) (3183.29 4302.67))" list(3183.290000 4273.030000) nil)@@@list("bobo_dong" "2014/01/13 20:54:55" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:00" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] BOTTOM" "118.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((2867.7 3985.9) (3183.29 4302.67))" list(3183.290000 4273.000000) nil)@@@list("bobo_dong" "2014/02/26 15:15:18" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:59" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "11.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((2867.7 3985.9) (3183.29 4302.67))" list(3183.290000 4273.000000) nil)@@@list("bobo_dong" "2014/02/26 13:17:20" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:09" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "73.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2671.23 2632.62) (3293.31 3238.48))" list(3210.600000 3227.710000) nil)@@@list("bobo_dong" "2014/01/13 20:56:49" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:37" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "119.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((2671.23 2632.62) (3293.31 3238.48))" list(3210.600000 3227.700000) nil)@@@list("bobo_dong" "2014/02/26 15:15:13" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:26:00" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "85.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Top ((3068.02 4290.55) (3261.72 4446.45))" list(3245.340000 4290.550000) nil)@@@list("bobo_dong" "2014/01/13 20:55:01" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("doris_chen" "2014/01/16 15:00:02" nil "JULIA_YU-PC1" "g1t-p0jac_byt-t.13-chk") | list("[Package] TOP" "12.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Top ((3068.02 4290.55) (3261.72 4446.45))" list(3245.420000 4290.550000) nil)@@@list("bobo_dong" "2014/02/26 13:17:21" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:31:09" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] BOTTOM" "91.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.11 0.63) (3261.09 4834.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((3163.47 3594.45) (3305.09 3854.29))" list(3261.090000 3854.290000) nil)@@@list("bobo_dong" "2014/01/13 20:57:04" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/01/13 22:18:53" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.11") | list("[Package] BOTTOM" "111.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-659.03 0.62) (3261.17 4834.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((3157.96 3594.45) (3305.09 3854.29))" list(3261.170000 3854.290000) nil)@@@list("bobo_dong" "2014/02/26 15:15:22" nil "S0DCOA89102" "g1t-p0jac.11")@@@list("vincent_kuo" "2014/02/26 15:25:54" nil "VINCENT_KUO-PC" "g1t-p0jac_byt-t.14") | list("[Package] TOP" "89.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "114.17 MIL" "-114.17 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3180.93 184.02) (-2895.2 613.72))" "[Shape] Package Geometry/Place_Bound_Top ((-3162.93 202.02) (-2913.2 595.72))" list(-3162.930000 231.260000) nil)@@@list("lei_pang" "2013/05/31 09:59:57" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "159.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3162.93 202.02) (-2913.2 595.72))" list(-3011.550000 595.720000) nil)@@@list("lei_pang" "2013/05/31 11:08:48" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "142.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3148.75 -466.6) (-2833.88 -90.02))" list(-3009.720000 -128.230000) nil)@@@list("lei_pang" "2013/05/31 11:08:30" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "107.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3180.93 184.02) (-2895.2 613.72))" list(-2999.850000 613.720000) nil)@@@list("lei_pang" "2013/05/31 10:00:22" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "135.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3019.24 701.76) (-2858.22 858.84))" list(-2996.700000 725.180000) nil)@@@list("lei_pang" "2013/05/31 11:06:21" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "108.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3166.75 -484.6) (-2815.88 -72.02))" list(-2978.190000 -128.230000) nil)@@@list("lei_pang" "2013/05/31 10:00:23" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "30.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2976.76 -23.97) (-2913.38 77.25))" "[Shape] Package Geometry/Place_Bound_Top ((-2974.07 -18.36) (-2916.07 71.64))" list(-2974.070000 -18.360000) nil)@@@list("lei_pang" "2013/05/31 11:08:36" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:18:04" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "109.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3269.12 -583.02) (-2912.4 -170.44))" list(-2912.400000 -567.200000) nil)@@@list("lei_pang" "2013/05/31 10:48:32" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "98.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "305.1 MIL" "-305.10 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3126.43 1421.19) (-2936.43 1611.19))" list(-2895.100000 1118.900000) nil)@@@list("lei_pang" "2013/05/31 11:04:41" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "167.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "97.64 MIL" "-97.64 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3166.75 -484.6) (-2815.88 -72.02))" "[Shape] Package Geometry/Place_Bound_Top ((-3148.75 -466.6) (-2833.88 -90.02))" list(-2826.440000 -123.280000) nil)@@@list("lei_pang" "2013/05/31 10:49:49" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "175.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3166.75 -484.6) (-2815.88 -72.02))" "[Shape] Package Geometry/Place_Bound_Top ((-2819.22 -405.35) (-2771.98 -373.85))" list(-2815.880000 -405.350000) nil)@@@list("lei_pang" "2013/05/31 10:50:01" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "102.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2928.23 MIL" "-2928.23 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-3126.43 -3710.31) (-2936.43 -3520.31))" list(-2812.700000 -594.700000) nil)@@@list("lei_pang" "2013/05/31 11:04:46" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "42.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2976.15 MIL" "-2976.15 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2531.41 -3665.29) (-2431.45 -3565.32))" list(-2712.800000 -594.700000) nil)@@@list("lei_pang" "2013/05/31 11:03:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "106.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2970.62 MIL" "-2970.62 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-2731.41 -3665.29) (-2631.45 -3565.32))" list(-2712.800000 -594.700000) nil)@@@list("lei_pang" "2013/05/31 11:04:50" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "5.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2661.73 -350.29) (-2560.51 -286.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2656.12 -347.6) (-2566.12 -289.6))" list(-2656.120000 -347.600000) nil)@@@list("lei_pang" "2013/05/31 11:08:39" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:22:22" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "6.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2661.73 -416.59) (-2560.51 -353.21))" "[Shape] Package Geometry/Place_Bound_Top ((-2656.12 -413.9) (-2566.12 -355.9))" list(-2656.120000 -413.900000) nil)@@@list("lei_pang" "2013/05/31 11:08:39" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:22:26" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "7.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "222.44 MIL" "-222.44 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3004.17 1572.0) (-2814.17 1762.0))" list(-2591.730000 1581.710000) nil)@@@list("sky_zheng" "2013/09/13 10:58:57" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:55" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "25.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2590.36 MIL" "-2590.36 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2959.16 -3390.46) (-2859.19 -3290.5))" list(-2591.730000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 11:00:21" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:41" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "4.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2789.37 MIL" "-2789.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-2959.16 -3590.46) (-2859.19 -3490.5))" list(-2591.730000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 10:58:55" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:54" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "8.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "3289.03 MIL" "-3289.03 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-3004.17 -4185.48) (-2814.17 -3995.48))" list(-2591.730000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 10:58:58" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:56" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "28.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2504.58 833.55) (-2329.63 1270.55))" list(-2493.300000 1270.550000) nil)@@@list("sky_zheng" "2013/09/13 11:00:34" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:09" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "3.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "365.89 MIL" "-365.89 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-2959.16 1067.02) (-2859.19 1166.98))" list(-2493.300000 1117.000000) nil)@@@list("sky_zheng" "2013/09/13 10:58:54" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:53" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "24.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "365.89 MIL" "-365.89 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2959.16 867.02) (-2859.19 966.98))" list(-2493.300000 917.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:20" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:40" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "27.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2531.17 6.77) (-2356.22 443.77))" list(-2493.300000 443.770000) nil)@@@list("sky_zheng" "2013/09/13 11:00:33" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:09" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "26.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2516.68 -302.17) (-2379.03 -113.43))" list(-2493.300000 -113.430000) nil)@@@list("sky_zheng" "2013/09/13 11:00:33" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:08" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "31.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2496.91 -491.37) (-2395.69 -427.99))" "[Shape] Package Geometry/Place_Bound_Top ((-2491.3 -488.68) (-2401.3 -430.68))" list(-2491.300000 -488.680000) nil)@@@list("lei_pang" "2013/05/31 11:08:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:18:10" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "4.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2497.31 -556.07) (-2396.09 -492.69))" "[Shape] Package Geometry/Place_Bound_Top ((-2490.5 -553.38) (-2400.5 -495.38))" list(-2490.500000 -553.380000) nil)@@@list("lei_pang" "2013/05/31 11:08:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:22:19" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "103.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "396.56 MIL" "-396.56 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-2531.41 1466.21) (-2431.45 1566.18))" list(-2481.430000 1069.650000) nil)@@@list("lei_pang" "2013/05/31 11:04:47" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Spacing-SameNet] IN1" "32.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN1" "[Line] GND ((-2473.25 -92.94) (-2460.51 -80.2))" "[Line] GND ((-2493.8 -84.2) (-2468.61 -59.01))" list(-2471.250000 -82.200000) nil)@@@list("lei_pang" "2013/05/31 09:35:00" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "12.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-2626.89 -739.3) (-2430.03 -542.44))" list(-2430.030000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 10:59:01" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:59" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "13.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2455.4 -61.7) (-2396.4 -33.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2437.08 -118.41) (-2149.06 -59.39))" list(-2396.400000 -61.700000) nil)@@@list("lei_pang" "2013/05/31 11:03:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:34" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "5.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2393.3 -523.25) (-2353.3 -503.25))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-2353.990000 -503.250000) nil)@@@list("lei_pang" "2013/05/31 11:04:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:16:19" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "4.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2393.3 -544.91) (-2353.3 -524.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-2353.990000 -524.910000) nil)@@@list("lei_pang" "2013/05/31 11:04:51" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:16:18" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "6.Pkg to Pkg Spacing" "55.12 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-3.94 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2832.99 -132.03) (-2226.04 632.94))" "[Shape] Package Geometry/Place_Bound_Top ((-2808.61 -95.39) (-2263.8 597.01))" list(-2303.180000 597.010000) nil)@@@list("lei_pang" "2013/05/31 11:05:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:16:40" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Spacing-SameNet] IN1" "1.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN1" "[Line] GND ((-2296.78 -294.1) (-2274.99 -290.1))" "[Line] GND ((-2278.99 -294.1) (-2274.99 -270.29))" list(-2276.990000 -292.100000) nil)@@@list("lei_pang" "2013/05/31 11:02:49" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:04:33" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Spacing-SameNet] IN1" "2.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN1" "[Line] GND ((-2278.99 -310.58) (-2258.51 -290.1))" "[Line] GND ((-2278.99 -294.1) (-2274.99 -270.29))" list(-2276.990000 -292.100000) nil)@@@list("lei_pang" "2013/05/31 13:05:38" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:04:35" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Spacing-SameNet] IN1" "23.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN1" "[Line] GND ((-2274.35 -341.49) (-2263.68 -330.82))" "[Line] GND ((-2282.03 -356.54) (-2263.68 -338.19))" list(-2265.680000 -339.490000) nil)@@@list("lei_pang" "2013/05/31 11:02:50" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "15.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2250.12 190.5) (-2222.12 249.5))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-2226.030000 249.500000) nil)@@@list("lei_pang" "2013/05/31 11:06:02" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:24" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "65.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "44.09 MIL" "-44.09 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2363.77 454.23) (-2173.45 644.55))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2368.35 336.7) (-2199.05 461.9))" list(-2209.190000 454.230000) nil)@@@list("lei_pang" "2013/05/31 10:37:21" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "37.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2204.58 1133.35) (-2125.42 1176.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2207.54 1131.38) (-2122.46 1178.62))" list(-2204.580000 1133.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:42" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:16" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "38.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2204.58 1083.35) (-2125.42 1126.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2207.54 1081.38) (-2122.46 1128.62))" list(-2204.580000 1083.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:43" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:17" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "36.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2204.58 1033.35) (-2125.42 1076.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2207.54 1031.38) (-2122.46 1078.62))" list(-2204.580000 1033.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:41" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:16" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "34.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2204.58 983.35) (-2125.42 1026.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2207.54 981.38) (-2122.46 1028.62))" list(-2204.580000 983.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:40" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:15" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "35.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2204.58 933.35) (-2125.42 976.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2207.54 931.38) (-2122.46 978.62))" list(-2204.580000 933.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:40" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:16" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "39.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2363.77 454.23) (-2173.45 644.55))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2437.08 630.55) (-2149.06 689.57))" list(-2173.450000 630.550000) nil)@@@list("lei_pang" "2013/05/31 10:36:42" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "64.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "31.5 MIL" "-31.50 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2363.77 454.23) (-2173.45 644.55))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2345.77 472.23) (-2191.45 626.55))" list(-2173.450000 497.430000) nil)@@@list("lei_pang" "2013/05/31 10:37:20" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "1.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2200.17 -396.02) (-2049.83 -273.98))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-2125.000000 -396.020000) nil)@@@list("sky_zheng" "2013/09/13 10:59:55" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:46" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "9.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "41.34 MIL" "-1.97 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2129.71 -145.02) (-1940.29 5.02))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-2104.520000 5.020000) nil)@@@list("sky_zheng" "2013/09/13 11:00:03" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:51" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "11.Pkg to Pkg Spacing" "61.02 MIL [PACKAGE_HEIGHT_MIN]" "70.87 MIL" "-9.85 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2096.3 87.95) (-1883.7 332.05))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2215.47 8.75) (-1861.14 359.13))" list(-2096.300000 87.950000) nil)@@@list("sky_zheng" "2013/09/13 11:00:19" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:52" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "25.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "14.57 MIL" "-14.57 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2126.44 513.56) (-2093.56 546.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2109.0 485.5) (-2081.0 544.5))" list(-2093.560000 513.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:32" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:07" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "22.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2130.12 694.56) (-2019.88 785.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-2075.000000 694.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:18" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:58" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "39.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "370.86 MIL" "-370.86 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2331.41 1466.21) (-2231.45 1566.18))" list(-2057.730000 1138.550000) nil)@@@list("lei_pang" "2013/05/31 11:03:23" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "64.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2055.51 716.82) (-1659.31 1235.15))" list(-2055.510000 1138.550000) nil)@@@list("lei_pang" "2013/05/31 11:03:53" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "2.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-2401.79 1355.19) (-2029.15 1867.01))" list(-2031.530000 1727.520000) nil)@@@list("sky_zheng" "2013/09/13 10:58:53" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:52" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "119.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-2002.760000 686.940000) nil)@@@list("lei_pang" "2013/05/31 11:06:03" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "4.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-2002.760000 686.940000) nil)@@@list("lei_pang" "2013/05/31 13:06:03" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:28:14" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "138.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2026.1 228.8) (-1998.1 287.8))" "[Shape] Package Geometry/Place_Bound_Top ((-2003.33 283.52) (-1971.51 315.34))" list(-1998.280000 287.800000) nil)@@@list("lei_pang" "2013/05/31 11:06:25" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "139.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1974.5 255.5) (-1946.5 314.5))" "[Shape] Package Geometry/Place_Bound_Top ((-2003.33 283.52) (-1971.51 315.34))" list(-1974.500000 290.150000) nil)@@@list("lei_pang" "2013/05/31 11:06:40" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "164.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1974.5 255.5) (-1946.5 314.5))" "[Shape] Package Geometry/Place_Bound_Top ((-1993.41 224.09) (-1961.59 255.91))" list(-1973.910000 255.500000) nil)@@@list("lei_pang" "2013/05/31 10:49:46" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "2.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-2045.17 -396.02) (-1894.83 -273.98))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1970.000000 -396.020000) nil)@@@list("sky_zheng" "2013/09/13 10:59:56" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:46" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "165.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1974.5 255.5) (-1946.5 314.5))" "[Shape] Package Geometry/Place_Bound_Top ((-1950.41 267.29) (-1918.59 299.11))" list(-1946.500000 272.750000) nil)@@@list("lei_pang" "2013/05/31 10:49:47" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "107.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1961.17 561.83) (-1933.17 620.83))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1933.74 534.76) (-1874.74 562.76))" list(-1933.170000 561.830000) nil)@@@list("lei_pang" "2013/05/31 10:48:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "14.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-1892.63 1341.43) (-1380.81 1941.82))" list(-1892.630000 1738.090000) nil)@@@list("sky_zheng" "2013/09/13 10:59:41" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:00" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "35.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "35.43 MIL" "-35.43 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1861.44 446.56) (-1828.56 479.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1894.02 381.89) (-1795.98 468.11))" list(-1861.440000 446.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:30" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:50" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "32.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1809.0 262.5) (-1781.0 321.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1858.0 284.0) (-1806.0 336.0))" list(-1808.680000 321.500000) nil)@@@list("sky_zheng" "2013/09/13 11:00:27" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:48" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "49.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1806.38 -356.5) (-1723.62 -313.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1792.44 -352.44) (-1759.56 -319.56))" list(-1792.440000 -352.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:55" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:24" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "50.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1806.38 -311.5) (-1723.62 -268.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1770.44 -311.44) (-1737.56 -278.56))" list(-1770.440000 -311.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:56" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:24" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "13.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1753.44 136.19) (-1666.56 253.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1753.440000 195.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:06" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:53" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "197.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1762.91 93.09) (-1731.09 124.91))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1753.91 67.09) (-1722.09 98.91))" list(-1750.050000 93.390000) nil)@@@list("sky_zheng" "2013/09/13 11:00:44" nil "RDD_704_PC" "g1t-oxygen.10")@@@nil | list("[Package] BOTTOM" "49.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1726.66 193.54) (-1693.78 226.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1748.65 87.04) (-1677.79 292.92))" list(-1726.660000 193.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:25" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:54" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "48.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1726.66 154.54) (-1693.78 187.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1748.65 87.04) (-1677.79 292.92))" list(-1726.660000 154.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:23" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:53" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "7.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1778.49 -512.02) (-1719.49 -484.02))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1719.490000 -508.960000) nil)@@@list("lei_pang" "2013/05/31 11:05:55" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:16:49" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "45.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1721.5 48.62) (-1678.5 131.38))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1712.44 62.56) (-1679.56 95.44))" list(-1712.440000 62.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:51" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:22" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "44.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1888.61 630.55) (-1600.59 689.57))" list(-1709.060000 689.570000) nil)@@@list("lei_pang" "2013/05/31 11:03:30" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "7.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1888.61 630.55) (-1600.59 689.57))" list(-1709.060000 689.570000) nil)@@@list("lei_pang" "2013/05/31 13:06:07" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:54" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "97.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1686.87 -584.28) (-1072.13 -437.72))" list(-1686.870000 -567.200000) nil)@@@list("lei_pang" "2013/05/31 11:04:41" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "46.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1676.5 48.62) (-1633.5 131.38))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1670.44 85.06) (-1637.56 117.94))" list(-1670.440000 85.060000) nil)@@@list("sky_zheng" "2013/09/13 11:00:52" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:23" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "27.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1669.0 -299.5) (-1641.0 -240.5))" "[Shape] Package Geometry/Place_Bound_Top ((-1691.44 -301.44) (-1658.56 -268.56))" list(-1669.000000 -299.500000) nil)@@@list("sky_zheng" "2013/09/13 10:59:54" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:45" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "3.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1718.81 -268.44) (-1601.19 -181.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1660.000000 -268.440000) nil)@@@list("sky_zheng" "2013/09/13 10:59:57" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:47" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "8.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1717.49 -512.02) (-1658.49 -484.02))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1658.490000 -508.960000) nil)@@@list("lei_pang" "2013/05/31 11:05:54" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:16:55" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "60.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1670.6 457.5) (-1642.6 516.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1644.14 454.06) (-1611.26 486.94))" list(-1642.600000 457.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:38" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:38" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "21.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1633.81 321.56) (-1516.19 408.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1633.810000 408.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:17" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:57" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "11.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1598.89 -45.1) (-1567.07 -13.28))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1580.530000 -13.470000) nil)@@@list("lei_pang" "2013/05/31 11:05:57" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:11" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "50.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1571.95 -268.46) (-1539.07 -235.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1604.89 -274.52) (-1522.13 -231.52))" list(-1571.950000 -268.460000) nil)@@@list("lei_pang" "2013/05/31 11:04:26" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:58" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "12.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1595.32 39.09) (-1543.32 91.09))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1560.820000 40.520000) nil)@@@list("lei_pang" "2013/05/31 11:05:59" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:14" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "54.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1566.38 463.5) (-1483.62 506.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1553.44 462.56) (-1520.56 495.44))" list(-1553.440000 463.500000) nil)@@@list("sky_zheng" "2013/09/13 11:01:01" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:26" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "4.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1598.81 -268.44) (-1481.19 -181.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1540.000000 -268.440000) nil)@@@list("sky_zheng" "2013/09/13 10:59:58" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:48" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "53.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1566.38 418.5) (-1483.62 461.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1529.94 423.56) (-1497.06 456.44))" list(-1529.940000 423.560000) nil)@@@list("sky_zheng" "2013/09/13 11:01:00" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:25" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "59.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1525.51 520.47) (-1497.51 579.47))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1528.44 566.56) (-1495.56 599.44))" list(-1525.510000 579.470000) nil)@@@list("lei_pang" "2013/05/31 11:04:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:29" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "41.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1531.38 233.5) (-1448.62 276.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1518.44 243.56) (-1485.56 276.44))" list(-1518.440000 243.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:47" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:19" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "15.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1508.44 296.19) (-1421.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1508.440000 413.810000) nil)@@@list("sky_zheng" "2013/09/13 11:00:08" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:54" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "58.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1496.51 520.47) (-1468.51 579.47))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1528.44 566.56) (-1495.56 599.44))" list(-1496.510000 579.470000) nil)@@@list("lei_pang" "2013/05/31 11:04:35" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:21" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "9.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1551.99 -41.36) (-1492.99 -13.36))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1492.990000 -13.470000) nil)@@@list("lei_pang" "2013/05/31 11:05:56" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:01" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "52.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1481.56 -55.46) (-1448.68 -22.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1483.62 -86.4) (-1440.62 -3.64))" list(-1481.560000 -55.460000) nil)@@@list("lei_pang" "2013/05/31 11:04:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:03" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "10.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1492.33 -65.23) (-1440.33 -13.23))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1462.810000 -13.470000) nil)@@@list("lei_pang" "2013/05/31 11:05:58" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:07" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "42.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1476.38 -136.5) (-1393.62 -93.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1462.44 -131.44) (-1429.56 -98.56))" list(-1462.440000 -131.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:48" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:20" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "40.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1531.38 233.5) (-1448.62 276.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1480.44 217.56) (-1447.56 250.44))" list(-1448.620000 233.500000) nil)@@@list("sky_zheng" "2013/09/13 11:00:46" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:18" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "39.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1631.54 -88.11) (-1118.46 228.11))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1480.44 217.56) (-1447.56 250.44))" list(-1447.560000 228.110000) nil)@@@list("sky_zheng" "2013/09/13 11:00:45" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:17" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "53.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1439.46 -106.46) (-1406.58 -73.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1440.62 -86.4) (-1397.62 -3.64))" list(-1439.460000 -73.580000) nil)@@@list("lei_pang" "2013/05/31 11:04:29" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:05" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "51.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1413.99 286.54) (-1381.11 319.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1419.05 269.17) (-1376.05 351.93))" list(-1413.990000 286.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:02" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "16.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1413.44 296.19) (-1326.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1413.440000 413.810000) nil)@@@list("sky_zheng" "2013/09/13 11:00:09" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:55" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "44.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1476.38 -136.5) (-1393.62 -93.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1424.44 -110.44) (-1391.56 -77.56))" list(-1393.620000 -93.500000) nil)@@@list("sky_zheng" "2013/09/13 11:00:50" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:21" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "43.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1631.54 -88.11) (-1118.46 228.11))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1424.44 -110.44) (-1391.56 -77.56))" list(-1391.560000 -88.110000) nil)@@@list("sky_zheng" "2013/09/13 11:00:49" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:21" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "13.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1404.52 40.22) (-1352.52 92.22))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1374.580000 40.520000) nil)@@@list("lei_pang" "2013/05/31 11:06:01" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:17" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "55.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1370.99 302.54) (-1338.11 335.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1376.05 269.17) (-1333.05 351.93))" list(-1370.990000 302.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:31" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:10" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "54.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1320.66 472.54) (-1287.78 505.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1337.6 465.48) (-1254.84 508.48))" list(-1320.660000 472.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:30" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:06" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "14.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1348.69 40.4) (-1296.69 92.4))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-1320.190000 40.520000) nil)@@@list("lei_pang" "2013/05/31 11:06:02" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:20" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "17.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1318.44 296.19) (-1231.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1318.440000 413.810000) nil)@@@list("sky_zheng" "2013/09/13 11:00:14" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:56" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "47.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1311.5 -381.38) (-1268.5 -298.62))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1302.44 -367.44) (-1269.56 -334.56))" list(-1302.440000 -367.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:53" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:23" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "51.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1311.38 418.5) (-1228.62 461.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1297.44 428.56) (-1264.56 461.44))" list(-1297.440000 428.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:57" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:25" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "57.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1282.66 -163.46) (-1249.78 -130.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1288.72 -196.4) (-1245.72 -113.64))" list(-1282.660000 -163.460000) nil)@@@list("lei_pang" "2013/05/31 11:04:34" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:16" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "145.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-1281.83 916.18) (-1125.93 1109.88))" list(-1281.830000 1109.020000) nil)@@@list("lei_pang" "2013/05/31 11:08:33" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "56.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1308.66 -198.46) (-1275.78 -165.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1288.72 -196.4) (-1245.72 -113.64))" list(-1275.780000 -165.580000) nil)@@@list("lei_pang" "2013/05/31 11:04:33" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:16" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "52.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1311.38 463.5) (-1228.62 506.5))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1274.94 469.56) (-1242.06 502.44))" list(-1274.940000 469.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:59" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:25" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "28.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2072.88 -733.18) (-1271.44 -477.35))" list(-1271.440000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 11:00:23" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:43" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "48.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1266.5 -381.38) (-1223.5 -298.62))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1262.44 -345.44) (-1229.56 -312.56))" list(-1262.440000 -345.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:55" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:24" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "30.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1246.96 -735.36) (-695.78 -579.65))" list(-1246.960000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 11:00:25" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:45" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "5.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1308.44 -278.81) (-1221.56 -161.19))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1221.560000 -275.780000) nil)@@@list("sky_zheng" "2013/09/13 10:59:59" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:48" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "14.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1208.4 -323.7) (-1188.4 -283.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1308.97 -382.45) (-1020.95 -323.43))" list(-1208.400000 -323.700000) nil)@@@list("lei_pang" "2013/05/31 11:03:31" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:38" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "6.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1220.44 -278.81) (-1133.56 -161.19))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1180.040000 -278.810000) nil)@@@list("sky_zheng" "2013/09/13 11:00:00" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:49" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "38.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "35.43 MIL" "-35.43 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1180.22 553.54) (-1147.34 586.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1168.38 522.5) (-1085.62 565.5))" list(-1147.340000 553.540000) nil)@@@list("lei_pang" "2013/05/31 11:04:04" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:57" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "18.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1223.44 296.19) (-1136.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1136.560000 355.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:12" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:56" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Spacing-SameNet] IN1" "24.Line to Line Same Net" "3 MIL [DEFAULT]" "2.75 MIL" "0.25 MIL" "DRC ERROR CLASS/IN1" "[Line] +V3P3SX ((-1144.87 -247.88) (-953.43 -227.88))" "[Line] +V3P3SX ((-1158.58 -230.33) (-1142.42 -220.33))" list(-1134.870000 -237.880000) nil)@@@list("lei_pang" "2013/05/31 11:02:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "41.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1130.17 -301.69) (-1090.17 -281.69))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1150.17 -301.69) (-1110.17 -281.69))" list(-1130.170000 -301.690000) nil)@@@list("lei_pang" "2013/05/31 11:04:14" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:37" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "42.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1130.17 -321.69) (-1090.17 -301.69))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1150.17 -321.69) (-1110.17 -301.69))" list(-1130.170000 -321.690000) nil)@@@list("lei_pang" "2013/05/31 11:04:16" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:38" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "4.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "35.43 MIL" "-35.43 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1127.97 -50.42) (-1095.09 -17.54))" "[Shape] Package Geometry/Place_Bound_Top ((-1158.75 -129.91) (-1115.75 -47.15))" list(-1127.970000 -50.420000) nil)@@@list("lei_pang" "2013/05/31 11:08:43" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:28:10" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "10.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "64.96 MIL" "-64.96 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1631.54 -88.11) (-1118.46 228.11))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1118.460000 -272.750000) nil)@@@list("sky_zheng" "2013/09/13 11:00:05" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:52" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "40.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1150.17 -281.69) (-1110.17 -261.69))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1130.17 -281.69) (-1090.17 -261.69))" list(-1110.170000 -281.690000) nil)@@@list("lei_pang" "2013/05/31 11:04:14" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:36" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "23.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1389.96 688.78) (-760.04 1161.22))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1075.000000 1161.220000) nil)@@@list("sky_zheng" "2013/09/13 11:00:19" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:04" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "43.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1069.87 -281.79) (-1029.87 -261.79))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1089.87 -281.79) (-1049.87 -261.79))" list(-1069.870000 -281.790000) nil)@@@list("lei_pang" "2013/05/31 11:04:16" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:39" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "46.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1069.87 -321.79) (-1029.87 -301.79))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1089.87 -321.79) (-1049.87 -301.79))" list(-1069.870000 -321.790000) nil)@@@list("lei_pang" "2013/05/31 11:04:22" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:42" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "44.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1089.87 -241.79) (-1049.87 -221.79))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1069.87 -241.79) (-1029.87 -221.79))" list(-1049.870000 -241.790000) nil)@@@list("lei_pang" "2013/05/31 11:04:18" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:40" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "45.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1089.87 -261.79) (-1049.87 -241.79))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1069.87 -261.79) (-1029.87 -241.79))" list(-1049.870000 -261.790000) nil)@@@list("lei_pang" "2013/05/31 11:04:19" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:41" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "47.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1089.87 -301.79) (-1049.87 -281.79))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1069.87 -301.79) (-1029.87 -281.79))" list(-1049.870000 -301.790000) nil)@@@list("lei_pang" "2013/05/31 11:04:21" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:43" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "19.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1128.44 296.19) (-1041.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1041.560000 355.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:14" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:56" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "34.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "35.43 MIL" "-35.43 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1128.44 296.19) (-1041.56 413.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1116.38 253.5) (-1033.62 296.5))" list(-1041.560000 296.190000) nil)@@@list("sky_zheng" "2013/09/13 11:00:29" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:50" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "7.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1128.44 -278.81) (-1041.56 -161.19))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-1041.560000 -272.750000) nil)@@@list("sky_zheng" "2013/09/13 11:00:01" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:49" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "39.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "31.5 MIL" "-31.50 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-997.15 526.95) (-964.27 559.83))" "[Shape] Package Geometry/Place_Bound_Bottom ((-1084.46 485.87) (-981.7 600.73))" list(-997.150000 526.950000) nil)@@@list("lei_pang" "2013/05/31 11:04:08" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:25:29" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "25.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-985.65 1512.42) (-942.35 1591.58))" "[Shape] Package Geometry/Place_Bound_Top ((-987.62 1509.46) (-940.38 1594.54))" list(-985.650000 1512.420000) nil)@@@list("sky_zheng" "2013/09/13 10:59:52" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:13" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "137.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-1083.91 902.54) (-969.35 958.06))" list(-977.960000 902.540000) nil)@@@list("lei_pang" "2013/05/31 11:06:24" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "146.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-1026.21 768.75) (-974.21 820.75))" list(-977.960000 781.300000) nil)@@@list("lei_pang" "2013/05/31 11:08:34" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "6.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Top ((-1026.21 768.75) (-974.21 820.75))" list(-977.960000 781.300000) nil)@@@list("lei_pang" "2013/05/31 13:06:05" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:26" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "12.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1031.81 -103.44) (-914.19 -16.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-973.000000 -103.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:05" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:53" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "8.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1031.81 -198.44) (-914.19 -111.56))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-973.000000 -198.440000) nil)@@@list("sky_zheng" "2013/09/13 11:00:02" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:50" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "126.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "59.06 MIL" "-59.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-986.07 -501.41) (-516.99 -331.17))" "[Shape] Package Geometry/Place_Bound_Top ((-2886.99 -562.96) (-970.62 686.94))" list(-970.620000 -331.170000) nil)@@@list("lei_pang" "2013/05/31 10:48:54" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "166.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "72.44 MIL" "-72.44 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-986.07 -501.41) (-516.99 -331.17))" "[Shape] Package Geometry/Place_Bound_Top ((-968.07 -483.41) (-534.99 -349.17))" list(-968.070000 -483.410000) nil)@@@list("lei_pang" "2013/05/31 10:49:49" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "66.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "43.31 MIL" "-43.31 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-950.2 -497.09) (-552.0 -307.55))" "[Shape] Package Geometry/Place_Bound_Bottom ((-932.2 -479.09) (-570.0 -325.55))" list(-932.200000 -479.090000) nil)@@@list("lei_pang" "2013/05/31 10:37:22" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "20.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1031.81 261.56) (-914.19 348.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-914.190000 305.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:16" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:57" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "14.Pkg to Pkg Spacing" "39.37 MIL [PACKAGE_HEIGHT_MIN]" "47.24 MIL" "-7.87 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1031.81 166.56) (-914.19 253.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-2220.99 -406.22) (-727.67 1189.46))" list(-914.190000 210.000000) nil)@@@list("sky_zheng" "2013/09/13 11:00:07" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:01:54" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Electrical] ALL" "2.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "382.5 MIL" "-182.50 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId2404<uTiL>.G3:<uTiL>cId23<uTiL>.D6 ((-827.83 -392.45) (-201.42 280.5))" "[PinPair] <uTiL>cId2404<uTiL>.F1:<uTiL>cId23<uTiL>.C5 ((-847.52 -431.82) (-212.56 269.36))" list(-847.520000 -431.820000) nil)@@@list("sky_zheng" "2013/09/13 10:58:51" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:49" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "24.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "35.43 MIL" "-35.43 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-791.44 538.56) (-758.56 571.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((-853.11 505.98) (-766.89 604.02))" list(-791.440000 538.560000) nil)@@@list("sky_zheng" "2013/09/13 11:00:30" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:06" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "1.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-1134.76 1640.89) (-741.06 1890.62))" list(-741.060000 1814.130000) nil)@@@list("sky_zheng" "2013/09/13 10:58:52" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:52" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Spacing-SameNet] IN4" "25.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN4" "[Line] +V1P8A ((-796.88 93.43) (-624.73 265.58))" "[Line] +V1P8A ((-934.27 7.3) (-756.88 184.69))" list(-736.440000 205.140000) nil)@@@list("lei_pang" "2013/05/31 11:02:53" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "21.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-696.65 1390.42) (-653.35 1469.58))" "[Shape] Package Geometry/Place_Bound_Top ((-698.62 1387.46) (-651.38 1472.54))" list(-696.650000 1390.420000) nil)@@@list("sky_zheng" "2013/09/13 10:59:49" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:04" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "29.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-644.6 -735.36) (-93.42 -579.65))" list(-644.600000 -713.980000) nil)@@@list("sky_zheng" "2013/09/13 11:00:24" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:44" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "35.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-642.79 -126.11) (-579.41 -24.89))" "[Shape] Package Geometry/Place_Bound_Bottom ((-640.1 -120.5) (-582.1 -30.5))" list(-640.100000 -120.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:00" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:47" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "37.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-637.55 445.51) (-574.17 546.73))" "[Shape] Package Geometry/Place_Bound_Bottom ((-634.86 451.12) (-576.86 541.12))" list(-634.860000 451.120000) nil)@@@list("lei_pang" "2013/05/31 11:04:03" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:52" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "36.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-637.48 550.99) (-574.1 652.21))" "[Shape] Package Geometry/Place_Bound_Bottom ((-634.79 556.6) (-576.79 646.6))" list(-634.790000 556.600000) nil)@@@list("lei_pang" "2013/05/31 11:04:01" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:50" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Electrical] ALL" "8.Diffpair Phase Tolerance" "5 [DIFFP_PHASE_TOL]" "29.8 MIL" "-24.80 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId76<uTiL>.1:<uTiL>cId23<uTiL>.E5 ((-625.5 208.2) (-187.56 36.64))" "[PinPair] <uTiL>cId75<uTiL>.1:<uTiL>cId23<uTiL>.F4 ((-625.5 166.4) (-198.7 47.78))" list(-625.500000 166.400000) nil)@@@list("lei_pang" "2013/05/31 11:03:02" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:00:33" nil "amy_shiu-pc2" "15t_ns_mb.100") | list("[Package] TOP" "22.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-621.65 1390.42) (-578.35 1469.58))" "[Shape] Package Geometry/Place_Bound_Top ((-623.62 1387.46) (-576.38 1472.54))" list(-621.650000 1390.420000) nil)@@@list("sky_zheng" "2013/09/13 10:59:50" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:05" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Electrical] ALL" "10.Diffpair Phase Tolerance" "5 [DIFFP_PHASE_TOL]" "26.02 MIL" "-21.02 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.H4:<uTiL>cId1621<uTiL>.1 ((-198.7 70.06) (-590.7 166.4))" "[PinPair] <uTiL>cId23<uTiL>.G3:<uTiL>cId1620<uTiL>.1 ((-209.84 58.92) (-590.7 205.65))" list(-590.700000 205.650000) nil)@@@list("lei_pang" "2013/05/31 11:03:07" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:00:44" nil "amy_shiu-pc2" "15t_ns_mb.100") | list("[Package] BOTTOM" "26.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-630.5 -254.06) (-587.5 -171.3))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-587.500000 -254.060000) nil)@@@list("lei_pang" "2013/05/31 11:03:49" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:14" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "28.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-583.5 -254.06) (-540.5 -171.3))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-583.500000 -254.060000) nil)@@@list("lei_pang" "2013/05/31 11:03:51" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:18" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "33.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-575.96 -126.17) (-512.58 -24.95))" "[Shape] Package Geometry/Place_Bound_Bottom ((-573.27 -120.56) (-515.27 -30.56))" list(-573.270000 -120.560000) nil)@@@list("lei_pang" "2013/05/31 11:03:58" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:38" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "30.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-569.41 16.98) (-506.03 118.2))" "[Shape] Package Geometry/Place_Bound_Bottom ((-566.72 22.59) (-508.72 112.59))" list(-566.720000 22.590000) nil)@@@list("lei_pang" "2013/05/31 11:03:54" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:25" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Spacing-SameNet] IN8" "30.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN8" "[Line] +V3P3A ((-758.54 -444.26) (-552.65 -429.26))" "[Line] +V3P3A ((-556.81 -444.94) (-526.01 -429.94))" list(-560.150000 -436.760000) nil)@@@list("lei_pang" "2013/05/31 11:02:58" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "15.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-573.3 672.12) (-553.3 712.12))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-553.300000 712.120000) nil)@@@list("lei_pang" "2013/05/31 11:03:32" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:43" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "57.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-950.2 -497.09) (-552.0 -307.55))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-552.000000 -307.550000) nil)@@@list("lei_pang" "2013/05/31 10:37:03" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "23.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-546.65 1390.42) (-503.35 1469.58))" "[Shape] Package Geometry/Place_Bound_Top ((-548.62 1387.46) (-501.38 1472.54))" list(-546.650000 1390.420000) nil)@@@list("sky_zheng" "2013/09/13 10:59:51" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:05" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "16.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-542.9 652.7) (-514.9 711.7))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-542.900000 711.700000) nil)@@@list("lei_pang" "2013/05/31 11:03:33" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:45" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "27.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-536.5 -253.76) (-493.5 -171.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-536.500000 -253.760000) nil)@@@list("lei_pang" "2013/05/31 11:03:50" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:15" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "17.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-514.0 692.0) (-474.0 712.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-514.000000 712.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:34" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:46" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "32.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-508.89 -126.45) (-445.51 -25.23))" "[Shape] Package Geometry/Place_Bound_Bottom ((-506.2 -120.84) (-448.2 -30.84))" list(-506.200000 -120.840000) nil)@@@list("lei_pang" "2013/05/31 11:03:57" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:31" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "31.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-503.25 17.39) (-439.87 118.61))" "[Shape] Package Geometry/Place_Bound_Bottom ((-500.56 23.0) (-442.56 113.0))" list(-500.560000 23.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:56" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:28" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "58.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-499.45 -583.75) (-309.91 -303.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-499.450000 -303.650000) nil)@@@list("lei_pang" "2013/05/31 10:37:05" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "81.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-499.45 -583.75) (-309.91 -303.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-551.56 -512.48) (-496.44 -430.54))" list(-496.440000 -491.200000) nil)@@@list("lei_pang" "2013/05/31 10:37:47" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "29.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-489.5 -253.76) (-446.5 -171.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-628.79 -312.45) (-340.77 -253.43))" list(-489.500000 -253.760000) nil)@@@list("lei_pang" "2013/05/31 11:03:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:22" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "67.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "43.31 MIL" "-43.31 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-499.45 -583.75) (-309.91 -303.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-481.45 -565.75) (-327.91 -321.65))" list(-481.450000 -565.750000) nil)@@@list("lei_pang" "2013/05/31 10:37:24" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "24.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-471.65 1390.42) (-428.35 1469.58))" "[Shape] Package Geometry/Place_Bound_Top ((-473.62 1387.46) (-426.38 1472.54))" list(-471.650000 1390.420000) nil)@@@list("sky_zheng" "2013/09/13 10:59:51" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:06" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "18.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-467.3 672.4) (-447.3 712.4))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-467.300000 712.400000) nil)@@@list("lei_pang" "2013/05/31 11:03:36" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:47" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "79.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-449.91 -420.37) (-378.47 -309.57))" "[Shape] Package Geometry/Place_Bound_Top ((-468.2 -359.01) (-448.2 -319.01))" list(-449.910000 -359.010000) nil)@@@list("lei_pang" "2013/05/31 09:59:46" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "98.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-449.91 -420.37) (-378.47 -309.57))" "[Shape] Package Geometry/Place_Bound_Top ((-468.6 -411.3) (-448.6 -371.3))" list(-449.910000 -411.300000) nil)@@@list("lei_pang" "2013/05/31 10:00:09" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "19.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-444.8 672.4) (-424.8 712.4))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-444.800000 712.400000) nil)@@@list("lei_pang" "2013/05/31 11:03:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:48" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "176.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-449.91 -420.37) (-378.47 -309.57))" "[Shape] Package Geometry/Place_Bound_Top ((-431.91 -402.37) (-396.47 -327.57))" list(-431.910000 -402.370000) nil)@@@list("lei_pang" "2013/05/31 10:50:02" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "30.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-379.58 1256.35) (-300.42 1299.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-382.54 1254.38) (-297.46 1301.62))" list(-379.580000 1256.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:36" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:13" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "29.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-379.58 1207.35) (-300.42 1250.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-382.54 1205.38) (-297.46 1252.62))" list(-379.580000 1207.350000) nil)@@@list("sky_zheng" "2013/09/13 11:00:35" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:10" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "20.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-348.58 -276.12) (-305.28 -196.96))" "[Shape] Package Geometry/Place_Bound_Top ((-350.55 -279.08) (-303.31 -194.0))" list(-348.580000 -276.120000) nil)@@@list("sky_zheng" "2013/09/13 10:59:48" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:04" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "15.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((-637.98 1581.4) (-348.02 1888.06))" list(-348.040000 1814.130000) nil)@@@list("sky_zheng" "2013/09/13 10:59:42" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:01" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "111.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-499.45 -583.75) (-309.91 -303.65))" list(-333.720000 -583.750000) nil)@@@list("lei_pang" "2013/05/31 10:48:35" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "1.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "64.96 MIL" "-64.96 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-319.85 183.12) (429.45 932.42))" "[Shape] Package Geometry/Place_Bound_Bottom ((-606.81 -406.22) (1317.61 1120.56))" list(-319.850000 1120.560000) nil)@@@list("sky_zheng" "2013/09/13 10:59:54" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:51" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "21.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-309.0 672.6) (-289.0 712.6))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-309.000000 712.600000) nil)@@@list("lei_pang" "2013/05/31 11:03:39" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:53" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "20.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-287.0 672.6) (-267.0 712.6))" "[Shape] Package Geometry/Place_Bound_Bottom ((-568.53 710.45) (-280.51 769.47))" list(-287.000000 712.600000) nil)@@@list("lei_pang" "2013/05/31 11:03:38" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:52" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "120.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-269.55 -877.41) (-210.53 -589.39))" list(-268.360000 -877.410000) nil)@@@list("lei_pang" "2013/05/31 11:06:04" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "5.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Top ((-269.55 -877.41) (-210.53 -589.39))" list(-268.360000 -877.410000) nil)@@@list("lei_pang" "2013/05/31 13:06:04" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:23:18" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "61.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "40.59 MIL" "-40.59 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-272.85 -48.65) (432.45 656.65))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.85 -30.65) (414.45 638.65))" list(-254.850000 -30.650000) nil)@@@list("lei_pang" "2013/05/31 11:04:40" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:26:51" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "147.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-210.85 625.46) (340.34 1304.38))" list(-209.790000 1117.970000) nil)@@@list("lei_pang" "2013/05/31 11:08:35" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "153.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((-202.27 -1374.63) (-170.45 -1342.81))" list(-192.250000 -1373.500000) nil)@@@list("lei_pang" "2013/05/31 10:01:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Electrical] ALL" "9.Diffpair Phase Tolerance" "5 [DIFFP_PHASE_TOL]" "5.12 MIL" "-0.12 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.J9:<uTiL>cId1619<uTiL>.1 ((-143.0 81.2) (-555.4 166.4))" "[PinPair] <uTiL>cId23<uTiL>.K8:<uTiL>cId1618<uTiL>.1 ((-154.14 92.34) (-555.4 208.2))" list(-154.140000 92.340000) nil)@@@list("lei_pang" "2013/05/31 11:03:05" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:00:34" nil "amy_shiu-pc2" "15t_ns_mb.100") | list("[Package] BOTTOM" "70.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-139.68 -391.52) (-73.36 -325.2))" "[Shape] Package Geometry/Place_Bound_Bottom ((-121.68 -373.52) (-91.36 -343.2))" list(-121.680000 -373.520000) nil)@@@list("lei_pang" "2013/05/31 10:37:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "69.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-80.64 -617.41) (-9.2 -506.61))" "[Shape] Package Geometry/Place_Bound_Bottom ((-62.64 -599.41) (-27.2 -524.61))" list(-62.640000 -599.410000) nil)@@@list("lei_pang" "2013/05/31 10:37:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "155.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "31.5 MIL" "-31.50 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((-16.08 -810.92) (200.84 -594.0))" list(-34.080000 -692.620000) nil)@@@list("lei_pang" "2013/05/31 10:49:35" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "99.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((-50.7 -750.2) (-30.7 -710.2))" list(-34.080000 -750.200000) nil)@@@list("lei_pang" "2013/05/31 10:00:10" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "66.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((-80.4 -824.9) (-28.4 -772.9))" list(-28.880000 -803.900000) nil)@@@list("lei_pang" "2013/05/31 09:59:08" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "92.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((60.0 -576.22) (88.0 -517.22))" list(60.000000 -576.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:59" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "33.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((-282.4 1206.97) (60.12 1380.01))" list(60.120000 1361.380000) nil)@@@list("sky_zheng" "2013/09/13 11:00:28" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:49" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "18.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((88.7 -890.3) (116.7 -831.3))" "[Shape] Package Geometry/Place_Bound_Top ((88.39 -948.87) (376.41 -889.85))" list(88.700000 -890.300000) nil)@@@list("lei_pang" "2013/05/31 11:06:08" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:36" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "19.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((118.6 -890.3) (146.6 -831.3))" "[Shape] Package Geometry/Place_Bound_Top ((88.39 -948.87) (376.41 -889.85))" list(118.600000 -890.300000) nil)@@@list("lei_pang" "2013/05/31 11:06:09" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:38" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "16.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((119.8 -22.44) (147.8 36.56))" "[Shape] Package Geometry/Place_Bound_Top ((67.17 34.33) (355.19 93.35))" list(119.800000 36.560000) nil)@@@list("lei_pang" "2013/05/31 11:06:05" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:27" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "80.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((172.83 -578.04) (192.83 -538.04))" list(172.830000 -576.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:48" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "74.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((195.8 -577.6) (253.8 -487.6))" list(195.800000 -576.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "17.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((213.0 -5.3) (233.0 34.7))" "[Shape] Package Geometry/Place_Bound_Top ((67.17 34.33) (355.19 93.35))" list(213.000000 34.700000) nil)@@@list("lei_pang" "2013/05/31 11:06:07" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:30" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "78.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-34.08 -828.92) (218.84 -576.0))" "[Shape] Package Geometry/Place_Bound_Top ((215.53 -731.06) (297.47 -675.94))" list(218.840000 -727.690000) nil)@@@list("lei_pang" "2013/05/31 09:59:45" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "100.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((234.48 -48.24) (254.48 -8.24))" list(240.930000 -48.240000) nil)@@@list("lei_pang" "2013/05/31 10:00:11" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "156.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((256.08 -48.24) (276.08 -8.24))" list(256.080000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 11:08:44" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "154.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-129.37 -1382.68) (485.37 -1236.12))" "[Shape] Package Geometry/Place_Bound_Bottom ((246.99 -1327.8) (278.81 -1295.98))" list(262.900000 -1295.980000) nil)@@@list("lei_pang" "2013/05/31 10:01:38" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Electrical] ALL" "35.Diffpair Phase Tolerance" "5 [DIFFP_PHASE_TOL]" "18.53 MIL" "-13.53 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.AM50:<uTiL>cId312<uTiL>.1 ((291.46 315.14) (332.8 806.9))" "[PinPair] <uTiL>cId23<uTiL>.AM48:<uTiL>cId313<uTiL>.2 ((269.18 315.14) (325.92 773.61))" list(269.180000 315.140000) nil)@@@list("lei_pang" "2013/05/31 11:03:10" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "157.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((278.58 -48.24) (298.58 -8.24))" list(278.580000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 11:08:45" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "101.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((301.08 -48.24) (321.08 -8.24))" list(301.080000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:12" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "20.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((302.73 -890.06) (322.73 -850.06))" "[Shape] Package Geometry/Place_Bound_Top ((88.39 -948.87) (376.41 -889.85))" list(302.730000 -890.060000) nil)@@@list("lei_pang" "2013/05/31 11:06:11" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:41" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "102.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((323.58 -48.24) (343.58 -8.24))" list(323.580000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:13" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "156.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((326.03 -878.59) (480.15 -724.47))" "[Shape] Package Geometry/Place_Bound_Top ((344.03 -860.59) (462.15 -742.47))" list(344.030000 -860.590000) nil)@@@list("lei_pang" "2013/05/31 10:49:37" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "103.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((346.64 -48.24) (366.64 -8.24))" list(346.640000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:15" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "34.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((350.17 -1317.58) (451.39 -1254.2))" "[Shape] Package Geometry/Place_Bound_Bottom ((355.78 -1314.89) (445.78 -1256.89))" list(355.780000 -1314.890000) nil)@@@list("lei_pang" "2013/05/31 11:03:59" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:43" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "114.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((-228.85 607.46) (358.34 1322.38))" list(356.630000 1085.740000) nil)@@@list("lei_pang" "2013/05/31 10:00:34" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "91.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-228.85 607.46) (358.34 1322.38))" "[Shape] Package Geometry/Place_Bound_Top ((353.9 930.5) (381.9 989.5))" list(356.630000 930.500000) nil)@@@list("lei_pang" "2013/05/31 09:59:58" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "67.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "53.15 MIL" "-53.15 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-228.85 607.46) (358.34 1322.38))" "[Shape] Package Geometry/Place_Bound_Top ((-210.85 625.46) (340.34 1304.38))" list(356.630000 625.460000) nil)@@@list("lei_pang" "2013/05/31 09:59:09" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "104.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((368.58 -48.24) (388.58 -8.24))" list(368.580000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:16" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "97.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((393.68 -48.6) (421.68 10.4))" list(393.680000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:05" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "94.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((421.8 -48.6) (449.8 10.4))" list(421.800000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:02" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Spacing-SameNet] IN6" "26.Line to Line Same Net" "3 MIL [DEFAULT]" "0 MIL" "3.00 MIL" "DRC ERROR CLASS/IN6" "[Line] GND ((422.59 -1171.61) (425.59 -1167.07))" "[Line] GND ((422.13 -1170.07) (425.59 -1167.07))" list(424.090000 -1168.570000) nil)@@@list("lei_pang" "2013/05/31 11:02:54" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "8.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((426.39 582.31) (527.61 645.69))" "[Shape] Package Geometry/Place_Bound_Top ((432.0 585.0) (522.0 643.0))" list(432.000000 585.000000) nil)@@@list("lei_pang" "2013/05/31 11:08:42" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:22:32" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "95.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((449.9 -48.6) (477.9 10.4))" list(449.900000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:03" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "157.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "31.5 MIL" "-31.50 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((432.47 876.47) (545.59 983.33))" "[Shape] Package Geometry/Place_Bound_Top ((450.47 894.47) (527.59 965.33))" list(450.470000 894.470000) nil)@@@list("lei_pang" "2013/05/31 10:49:38" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "93.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((480.48 -48.54) (508.48 10.46))" list(480.480000 -45.030000) nil)@@@list("lei_pang" "2013/05/31 10:00:00" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "149.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "23.13 MIL" "-23.13 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-129.37 -1382.68) (485.37 -1236.12))" "[Shape] Package Geometry/Place_Bound_Bottom ((451.73 -1285.36) (515.03 -1253.86))" list(485.370000 -1285.360000) nil)@@@list("lei_pang" "2013/05/31 10:01:23" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "150.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "23.13 MIL" "-23.13 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-129.37 -1382.68) (485.37 -1236.12))" "[Shape] Package Geometry/Place_Bound_Bottom ((452.32 -1320.02) (515.62 -1288.52))" list(485.370000 -1320.020000) nil)@@@list("lei_pang" "2013/05/31 10:01:24" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "7.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "17.72 MIL" "-17.72 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((482.55 649.45) (583.77 712.83))" "[Shape] Package Geometry/Place_Bound_Top ((488.16 652.14) (578.16 710.14))" list(488.160000 652.140000) nil)@@@list("lei_pang" "2013/05/31 11:08:41" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:22:29" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "158.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((531.6 -84.7) (551.6 -44.7))" list(533.210000 -84.700000) nil)@@@list("lei_pang" "2013/05/31 11:08:47" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "136.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((240.93 -337.31) (533.21 -45.03))" "[Shape] Package Geometry/Place_Bound_Top ((258.93 -319.31) (515.21 -63.03))" list(533.210000 -319.310000) nil)@@@list("lei_pang" "2013/05/31 11:06:23" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "41.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2202.27 MIL" "-2202.27 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((811.11 -3665.29) (911.07 -3565.32))" list(596.840000 -1373.500000) nil)@@@list("lei_pang" "2013/05/31 11:03:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "101.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2264.09 MIL" "-2264.09 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1316.09 -3710.31) (1506.09 -3520.31))" list(596.840000 -1373.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:45" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "105.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2230.63 MIL" "-2230.63 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1011.11 -3665.29) (1111.07 -3565.32))" list(596.840000 -1373.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:49" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "99.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2146.81 MIL" "-2146.81 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((566.09 -3710.31) (756.09 -3520.31))" list(596.840000 -1373.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:43" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "153.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((625.36 518.86) (795.6 869.82))" "[Shape] Package Geometry/Place_Bound_Top ((643.36 536.86) (777.6 851.82))" list(643.360000 536.860000) nil)@@@list("lei_pang" "2013/05/31 10:49:33" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "40.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "320.71 MIL" "-320.71 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((611.11 1466.21) (711.07 1566.18))" list(645.600000 1145.500000) nil)@@@list("lei_pang" "2013/05/31 11:03:26" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "21.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((642.4 -5.32) (662.4 34.68))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(662.400000 34.680000) nil)@@@list("lei_pang" "2013/05/31 11:06:11" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:44" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "28.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((664.4 -5.32) (684.4 34.68))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(664.400000 34.680000) nil)@@@list("lei_pang" "2013/05/31 11:06:18" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:56" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "174.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((653.26 -556.84) (1142.02 -9.02))" "[Shape] Package Geometry/Place_Bound_Top ((671.26 -538.84) (1124.02 -27.02))" list(671.260000 -538.840000) nil)@@@list("lei_pang" "2013/05/31 10:49:59" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "27.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((686.4 -5.32) (706.4 34.68))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(686.400000 34.680000) nil)@@@list("lei_pang" "2013/05/31 11:06:17" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:56" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "26.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((666.42 1678.03) (831.78 1843.39))" list(693.620000 1822.010000) nil)@@@list("sky_zheng" "2013/09/13 10:59:53" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:14" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "25.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((708.6 -5.3) (728.6 34.7))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(708.600000 34.700000) nil)@@@list("lei_pang" "2013/05/31 11:06:14" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:54" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "26.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((730.8 -5.2) (750.8 34.8))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(730.800000 34.800000) nil)@@@list("lei_pang" "2013/05/31 11:06:16" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:54" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "113.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((730.92 925.67) (1034.54 1147.96))" list(730.920000 1145.500000) nil)@@@list("lei_pang" "2013/05/31 10:00:29" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "169.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "73.62 MIL" "-73.62 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((730.92 925.67) (1034.54 1147.96))" "[Shape] Package Geometry/Place_Bound_Top ((748.92 943.67) (1016.54 1129.96))" list(730.920000 1129.960000) nil)@@@list("lei_pang" "2013/05/31 10:49:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "154.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "27.56 MIL" "-27.56 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((730.92 925.67) (1034.54 1147.96))" "[Shape] Package Geometry/Place_Bound_Top ((640.53 1077.29) (747.15 1140.47))" list(730.920000 1128.460000) nil)@@@list("lei_pang" "2013/05/31 10:49:35" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "104.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "327.9 MIL" "-327.90 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((811.11 1466.21) (911.07 1566.18))" list(742.800000 1145.500000) nil)@@@list("lei_pang" "2013/05/31 11:04:48" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "23.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((753.1 -5.2) (773.1 34.8))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(753.100000 34.800000) nil)@@@list("lei_pang" "2013/05/31 11:06:12" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:51" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "54.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((757.21 -955.85) (1045.23 -896.83))" list(757.210000 -952.240000) nil)@@@list("lei_pang" "2013/05/31 11:03:41" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "8.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Bottom ((757.21 -955.85) (1045.23 -896.83))" list(757.210000 -952.240000) nil)@@@list("lei_pang" "2013/05/31 13:06:08" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:27:00" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "22.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((713.5 -898.0) (772.5 -870.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((757.21 -955.85) (1045.23 -896.83))" list(772.500000 -898.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:40" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:01" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "24.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((775.2 -5.3) (795.2 34.7))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(775.200000 34.700000) nil)@@@list("lei_pang" "2013/05/31 11:06:13" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:52" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Electrical] ALL" "3.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "393.13 MIL" "-193.13 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId38<uTiL>.K7:<uTiL>cId35<uTiL>.K7 ((822.74 -735.69) (822.74 645.31))" "[PinPair] <uTiL>cId37<uTiL>.J7:<uTiL>cId35<uTiL>.J7 ((791.25 -293.19) (791.25 645.31))" list(791.250000 -293.190000) nil)@@@list("lei_pang" "2013/05/31 11:03:18" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 14:38:41" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "22.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((797.8 -5.4) (817.8 34.6))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(797.800000 34.600000) nil)@@@list("lei_pang" "2013/05/31 11:06:19" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:50" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "29.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((820.6 -5.5) (840.6 34.5))" "[Shape] Package Geometry/Place_Bound_Top ((657.73 34.33) (945.75 93.35))" list(820.600000 34.500000) nil)@@@list("lei_pang" "2013/05/31 11:06:20" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:17:58" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Electrical] ALL" "1.Diffpair Phase Tolerance" "5 [DIFFP_PHASE_TOL]" "24.21 MIL" "-19.21 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId37<uTiL>.J7:<uTiL>cId35<uTiL>.J7 ((791.25 -293.19) (791.25 645.31))" "[PinPair] <uTiL>cId38<uTiL>.K7:<uTiL>cId35<uTiL>.K7 ((822.74 -735.69) (822.74 645.31))" list(822.740000 -735.690000) nil)@@@list("lei_pang" "2013/05/31 11:03:13" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 14:38:37" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Electrical] ALL" "2.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "434.4 MIL" "-234.40 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId37<uTiL>.J7:<uTiL>cId35<uTiL>.J7 ((791.25 -293.19) (791.25 645.31))" "[PinPair] <uTiL>cId38<uTiL>.K7:<uTiL>cId35<uTiL>.K7 ((822.74 -735.69) (822.74 645.31))" list(822.740000 -735.690000) nil)@@@list("lei_pang" "2013/05/31 11:03:16" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 14:38:40" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "158.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "50.98 MIL" "-50.98 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((730.92 925.67) (1034.54 1147.96))" "[Shape] Package Geometry/Place_Bound_Top ((1027.43 945.88) (1177.77 1067.92))" list(1034.540000 945.880000) nil)@@@list("lei_pang" "2013/05/31 10:49:40" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "55.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((507.9 1240.81) (1075.09 1860.68))" list(1075.090000 1822.010000) nil)@@@list("sky_zheng" "2013/09/13 11:01:02" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:26" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "10.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Bottom ((1068.57 241.77) (1127.59 529.79))" list(1116.530000 529.790000) nil)@@@list("lei_pang" "2013/05/31 13:06:12" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:27:08" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "59.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((1068.57 241.77) (1127.59 529.79))" list(1116.530000 529.790000) nil)@@@list("lei_pang" "2013/05/31 11:03:47" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "58.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Bottom ((1068.57 654.83) (1127.59 942.85))" list(1127.590000 908.880000) nil)@@@list("lei_pang" "2013/05/31 11:03:46" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "9.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3134.0 -3714.0) (1508.1 1625.9))" "[Shape] Package Geometry/Place_Bound_Bottom ((1068.57 654.83) (1127.59 942.85))" list(1127.590000 908.880000) nil)@@@list("lei_pang" "2013/05/31 13:06:09" nil "teresa_yu-pc" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:27:05" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "150.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((653.26 -556.84) (1142.02 -9.02))" "[Shape] Package Geometry/Place_Bound_Top ((1126.55 -355.75) (1185.57 -67.73))" list(1142.020000 -355.750000) nil)@@@list("lei_pang" "2013/05/31 10:49:30" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "151.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((653.26 -556.84) (1142.02 -9.02))" "[Shape] Package Geometry/Place_Bound_Top ((1126.55 -787.77) (1185.57 -499.75))" list(1142.020000 -556.840000) nil)@@@list("lei_pang" "2013/05/31 10:49:31" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "25.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1132.5 -234.0) (1191.5 -206.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((1191.47 -275.77) (1250.49 12.25))" list(1191.500000 -234.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:45" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:10" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "24.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1132.5 -264.0) (1191.5 -236.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((1191.47 -275.77) (1250.49 12.25))" list(1191.500000 -264.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:44" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:08" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] BOTTOM" "23.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "55.12 MIL" "-55.12 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1132.5 -294.0) (1191.5 -266.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((1191.47 -275.77) (1250.49 12.25))" list(1191.500000 -266.000000) nil)@@@list("lei_pang" "2013/05/31 11:03:43" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@list("amy_shiu" "2013/05/31 12:24:04" nil "AMY_SHIU-PC2" "15t_ns_mb.100") | list("[Package] TOP" "96.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1180.0 290.5) (1208.0 349.5))" list(1205.170000 290.500000) nil)@@@list("lei_pang" "2013/05/31 10:00:04" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "159.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "37.4 MIL" "-37.40 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1223.17 163.17) (1416.83 356.83))" list(1205.170000 269.840000) nil)@@@list("lei_pang" "2013/05/31 10:49:40" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "179.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1179.09 249.09) (1210.91 280.91))" list(1205.170000 252.760000) nil)@@@list("lei_pang" "2013/05/31 10:50:06" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "68.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "22.44 MIL" "-22.44 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1189.99 276.2) (1298.23 384.44))" "[Shape] Package Geometry/Place_Bound_Bottom ((1207.99 294.2) (1280.23 366.44))" list(1207.990000 294.200000) nil)@@@list("lei_pang" "2013/05/31 10:37:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "88.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1360.0 108.0) (1380.0 148.0))" list(1360.000000 145.170000) nil)@@@list("lei_pang" "2013/05/31 09:59:55" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "111.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1330.79 -953.73) (1553.08 -650.11))" list(1372.100000 -650.110000) nil)@@@list("lei_pang" "2013/05/31 10:00:27" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "84.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1380.0 108.0) (1400.0 148.0))" list(1380.000000 145.170000) nil)@@@list("lei_pang" "2013/05/31 09:59:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "100.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "313.09 MIL" "-313.09 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1316.09 1421.19) (1506.09 1611.19))" list(1384.730000 1108.100000) nil)@@@list("lei_pang" "2013/05/31 11:04:44" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "143.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1348.79 -187.7) (1535.08 79.92))" list(1395.920000 -187.700000) nil)@@@list("lei_pang" "2013/05/31 11:08:31" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "109.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1411.84 366.71) (1478.16 433.03))" list(1411.840000 374.830000) nil)@@@list("lei_pang" "2013/05/31 10:00:24" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "178.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1411.84 366.71) (1478.16 433.03))" "[Shape] Package Geometry/Place_Bound_Top ((1429.84 384.71) (1460.16 415.03))" list(1429.840000 384.710000) nil)@@@list("lei_pang" "2013/05/31 10:50:04" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "85.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1432.0 340.0) (1472.0 360.0))" list(1434.830000 340.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:52" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "86.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1432.0 320.0) (1472.0 340.0))" list(1434.830000 320.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:53" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "180.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "5 MIL" "-5.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1434.09 284.09) (1465.91 315.91))" list(1434.830000 295.200000) nil)@@@list("lei_pang" "2013/05/31 10:50:11" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "106.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1432.0 260.0) (1472.0 280.0))" list(1434.830000 260.000000) nil)@@@list("lei_pang" "2013/05/31 10:00:21" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "87.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1432.0 240.0) (1472.0 260.0))" list(1434.830000 240.000000) nil)@@@list("lei_pang" "2013/05/31 09:59:54" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "105.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "12.99 MIL" "-12.99 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1205.17 145.17) (1434.83 374.83))" "[Shape] Package Geometry/Place_Bound_Top ((1432.0 220.0) (1472.0 240.0))" list(1434.830000 220.000000) nil)@@@list("lei_pang" "2013/05/31 10:00:19" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "144.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1348.79 -935.73) (1535.08 -668.11))" list(1449.760000 -935.730000) nil)@@@list("lei_pang" "2013/05/31 11:08:32" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "110.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1411.84 366.71) (1478.16 433.03))" list(1473.610000 366.710000) nil)@@@list("lei_pang" "2013/05/31 10:00:25" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "112.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3086.45 -1373.5) (1525.7 1223.07))" "[Shape] Package Geometry/Place_Bound_Top ((1330.79 -205.7) (1553.08 97.92))" list(1473.610000 97.920000) nil)@@@list("lei_pang" "2013/05/31 10:00:28" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "170.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "73.62 MIL" "-73.62 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1330.79 -205.7) (1553.08 97.92))" "[Shape] Package Geometry/Place_Bound_Top ((1348.79 -187.7) (1535.08 79.92))" list(1535.080000 97.920000) nil)@@@list("lei_pang" "2013/05/31 10:49:53" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] TOP" "172.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "73.62 MIL" "-73.62 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1330.79 -953.73) (1553.08 -650.11))" "[Shape] Package Geometry/Place_Bound_Top ((1348.79 -935.73) (1535.08 -668.11))" list(1535.080000 -650.110000) nil)@@@list("lei_pang" "2013/05/31 10:49:56" nil "TERESA_YU-PC" "15t_ns_mb.100")@@@nil | list("[Package] BOTTOM" "31.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "45.91 MIL" "-45.91 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1628.15 497.87) (2021.85 982.13))" "[Shape] Package Geometry/Place_Bound_Bottom ((1628.15 497.87) (2021.85 982.13))" list(1628.150000 497.870000) nil)@@@list("sky_zheng" "2013/09/13 11:00:26" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:46" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "32.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1988.35 1185.42) (2031.65 1264.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((1986.38 1182.46) (2033.62 1267.54))" list(1988.350000 1185.420000) nil)@@@list("sky_zheng" "2013/09/13 11:00:37" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:14" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "19.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((1686.15 1656.46) (2016.77 1815.82))" list(2016.770000 1751.140000) nil)@@@list("sky_zheng" "2013/09/13 10:59:46" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:03" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "31.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2043.35 1185.42) (2086.65 1264.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((2041.38 1182.46) (2088.62 1267.54))" list(2043.350000 1185.420000) nil)@@@list("sky_zheng" "2013/09/13 11:00:37" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:14" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "33.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "36.22 MIL" "-36.22 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2098.35 1185.42) (2141.65 1264.58))" "[Shape] Package Geometry/Place_Bound_Bottom ((2096.38 1182.46) (2143.62 1267.54))" list(2098.350000 1185.420000) nil)@@@list("sky_zheng" "2013/09/13 11:00:39" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 17:02:15" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "11.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2192.01 1500.86) (2388.87 1697.72))" list(2270.710000 1697.720000) nil)@@@list("sky_zheng" "2013/09/13 10:59:00" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:58" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "10.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "299.74 MIL" "-299.74 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2650.95 1572.0) (2840.95 1762.0))" list(2352.620000 1542.920000) nil)@@@list("sky_zheng" "2013/09/13 10:58:59" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:57" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "6.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "360.1 MIL" "-360.10 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2695.96 1267.02) (2795.93 1366.98))" list(2353.710000 1478.940000) nil)@@@list("sky_zheng" "2013/09/13 10:58:56" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:55" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "27.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "342.49 MIL" "-342.49 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2695.96 1067.02) (2795.93 1166.98))" list(2353.710000 1054.290000) nil)@@@list("sky_zheng" "2013/09/13 11:00:23" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:42" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "18.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2259.03 739.09) (2418.39 1069.71))" list(2353.710000 739.090000) nil)@@@list("sky_zheng" "2013/09/13 10:59:46" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:02" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "17.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2259.02 113.1) (2418.38 443.72))" list(2353.710000 113.100000) nil)@@@list("sky_zheng" "2013/09/13 10:59:45" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:02" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "16.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2259.02 -512.88) (2418.38 -182.26))" list(2353.710000 -512.880000) nil)@@@list("sky_zheng" "2013/09/13 10:59:43" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:01" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "13.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((1821.59 -1544.62) (2481.78 -957.58))" list(2368.460000 -957.580000) nil)@@@list("sky_zheng" "2013/09/13 10:59:02" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:17:00" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] BOTTOM" "26.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "1968.01 MIL" "-1968.01 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Bottom ((2695.96 -3590.46) (2795.93 -3490.5))" list(2428.510000 -1540.750000) nil)@@@list("sky_zheng" "2013/09/13 11:00:22" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 13:31:42" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "5.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2166.32 MIL" "-2166.32 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2695.96 -3790.46) (2795.93 -3690.5))" list(2428.510000 -1540.750000) nil)@@@list("sky_zheng" "2013/09/13 10:58:56" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:54" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | list("[Package] TOP" "9.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "2464.79 MIL" "-2464.79 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-2591.73 -1540.75) (2428.51 1822.01))" "[Shape] Package Geometry/Place_Bound_Top ((2650.95 -4185.48) (2840.95 -3995.48))" list(2428.510000 -1540.750000) nil)@@@list("sky_zheng" "2013/09/13 10:58:59" nil "RDD_704_PC" "g1t-oxygen.10")@@@list("andy_lien" "2013/09/13 12:16:56" nil "ANDY_LIEN-PC" "g1t-oxygen.10") | FIGURE | SIZE | 4.0 | 8.0 | 10.0 | 12.0 | 15.0 | 18.0 | 79.0 | 39.0 | 106.0 | 160.0 | 33.0x16.0 | 65.0x22.0 | 69.0x22.0 | 77.0x22.0 | 98.0x20.0 | 118.0x106.0 | TOLERANCE | +2.0/-2.0 | +3.0/-3.0 | DRILL CHART: L3-GND to L6-GND (3 to 6) | DRILL CHART: L5-SIG to L6-GND (5 to 6) | DRILL CHART: L6-GND to L7-SIG (6 to 7) | DRILL CHART: TOP to BOTTOM (1 to 8) | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | ROTATION | - | 0.000 | 90.000 | QTY | 1406 | 435 | 5266 | 868 | 47 | 9 | 60 | 1 | 2 | 4 | 1010 | TOTAL HOLES:
