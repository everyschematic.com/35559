# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IME_SCL: length 46.5
  L4-SIG w0.109: v3(30.18,101.74) 40.87,112.43 v3(66.12,112.43)
  L6-GND w0.102: v3(66.12,112.43) 66.12,112.08 v1(66.09,112.05) ; v4(30.25,101.38) 30.25,101.66 v3(30.18,101.74)
  L7-SIG w0.084: v1(30.33,98.37) 30.33,99.02 30.25,99.1 v4(30.25,101.38)
  BOTTOM w0.31: v1(66.09,112.05) 66.09,111.21 65.57,110.68 v9(65.57,109.97)
IME_SDA: length 46.5
  L4-SIG w0.109: v3(66.85,112.48) 66.42,112.05 41.05,112.05 v3(30.73,101.74)
  L6-GND w0.102: v3(30.73,101.74) 30.61,101.61 v4(30.61,101.38) ; v1(66.85,112.05) v3(66.85,112.48)
  L7-SIG w0.084: v4(30.61,101.38) 30.61,99.91 30.94,99.57 v1(33.17,99.57)
  BOTTOM w0.31: v1(66.85,112.05) v9(66.85,111.16)
IN2N: length 1.8
  BOTTOM w0.229: U1001.8 26.95,62.42
  BOTTOM w0.254: R1118.2 26.31,61.61 26.95,62.25 26.95,62.42
IN2P: length 1.7
  BOTTOM w0.229: U1001.7 27.35,62.39
  BOTTOM w0.254: 27.35,62.39 27.35,61.65 C1105.1
INT_EC#: length 11.3
  L4-SIG w0.109: v3(72.32,63.52) 72.32,65.54 72.33,65.55 72.33,65.87 72.09,66.11 70.06,66.11 69.8,66.37 69.8,67.47 v3(69.23,68.04)
  L6-GND w0.102: v3(72.32,63.52) 72.32,63.6 v1(72.56,63.84) ; v4(68.85,67.88) 69.07,67.88 v3(69.23,68.04)
  L7-SIG w0.084: v1(66.32,67.57) 67.69,67.57 67.91,67.79 68.76,67.79 v4(68.85,67.88)
  BOTTOM w0.31: R2691.1 66.46,67.43 v1(66.32,67.57)
INT_EC#_SOC: length 7
  L7-SIG w0.084: v6(60.82,67.59) 61.35,67.59 62.03,66.91 63.22,66.91 63.78,66.35 64.25,66.35
  L7-SIG w0.102: v1(67.16,66.53) 67.01,66.38 65.17,66.38 65.1,66.44 64.34,66.44 64.25,66.35
JACK_DET#: length 67.8
  L4-SIG w0.254: v3(34.44,59.32) 34.77,58.99 34.77,58.6 35.9,57.46 39.3,57.46 42.74,54.03 54.78,54.03 55.21,54.46 58.36,54.46 58.47,54.57 61.14,54.57 61.85,54.57 65.31,58.04 v3(65.31,58.28) ; v3(68.33,58.17) 68.33,62.34 67.08,63.58 67.08,64.45 v3(66.77,64.76)
  L5-SIG w0.254: v3(66.77,64.76) 66.52,65.01 62.82,65.01 62.21,65.62 61.54,65.62 60.08,67.08 59.73,67.08 v6(59.43,66.78)
  L6-GND w0.254: v3(65.31,58.28) 65.31,57.99 v4(65.53,57.77) ; v3(68.33,58.17) 68.28,58.12 v4(68.28,57.79) ; v1(33.86,59.27) 33.91,59.32 v3(34.44,59.32)
  L7-SIG w0.254: v4(65.53,57.77) 65.64,57.66 67.72,57.66 67.85,57.79 v4(68.28,57.79) ; v1(22.77,60.28) 24.62,58.43 28.45,58.43 29.72,59.7 33.43,59.7 v1(33.86,59.27)
KBC_EN: length 229.9
  L2-SIG w0.102: v8(26.98,50.5) 28.83,52.36 28.83,52.38 30.58,54.13 30.61,54.18 30.61,60.68 30.81,60.88 30.81,61.72 32.05,62.96 32.19,62.96 32.43,63.2 32.43,64.86 31.45,65.84 31.45,70.85 26.27,76.03 26.27,88.64 31.09,93.46 31.09,103.93 v8(31.4,104.23)
  L3-GND w0.102: v3(26.57,50.45) 26.92,50.45 v8(26.98,50.5) ; v8(31.4,104.23) v3(31.65,104.48)
  L4-SIG w0.102: v3(31.65,104.48) 40.31,113.14 65.74,113.14 67.4,114.81 71.68,114.81 75.3,111.19 80.61,111.19 88.64,103.16 88.64,99.49 89.32,98.81 89.32,93.75 88.8,93.23 88.8,89.7 87.7,88.6 87.7,84.18 80.71,77.2 78.41,77.2 78.06,76.85 78.06,76.5 78.06,76.5 78.06,76.15 77.5,75.59 77.5,74.02 v3(77.49,74.01)
  L5-SIG w0.102: v3(26.14,10.53) 23.93,8.32 23.93,6.61 24.15,6.39 24.59,6.39 25.1,6.89 26.34,6.89 26.82,6.41 v3(27.66,6.41)
  L6-GND w0.102: v4(77.22,74.28) 77.36,74.13 v3(77.49,74.01) ; v3(27.66,6.41) 27.81,6.26 v4(28.19,6.26) ; v3(26.14,10.53) 25.91,10.75 v4(25.91,10.8) ; v3(26.57,50.45) 26.37,50.66 v4(26.14,50.66)
  L7-SIG w0.102: v4(28.19,6.26) 28.35,6.11 29.74,6.11 30.53,5.32 30.53,4.66 30.2,4.33 v1(30.25,4.33) ; v4(77.22,74.28) 77.22,74.41 76.15,75.47 v1(75.54,75.47) ; v4(25.91,10.8) 25.91,11.8 24.64,13.07 24.64,19.14 23.5,20.28 23.5,23.99 v1(24,24.5) 24,25.43 23.53,25.9 23.53,27.99 26.29,30.74 26.29,36.28 22.78,39.79 22.78,50.78 23.25,51.25 25.55,51.25 v4(26.14,50.66)
  BOTTOM w0.102: D5104.3 29.88,3.77 R5110.1
KBC_EN_SOC: length 15.7
  L7-SIG w0.06: v6(59.08,73.28) 59.1,73.28 59.21,73.39 59.6,73.39 59.67,73.32 60.04,73.32 60.25,73.53 61.54,73.53 61.75,73.32 63.89,73.32 64.1,73.53
  L7-SIG w0.102: v1(73.04,75.48) 72.83,75.68 72.33,75.68 71.47,74.82 71.47,74.29 71.24,74.05 71,74.05 70.87,74.19 64.76,74.19 64.1,73.53
KSI0: length 46.5
  L2-SIG w0.102: v7(70.09,106.64) 70.09,103.45 72.59,100.95 72.59,77.89 74.35,76.13 74.35,73.94 72.59,72.19 72.59,69.59 74.05,68.13 74.08,68.13 v8(74.42,67.8)
  L3-GND w0.102: v3(74.58,67.45) 74.42,67.6 v8(74.42,67.8)
  L6-GND w0.102: v3(74.58,67.45) 74.34,67.68 74.34,67.7 v1(74.32,67.72)
  BOTTOM w0.102: U3001.36 74.56,67.47 v1(74.32,67.72)
KSI1: length 45.9
  L2-SIG w0.102: v7(69.29,106.64) 69.29,103.92 72.39,100.82 72.39,77.8 74.14,76.05 74.14,74.02 72.39,72.27 72.39,69.51 73.82,68.08 v2(73.82,67.58)
  BOTTOM w0.102: v2(73.82,67.58) 74.16,67.23 U3001.37
KSI2: length 47.5
  L2-SIG w0.102: v8(72.63,68.13) 72.63,68.26 72.19,68.7 72.19,72.36 73.94,74.11 73.94,75.96 72.19,77.72 72.19,100.7 68.49,104.39 v7(68.49,106.64)
  L3-GND w0.102: v8(72.63,68.13) 72.63,68.12 72.63,67.91 v3(72.75,67.79)
  L6-GND w0.102: v3(72.75,67.79) 72.75,67.53 v1(72.66,67.43)
  BOTTOM w0.102: U3001.49 69.29,65.54 69.88,66.13 71.35,66.13 v1(72.66,67.43)
KSI3: length 46.9
  L2-SIG w0.102: v8(72.19,68.15) 71.98,68.36 71.98,72.44 73.74,74.19 73.74,75.88 71.98,77.63 71.98,100.54 67.69,104.84 v7(67.69,106.64)
  L3-GND w0.102: v3(72.19,67.8) v8(72.19,68.15)
  L6-GND w0.102: v3(72.19,67.8) 72.19,67.45 v1(72.2,67.44)
  BOTTOM w0.102: U3001.50 69.36,65.94 69.9,66.48 71.24,66.48 v1(72.2,67.44)
KSI4: length 43.8
  L2-SIG w0.102: v7(66.9,106.64) 66.9,105.32 71.76,100.47 71.76,77.56 73.53,75.78 73.53,74.28 71.78,72.52 71.78,69.99 v8(71.68,69.89)
  L3-GND w0.102: v8(71.68,69.89) 71.55,69.76 v3(71.55,69.54)
  L6-GND w0.102: v1(71.1,69.54) v3(71.55,69.54)
  BOTTOM w0.102: U3001.59 v1(71.1,69.54)
KSI5: length 43
  L2-SIG w0.102: v7(66.09,106.64) 66.09,105.8 71.55,100.34 71.55,77.45 73.33,75.68 73.33,74.36 71.58,72.61 71.58,71.33 71,70.75 70.31,70.75 v8(70.26,70.7)
  L3-GND w0.102: v3(69.89,70.3) 69.89,70.33 v8(70.26,70.7)
  L6-GND w0.102: v3(69.89,70.3) 69.84,70.26 v1(69.84,69.93)
  BOTTOM w0.102: U3001.60 69.84,69.94 v1(69.84,69.93)
KSI6: length 3.3
  L2-SIG w0.102: v7(71.18,70.1) 70.82,70.46 70.79,70.46 70.79,70.47 v8(70.8,70.47)
  L3-GND w0.102: v8(70.8,70.47) 70.79,70.47 70.58,70.27 v3(70.51,70.27)
  L6-GND w0.102: v1(70.27,70) 70.3,70.04 70.3,70.06 v3(70.51,70.27)
  BOTTOM w0.102: U3001.61 69.93,70.34 v1(70.27,70)
KSI7: length 2.3
  L2-SIG w0.102: v8(69.34,70.98) 69.47,71.1 69.47,71.13 70.01,71.66 70.03,71.66 v7(70.04,71.67)
  L3-GND w0.102: v3(69.33,70.31) 69.47,70.45 69.47,70.85 v8(69.34,70.98)
  L6-GND w0.102: v1(69.04,70.72) 69.31,70.46 69.31,70.34 v3(69.33,70.31)
KSO0: length 38.9
  L2-SIG w0.102: v7(76.49,106.61) 74.3,104.42 74.3,84.9 77.04,82.15 77.04,73.52 75.91,72.39 v2(75.91,71.64)
  BOTTOM w0.102: v2(75.91,71.64) 75.91,71.64 76.41,71.14 U3001.18
KSO1: length 39.5
  L2-SIG w0.102: v7(75.69,106.64) 74.09,105.04 74.09,84.81 76.84,82.07 76.84,73.63 75.5,72.3 75.5,71.42 v2(75.89,71.03)
  BOTTOM w0.102: v2(75.89,71.03) 76.19,70.74 U3001.19
KSO2: length 39.8
  L2-SIG w0.102: v7(74.89,106.61) 73.89,105.61 73.89,84.73 76.63,81.98 76.63,73.72 75.3,72.39 75.3,71.02 75.5,70.81 v2(75.89,70.42)
  BOTTOM w0.102: U3001.20 75.98,70.34 75.9,70.42 v2(75.89,70.42)
KSO3: length 45
  L2-SIG w0.102: v2(73.25,69.5) 73.66,69.91 74.19,69.91 75.01,70.72 75.01,72.5 76.43,73.92 76.43,81.9 73.69,84.64 73.69,106.21 v7(74.09,106.61)
  BOTTOM w0.102: v2(73.25,69.5) 72.89,69.14 U3001.58
KSO4: length 43
  L2-SIG w0.102: v2(74.02,71.5) 74.52,72.01 74.52,72.31 76.23,74.01 76.23,81.82 73.41,84.64 73.41,105.43 73.28,105.56 v7(73.28,106.59)
  BOTTOM w0.102: U3001.1 69.76,71.93 70.67,71.03 73.54,71.03 v2(74.02,71.5)
KSO5: length 42.3
  L2-SIG w0.102: v2(73.41,71.51) 76.02,74.13 76.02,81.73 73.2,84.55 73.2,101.43 72.49,102.14 v7(72.49,106.64)
  BOTTOM w0.102: v2(73.41,71.51) 73.13,71.23 70.79,71.23 70.16,71.86 U3001.2
KSO6: length 41.7
  L2-SIG w0.102: v2(73.35,70.48) 73,70.83 73,71.79 74.75,73.54 74.75,76.3 73,78.05 73,101.23 71.69,102.54 v7(71.69,106.66)
  BOTTOM w0.102: U3001.11 73.76,72.11 73.97,71.91 74.18,71.91 74.42,71.67 74.42,71.33 73.99,70.9 73.77,70.9 v2(73.35,70.48)
KSO7: length 43.1
  L2-SIG w0.102: v2(73.97,70.49) 73.58,70.11 73.58,70.11 73.49,70.03 73.22,70.03 72.8,70.45 72.8,72.1 74.55,73.86 74.55,76.22 72.8,77.97 72.8,101.1 70.89,103.01 v7(70.89,106.64)
  BOTTOM w0.102: v2(73.97,70.49) 74.4,70.49 74.63,70.72 74.63,71.75 74.16,72.22 U3001.12
KSO9: length 44.5
  L2-SIG w0.102: v7(65.3,106.66) 65.3,106.23 71.35,100.19 71.35,77.33 73.11,75.56 73.11,74.43 71.27,72.59 71.27,71.42 v8(71.19,71.33)
  L3-GND w0.102: v3(71.17,70.98) 71.19,70.99 v8(71.19,71.33)
  L6-GND w0.102: v4(71.44,70.68) 71.17,70.95 v3(71.17,70.98)
  L7-SIG w0.102: v1(74.96,72.7) 74.38,72.12 73.18,72.12 72.29,71.23 71.99,71.23 v4(71.44,70.68)
LCD_DDC_SCL: length 25.2
  L4-SIG w0.109: v3(75.41,13.73) 75.01,13.32 75.01,11.75 68.98,5.72 v3(67.34,5.72) 66.75,5.72 66.15,6.32 65.42,6.32 64.95,5.85 63.79,5.85 63.74,5.89 61.44,5.89 61.15,5.6 v3(59.36,5.6)
  L6-GND w0.102: v3(67.34,5.72) 67.29,5.68 67.08,5.68 v1(66.98,5.78) ; v1(59.56,5.92) 59.56,5.84 59.36,5.65 v3(59.36,5.6) ; v1(75.13,14.06) 75.41,13.77 v3(75.41,13.73)
  BOTTOM w0.31: U7107.25 72.66,14.07 73.75,14.07 v9(74.09,14.42) 74.43,14.42 74.79,14.06 v1(75.13,14.06)
LCD_DDC_SDA: length 26.5
  L4-SIG w0.109: v3(75.44,12.91) 75.51,12.84 75.51,11.96 68.81,5.26 66.76,5.26 v3(66.74,5.29) 66.55,5.47 66.49,5.47 65.85,6.11 65.52,6.11 65.04,5.64 63.7,5.64 63.65,5.68 61.6,5.68 v3(60.63,4.71)
  L6-GND w0.102: v1(66.87,4.96) 66.78,5.05 66.78,5.24 v3(66.74,5.29) ; v3(75.44,12.91) 75.36,12.91 v1(75.13,13.14) ; v1(60.3,4.48) 60.53,4.71 v3(60.63,4.71)
  BOTTOM w0.31: v1(75.13,13.14) 74.61,13.66 72.25,13.66 71.97,13.95 U7107.26 ; CON7305.7 59.26,3.44 v1(60.3,4.48)
LCD_ENBLT: length 7.8
  L4-SIG w0.109: v3(65.18,15.73) 65.59,16.14 66.29,16.14 67.03,15.4 69.28,15.4 70.84,13.84 v3(70.84,13.83)
  L6-GND w0.102: v1(70.97,14.26) 70.97,13.95 v3(70.84,13.83) ; v3(65.18,15.73) 65.48,15.43 v1(65.53,15.43)
LCD_ENPVCC: length 15.3
  L4-SIG w0.109: v3(69.65,13.9) 68.38,13.9 67.52,13.05 64.73,13.05 63.34,14.43 57.36,14.43 v3(56.62,15.17)
  L6-GND w0.102: v1(69.97,14.26) 69.97,14.22 v3(69.65,13.9) ; v1(56.08,15.17) v3(56.62,15.17)
LDO1_EN: length 6.8
  BOTTOM w0.229: U1001.44 30.99,65.14
  BOTTOM w0.31: 30.99,65.14 31.74,65.89 32.5,65.89 32.71,65.69 32.71,64.71 32.63,64.64 C1020.2 32.65,63.84 R1045.2 R1015.2 R1014.2
LDO_FB: length 4.1
  BOTTOM w0.102: v9(78.74,99.15) 79.31,98.58 U2101.4
  BOTTOM w0.381: U2101.4 80.09,97.94 R2130.1 81,97.59 81.2,97.38 R2129.2
LED_AN:
  vias: v9(47.74,2.72)
LED_CH1: length 22.9
  L2-SIG w0.102: v8(49.05,23.74) 49.05,23.73 49.99,22.79 49.99,5.04 v2(50.62,4.4)
  L3-GND w0.102: v3(48.77,23.96) 49,23.74 v8(49.05,23.74)
  L6-GND w0.102: v3(48.77,23.96) 48.69,23.96 v1(48.48,24.17)
  BOTTOM w0.102: CON7305.35 50.86,4.17 v2(50.62,4.4) ; v1(48.48,24.17) 48.25,23.94 SR9001.2
LED_CH2: length 24.4
  L2-SIG w0.102: v8(47.91,25.99) 47.91,25.41 50.19,23.12 50.19,5.5 v2(50.65,5.04)
  L3-GND w0.102: v3(47.91,25.49) v8(47.91,25.99)
  L6-GND w0.102: v1(47.91,24.98) v3(47.91,25.49)
  BOTTOM w0.102: CON7305.34 51.16,5.26 50.93,5.04 v2(50.65,5.04)
LED_CH3: length 24.9
  L2-SIG w0.102: v2(51.54,4.4) 51.07,4.87 51.07,5.68 50.39,6.35 50.39,23.28 48.54,25.13 v2(48.54,25.89)
  BOTTOM w0.102: v2(48.54,25.89) 48.41,26.02 SR9002.2 ; v2(51.54,4.4) 51.46,4.32 CON7305.33
LED_CH4: length 30.6
  L2-SIG w0.102: v2(51.54,5.06) 51.54,5.82 50.75,6.61 50.75,24.26 47.73,27.27 45.74,27.27 45.5,27.51 v8(44.59,27.51)
  L3-GND w0.102: v3(44.53,28.03) 44.59,27.96 v8(44.59,27.51)
  L6-GND w0.102: v3(44.53,28.03) 44.16,28.39 v1(43.96,28.39)
  BOTTOM w0.102: CON7305.32 51.76,5.28 v2(51.54,5.06) ; v9(44.27,29.62) 44.27,28.7 v1(43.96,28.39)
LID_SW#: length 154.2
  L2-SIG w0.102: v2(22.34,53.34) 22.34,51.79 21.57,51.01 v2(21.57,12.2)
  L4-SIG w0.102: v3(35.52,59.62) 36.11,59.03 38.94,59.03 43.09,54.87 49.59,54.87 50.02,55.31 58.01,55.31 58.12,55.42 61.5,55.42 63.83,57.75 v3(63.83,58.54)
  L5-SIG w0.102: v3(63.83,58.54) 63.93,58.63 64.3,58.63 64.64,58.97 71.24,58.97 71.52,59.25 71.52,60.17 71.89,60.54 74.97,60.54 76.18,59.33 79.49,59.33 80.32,59.33 81.93,60.94 84.14,60.94 84.95,60.13 v3(86.3,60.13)
  L6-GND w0.102: v3(86.3,60.13) v4(86.3,59.78) ; v4(34.7,58.91) 34.87,59.09 34.87,59.27 35.22,59.62 v3(35.52,59.62) 35.53,59.62 35.69,59.78 v4(35.69,60.06)
  L7-SIG w0.102: v1(39.52,66.05) 39.46,66.05 38.97,66.53 36.82,66.53 35.99,65.71 35.99,60.69 35.69,60.39 v4(35.69,60.06) ; v1(27.94,3.33) 27.94,4.02 28.14,4.23 28.14,5.15 27.65,5.65 24.62,5.65 21.57,8.7 v2(21.57,12.2) ; v1(92.08,65.01) 92.08,63.87 87.99,59.78 v4(86.3,59.78) ; v4(34.7,58.91) 34.7,57.79 34.39,57.49 34.39,54.43 34.16,54.19 32.91,54.19 32.25,53.53 31.51,53.53 31.28,53.3 28.5,53.3 27.94,53.86 23.57,53.86 22.99,53.27 22.41,53.27 v2(22.34,53.34)
  BOTTOM w0.102: v1(39.52,66.05) 39.5,66.08 39.5,67.85 39.13,68.22 Q2650.6
LID_SW_SOC#: length 52
  L4-SIG w0.102: v3(36.07,59.7) 36.21,59.56 36.45,59.56 36.77,59.23 39.02,59.23 43.17,55.08 46.99,55.08 47.47,55.56 57.98,55.56 58.04,55.62 61.41,55.62 63.04,57.25 63.04,60.21 v3(61.85,61.4)
  L5-SIG w0.102: v5(58.19,66.52) 58.73,65.99 58.73,63.65 60.37,62.01 60.37,61.8 60.71,61.45 61.8,61.45 v3(61.85,61.4)
  L6-GND w0.102: v3(36.07,59.7) 36.04,59.73 v4(36.04,60.06)
  L7-SIG w0.06: v5(58.19,66.52) 58.21,66.52 58.47,66.78 v6(58.8,66.78)
  L7-SIG w0.102: v4(36.04,60.06) 36.04,60.35 36.27,60.58 36.27,65.01 37.36,66.1 v1(38.96,66.1)
  BOTTOM w0.102: Q2650.1 39.13,66.5 39.03,66.41 R2677.1
LIGHT_SENSOR_INT#: length 90.8
  L3-GND w0.102: v8(94.08,118.06) v3(94.44,118.06)
  L4-SIG w0.109: v3(79.33,75.23) 86.59,75.23 91.35,79.98 v3(91.55,79.98)
  L5-SIG w0.109: v3(91.55,79.98) 92.98,81.42 92.98,86.1 95.28,88.4 95.28,92.66 94.38,93.56 94.38,97.61 90.15,101.84 87.7,101.84 87.45,102.09 87.45,108.75 93.65,114.95 93.65,116.33 94.44,117.12 v3(94.44,118.06)
  L6-GND w0.102: v4(79,75.09) 79.19,75.09 v3(79.33,75.23)
  L7-SIG w0.06: 62.71,66.53 60.48,66.53 60.24,66.78 60.24,67.41 60.36,67.53 60.36,67.72 60.22,67.87 v6(60.22,68.13)
  L7-SIG w0.084: 62.71,66.53 64.64,64.6 v6(64.75,64.6) 65.16,64.6 65.61,65.06 65.91,65.06 66.07,65.21 66.07,65.44 66.06,65.44 66.29,65.67 69.11,65.67 69.78,66.35 69.78,66.54 69.78,66.7 70.38,67.3 70.99,67.3 71.55,67.3 71.98,67.73 72.76,67.73 73.66,66.83 74.09,66.83 75.13,67.86 75.13,68.01 75.13,68.33 76.31,69.51 76.31,71.53 76.33,71.55 76.68,71.91 76.92,71.91 79,73.99 v4(79,75.09)
LPC_AD0: length 68.9
  L3-GND w0.102: v8(50.89,107.02) v3(50.89,106.37)
  L4-SIG w0.109: v3(48.7,67.3) 48.21,67.3 46.55,68.96 44.55,68.96 44.25,69.26 39.96,69.26 34.63,74.59 34.63,74.84 34.63,75.71 30.65,79.69 30.65,83.75 31.94,85.04 32.06,85.16 32.7,85.16 33.56,85.16 35.59,87.19 36.08,87.68 36.08,88.03 36.08,92.3 36.93,93.15 36.93,96.07 36.79,96.21 36.79,101.67 36.91,101.79 39.9,104.79 48.77,104.79 50.34,106.36 50.88,106.36 v3(50.89,106.37)
  L5-SIG w0.06: v6(48.02,67.88) 48.6,67.3 v3(48.7,67.3)
  L6-GND w0.102: v3(50.89,106.37) 50.89,107.39 v1(50.89,107.39)
  BOTTOM w0.31: v1(50.89,107.39) 50.62,107.12 v9(50.14,107.12)
LPC_AD1: length 71
  L3-GND w0.102: v8(52.49,107.02) v3(52.49,106.32)
  L4-SIG w0.109: v3(48.53,67.83) 47.97,67.83 46.63,69.17 44.65,69.17 43.91,69.91 41.05,69.91 39.93,71.03 38.49,71.03 34.84,74.67 34.84,74.75 34.84,75.8 34.72,75.92 31.57,79.07 31.57,79.82 31.45,79.94 31.33,79.94 31.24,79.85 31.24,79.67 31.19,79.62 31.02,79.62 30.88,79.76 30.88,83.68 32.15,84.95 32.79,84.95 33.64,84.95 35.67,86.98 36.29,87.6 36.29,88.12 36.29,88.12 36.29,92.22 37.14,93.06 37.14,96.16 37,96.3 37,101.58 39.99,104.58 51.55,104.58 52.49,105.52 v3(52.49,106.32)
  L5-SIG w0.06: v6(47.82,68.17) 48.03,68.17 48.18,68.02 48.36,67.83 v3(48.53,67.83)
  L6-GND w0.102: v3(52.49,106.32) 52.11,106.7 v1(52.11,107.39)
  BOTTOM w0.31: v9(51.81,106.59) 52.11,106.88 v1(52.11,107.39)
LPC_AD2: length 72
  L3-GND w0.102: v8(54.09,107.02) v3(54.09,106.51)
  L4-SIG w0.109: v3(46.89,66.85) 46.89,67.04 47.15,67.3 47.15,67.91 46.32,68.75 44.46,68.75 44.16,69.05 39.87,69.05 34.42,74.5 34.42,74.92 34.42,75.62 30.44,79.61 30.44,83.84 31.85,85.25 31.97,85.37 31.98,85.37 33.47,85.37 35.5,87.4 35.87,87.77 35.87,87.94 35.87,92.39 36.72,93.24 36.72,95.98 36.58,96.12 36.58,101.76 36.7,101.88 36.82,102.01 36.82,102.01 39.82,105 39.99,105 48.5,105 50.26,106.76 51.05,106.76 51.1,106.71 53.9,106.71 v3(54.09,106.51)
  L6-GND w0.06: v6(46.6,67.12) 46.62,67.12 v3(46.89,66.85)
  L6-GND w0.102: v1(54.09,107.43) 54.09,107.43 v3(54.09,106.51)
  BOTTOM w0.31: v1(54.09,107.43) v9(54.09,106.03)
LPC_AD3: length 73.2
  L3-GND w0.102: v8(55.69,107.02) v3(55.69,106.53)
  L4-SIG w0.109: v3(55.69,106.53) 55.3,106.92 51.19,106.92 51.14,106.97 49.94,106.97 48.18,105.21 40.08,105.21 39.73,105.21 36.74,102.22 36.61,102.09 36.36,101.85 36.36,96.04 36.5,95.9 36.5,93.33 35.66,92.48 35.66,87.86 35.41,87.61 33.38,85.58 33.21,85.58 31.89,85.58 30.23,83.93 30.23,83.75 30.23,79.52 34.21,75.54 34.21,75.01 34.21,74.41 39.88,68.75 41.97,68.75 42.44,68.28 44.6,68.28 44.85,68.54 46.08,68.54 46.31,68.31 46.31,68.21 v3(46.77,67.75)
  L6-GND w0.06: v3(46.77,67.75) 46.77,67.64 46.91,67.49 v6(46.91,67.34)
  L6-GND w0.102: v3(55.69,106.53) 55.69,107.42 v1(55.69,107.42)
  BOTTOM w0.31: v9(57.16,107.42) v1(55.69,107.42)
LPC_CLKRUN#: length 1.4
  L3-GND w0.06: v8(45.52,68.41) 45.52,67.95 45.37,67.81 v3(45.37,67.75)
  L6-GND w0.06: v3(45.37,67.75) 45.87,67.75 v6(46.03,67.6)
LPC_FRAME#: length 74.1
  L3-GND w0.102: v8(57.29,107.02) v3(56.9,107.02)
  L4-SIG w0.109: v3(45.92,68.15) 44.85,68.15 44.77,68.07 42.33,68.07 41.91,68.49 39.83,68.49 34,74.32 34,75.1 34,75.45 30.14,79.31 30.02,79.43 30.02,83.66 30.02,83.66 30.02,84.01 31.8,85.79 31.8,85.79 33.29,85.79 35.32,87.82 35.45,87.94 35.45,92.57 36.29,93.41 36.29,95.81 36.15,95.95 36.15,101.58 36.15,101.93 36.15,101.93 36.65,102.43 39.64,105.42 39.82,105.42 40.16,105.42 40.16,105.42 47.91,105.42 49.67,107.18 51.22,107.18 51.28,107.13 56.79,107.13 v3(56.9,107.02)
  L6-GND w0.06: v6(46.33,67.89) 46.07,68.15 v3(45.92,68.15)
  L6-GND w0.102: v1(57.35,107.93) 57.35,107.47 v3(56.9,107.02)
  BOTTOM w0.31: v1(57.35,107.93) 58.34,107.93 v9(58.9,107.37)
LPC_RCOMP: length 5.7
  L7-SIG w0.06: v6(48.55,67.91) 48.1,67.45 47.66,67.45 47.57,67.55 47.4,67.55 47.28,67.43 47.28,67.4 46.79,66.91 46.28,66.91 46.13,66.76 45.99,66.76
  L7-SIG w0.127: 45.99,66.76 45.9,66.76 45.7,66.56 44.73,66.56 44.46,66.29 v1(43.63,66.29)
LPC_SERIRQ: length 49
  L4-SIG w0.109: v3(35.91,95.65) 35.91,93.33 35.24,92.65 35.24,88.03 33.21,86 31.71,86 29.81,84.1 29.81,83.58 29.81,79.34 30.05,79.1 30.05,79.1 33.79,75.36 33.79,74.22 40.64,67.37 46.03,67.37 46.27,67.13 46.27,66.92 46.85,66.34 v3(46.85,65.59)
  L6-GND w0.06: v3(46.85,65.59) 46.85,65.74 v6(46.65,65.93)
  L6-GND w0.102: v3(35.91,95.65) 35.91,96.5 v1(37.26,97.85)
  L7-SIG w0.084: v1(37.26,97.85) 37.35,97.94 v1(37.35,98.82)
  BOTTOM w0.31: v1(37.26,97.85) v9(38.42,97.85)
LPC_SERIRQ_R: length 23
  L3-GND w0.102: v8(54.89,107.02) v3(54.89,106.51)
  L4-SIG w0.102: v3(37.52,101.56) 37.52,101.64 40.02,104.14 52.52,104.14 v3(54.89,106.51)
  L6-GND w0.102: v3(54.89,106.51) 54.89,107.46 v1(54.89,107.46) ; v3(37.52,101.56) 37.35,101.4 v1(37.35,101.2)
  BOTTOM w0.102: v1(54.89,107.46) 54.89,107.25 v9(55.88,106.26)
LRCK2: length 5.4
  BOTTOM w0.102: U1001.35 29.35,68.88 29.67,69.19 31.19,69.19 31.57,69.58 32.56,69.58 33.11,70.14 R1053.1 C1061.1
LVDS_A_GND: length 5.7
  BOTTOM w0.279: v1(75.13,14.82) 74.85,15.09 73.78,15.09 73.56,14.86 U7107.24
  BOTTOM w0.381: v1(75.99,16.34) v9(77.01,16.34) 77.5,16.34 77.95,15.88 R7144.2
  vias: v1(64.74,16.19) v1(67,13.14) v1(67.97,20.96) v1(69.39,13.14) v1(70.05,13.14) v1(72.43,13.14) v1(73.22,13.14) v1(74.14,20.18) v1(74.86,20.18) v1(75.99,15.58)
M0_A_ZQ0: length 5.4
  L7-SIG w0.076: 63.54,98.21 63.54,97.97 63.76,97.74 64.1,97.74 v1(64.36,97.48)
  L7-SIG w0.102: v1(61.35,101.11) 61.35,100.47 63.54,98.28 63.54,98.21
  BOTTOM w0.203: v1(64.36,97.48) 64.59,97.28
M0_A_ZQ1: length 6.4
  L7-SIG w0.076: 63.32,98.21 63.32,97.95 63.46,97.82 63.46,97.81 63.69,97.58 63.7,97.58 64.29,96.98 v1(64.36,96.98)
  L7-SIG w0.102: v1(60.59,101.11) 60.59,99.87 61.24,99.22 62.31,99.22 63.32,98.21
M0_B_ZQ0: length 7.1
  L5-SIG w0.102: v3(69.73,95.75) 69.96,95.75 70.59,96.38 70.59,99.17 70.43,99.32 70.43,100.77 v3(70.46,100.8)
  L6-GND w0.076: 69.54,95.94 69.5,95.98 v1(68.86,95.98)
  L6-GND w0.102: v3(70.46,100.8) 70.78,101.11 v1(70.82,101.11) ; 69.54,95.94 v3(69.73,95.75)
M0_B_ZQ1: length 6.8
  L5-SIG w0.102: v3(69.83,96.5) 69.88,96.5 70.26,96.89 70.26,99.15 69.77,99.63 v3(69.77,100.82)
  L6-GND w0.076: 69.54,96.22 68.68,96.22 v1(68.38,95.92)
  L6-GND w0.102: v3(69.83,96.5) 69.55,96.22 69.54,96.22 ; v3(69.77,100.82) 69.8,100.82 v1(70.09,101.11)
M1_A_ZQ0: length 4.2
  L7-SIG w0.076: 46.56,98.19 46.58,98.17 v1(46.58,97.48)
  L7-SIG w0.102: v1(45.12,101.03) 45.12,100.81 46.42,99.51 46.42,98.33 46.56,98.19
M1_A_ZQ1: length 5
  L7-SIG w0.076: v1(46.58,96.98) 46.58,97.12 46.32,97.37 46.32,98.11 46.25,98.19
  L7-SIG w0.102: v1(44.36,101.06) 45.23,100.19 45.24,100.19 46.18,99.25 46.18,98.26 46.25,98.19
M1_B_ZQ0: length 6.3
  L5-SIG w0.076: v1(51.13,95.98) 51.13,97.37 51.13,97.38 51.79,98.04
  L5-SIG w0.102: v3(53.62,100.72) 53.49,100.59 53.49,99.75 53.39,99.64 53.28,99.53 51.79,98.04
  L6-GND w0.102: v1(53.87,101.17) 53.87,100.97 v3(53.62,100.72)
M1_B_ZQ1: length 6.2
  L5-SIG w0.076: v1(50.63,95.98) 50.75,96.1 50.75,97.29 51.65,98.19
  L5-SIG w0.102: v3(52.96,100.85) 52.68,100.57 52.68,99.22 51.65,98.19
  L6-GND w0.102: v1(53.14,101.17) 53.14,101.03 v3(52.96,100.85)
MCLK: length 6.7
  L7-SIG w0.084: v1(30.4,67.94) 31,68.54 32.41,68.54 32.79,68.92 34.39,68.92 v1(34.74,69.27) 35.35,69.27 v1(35.43,69.35)
  BOTTOM w0.31: v1(34.74,69.27) 34.54,69.07 33.88,69.07 v9(33.76,68.95)
MCSI_2_CLK_DN: length 67.1
  L4-SIG w0.094: v3(21.64,97.37) 21.39,97.12 21.39,77.87 25.72,73.54 25.75,73.54 26.28,73.54 30.96,68.87 31.23,68.87 32.79,67.31 34.35,67.31 37.9,63.76 38.5,63.76 40.11,62.16 42.69,62.16 43.22,62.69 46.34,62.69 47.54,61.49 55.12,61.49 56.88,63.26 56.88,65.05 56.81,65.13 56.71,65.13 56.47,64.89 56.39,64.89 56.33,64.94 v3(56.33,65.5)
  L6-GND w0.102: v3(21.64,97.37) 21.63,97.37 v1(21.63,97.73) ; v6(56.25,65.93) 56.39,65.79 56.39,65.79 56.46,65.71 56.46,65.63 v3(56.33,65.5)
MCSI_2_CLK_DN_CON: length 39.4
  L2-SIG w0.076: v8(21.63,99.76) 21.44,99.95 21.44,100.09 21.41,100.12 21.17,100.35 19.76,100.35 10.2,109.92 10.2,114.96 6.11,119.05 6.11,120.66 5.42,121.35 5.42,121.36 v8(5.23,121.55)
  L3-GND w0.102: v3(5.05,121.88) 5.05,121.73 v8(5.23,121.55) ; v3(21.63,99.37) v8(21.63,99.76)
  L6-GND w0.102: v3(5.05,121.88) v1(5.05,122.25) ; v1(21.63,98.98) v3(21.63,99.37)
  BOTTOM w0.178: CON2101.16 v1(5.05,122.25) 5.05,121.68 5.82,120.91 8.72,120.91 8.72,120.91 8.84,120.91 10.01,122.08 T2103.1
MCSI_2_CLK_DP: length 67.1
  L4-SIG w0.094: v3(21.08,97.34) 21.19,97.23 21.19,77.79 25.64,73.35 25.67,73.35 26.2,73.35 30.88,68.67 31.15,68.67 32.71,67.12 34.27,67.12 37.82,63.57 38.42,63.57 40.03,61.96 42.77,61.96 43.3,62.49 46.26,62.49 47.45,61.3 54.96,61.3 54.96,61.3 55.2,61.3 57.08,63.17 57.08,63.34 57.08,65.13 56.91,65.3 v3(56.91,65.5)
  L6-GND w0.102: v3(56.91,65.5) 56.67,65.74 56.67,65.8 56.59,65.87 56.59,66.08 v6(56.54,66.13) ; v1(21.08,97.73) v3(21.08,97.34)
MCSI_2_CLK_DP_CON: length 39.2
  L2-SIG w0.076: v8(5.35,120.12) 5.35,120.78 5.44,120.86 5.63,120.86 5.92,120.58 5.92,118.97 10.01,114.88 10.01,109.84 19.69,100.16 21.1,100.16 21.22,100.04 21.22,99.9 v8(21.07,99.76)
  L3-GND w0.102: v3(21.07,99.37) v8(21.07,99.76) ; v3(5.35,119.73) v8(5.35,120.12)
  L6-GND w0.102: v3(21.07,99.37) 21.08,99.37 v1(21.08,98.98) ; v3(5.35,119.73) v1(5.35,119.37)
  BOTTOM w0.178: CON2101.15 5.35,120.4 5.6,120.64 5.6,120.63 8.61,120.63 8.61,120.63 8.96,120.63 10.12,121.8 10.59,121.8 10.77,121.62 10.77,120.98 T2101.1
MCSI_2_DATA_DN: length 66.5
  L4-SIG w0.094: v3(22.86,97.37) 22.51,97.02 22.51,79.37 22.29,79.15 22.29,77.92 25.99,74.21 26.03,74.21 26.63,74.21 31.15,69.7 31.43,69.7 33.14,67.98 34.66,67.98 37.67,64.98 39.58,64.98 41.16,63.4 47.76,63.4 48.96,62.2 49.35,62.2 49.47,62.33 49.47,63.16 49.72,63.4 50.36,63.4 50.6,63.16 50.6,62.29 50.7,62.2 51.16,62.2 51.29,62.33 51.29,63.18 51.53,63.42 52.03,63.42 53.25,62.2 54.57,62.2 55.74,63.36 55.74,64.3 55.66,64.37 55.29,64.37 55.15,64.52 55.15,64.67 55.26,64.78 v3(55.48,64.78)
  L6-GND w0.102: v3(22.86,97.37) 22.86,97.72 v1(22.85,97.73) ; v3(55.48,64.78) 55.48,65.06 v6(55.41,65.14)
MCSI_2_DATA_DN_CON: length 37.2
  L2-SIG w0.076: v8(22.85,99.78) 22.67,99.6 22.67,99.42 22.25,99.01 19.91,99.01 9.36,109.56 9.36,114.61 4.69,119.29 4.69,120.4 4.63,120.46 4.48,120.46 v8(4.15,120.13)
  L3-GND w0.102: v3(22.85,99.4) v8(22.85,99.78) ; v3(4.15,119.75) v8(4.15,120.13)
  L6-GND w0.102: v1(22.85,98.98) v3(22.85,99.4) ; v3(4.15,119.75) v1(4.15,119.37)
  L7-SIG w0.076: v1(4.15,119.37) 4.15,120.42 3.62,120.95 3.37,120.95 3.14,121.18 2.55,121.18 1.98,120.61 v1(1.98,120.46)
MCSI_2_DATA_DP: length 66.6
  L4-SIG w0.094: v3(22.3,97.37) 22.32,97.35 22.32,79.45 22.1,79.23 22.1,77.83 25.91,74.02 25.95,74.02 26.55,74.02 31.07,69.5 31.35,69.5 33.06,67.79 34.58,67.79 37.59,64.78 39.5,64.78 41.08,63.2 47.68,63.2 48.88,62 49.43,62 49.67,62.24 49.67,63.08 49.8,63.2 50.28,63.2 50.41,63.08 50.41,62.21 50.62,62 51.24,62 51.48,62.24 51.48,63.1 51.61,63.23 51.95,63.23 53.17,62 54.65,62 55.93,63.28 v3(55.93,65.11)
  L6-GND w0.102: v3(55.93,65.11) 55.94,65.11 v6(55.69,65.36) ; v3(22.3,97.37) v1(22.3,97.73)
MCSI_2_DATA_DP_CON: length 37.2
  L2-SIG w0.076: v8(22.29,99.78) 22.48,99.59 22.48,99.5 22.17,99.2 19.99,99.2 9.55,109.64 9.55,114.69 4.88,119.36 4.88,120.48 4.71,120.65 4.52,120.65 4.45,120.72 v8(4.45,121.5)
  L3-GND w0.102: v8(4.45,121.5) v3(4.45,121.88) ; v3(22.29,99.4) v8(22.29,99.78)
  L6-GND w0.102: v1(4.45,122.25) v3(4.45,121.88) ; v3(22.29,99.4) 22.3,99.39 v1(22.3,98.98)
  L7-SIG w0.076: v1(4.45,122.25) 4.45,121.33 4.27,121.14 3.45,121.14 3.22,121.37 2.54,121.37 2.08,121.83 v1(2.08,122.01)
MCSI_COMP: length 8.8
  L7-SIG w0.254: v6(54.38,66.76) 54.52,66.62 54.88,66.62 55.15,66.34 55.15,65.63 55.1,65.58 55.1,64.93 55.14,64.9 55.14,63.56 54.79,63.2 54.79,58.94 v1(54.97,58.76)
MDSI_COMP: length 8.1
  L7-SIG w0.254: v6(54.84,66.21) 54.84,65.76 54.79,65.71 54.79,64.8 54.83,64.77 54.83,63.69 54.28,63.14 54.28,60.04 53.84,59.59 53.84,59.14 v1(54.22,58.76)
MICBIAS1: length 5.2
  L4-SIG w0.102: v3(28.25,62.21) 26.66,60.63 v3(26.66,58.99)
  L6-GND w0.102: v1(28.55,62.89) 28.55,62.52 v3(28.25,62.21) ; v1(26.98,59.35) 26.66,59.04 v3(26.66,58.99)
MIPI_BKLT_CTRL: length 1
  L3-GND w0.06: v3(47.52,72.91) 47.92,72.91 v8(48.05,73.03)
  L6-GND w0.06: v3(47.52,72.91) 47.34,72.72 v6(47.2,72.72)
OTG: length 3.4
  BOTTOM w0.31: R8834.2 30.09,20.8 R8806.1 30.7,21.57 v9(30.95,21.81) 31.81,22.68 U8800.8
PCIE_RCOMP_DN: length 5.5
  L7-SIG w0.06: v6(47.2,63.66) 47.2,63.1 46.56,62.47 44.48,62.47 43.99,61.99 43.1,61.99 43.1,61.99
  L7-SIG w0.127: 43.1,61.99 v1(42.83,62.27)
PCIE_RCOMP_DP: length 5
  L7-SIG w0.06: v6(43.66,62.26) 44.04,62.26 44.4,62.62 46.55,62.62 46.89,62.96 46.89,63.84 47,63.95 v6(47.41,63.95)
PG#: length 8
  L7-SIG w0.102: v1(34.22,21.58) 34.22,19.58 33.48,18.83 33.48,18.3 33.81,17.97 35.03,17.97 36.4,16.6 v1(37.19,16.6)
PLT_CLK0_2MP: length 77.7
  L4-SIG w0.109: v3(13.63,108.95) 13.84,108.74 13.84,94.68 14.53,93.99 14.53,85.15 14.04,84.66 14.04,76.48 14.67,75.85 v3(14.67,73.7)
  L5-SIG w0.109: v3(14.67,73.7) 15.1,73.27 22.14,73.27 23.12,72.28 26.57,72.28 31.29,67.56 31.3,67.56 33.23,65.62 33.23,63.48 35.22,61.5 37.63,61.5 38.71,62.58 44.06,62.58 44.33,62.85 45.03,62.85 46.84,64.66 v6(46.84,65.06)
  L6-GND w0.102: v3(13.63,108.95) v1(13.63,109.31)
  BOTTOM w0.31: v1(13.63,109.31) 14.09,108.85 v9(14.09,108.38)
PLT_CLK0_2MP_R: length 16.1
  L5-SIG w0.109: v3(8.05,121.88) 8.2,121.73 8.2,121.17 8.99,120.38 8.99,113.42 10.46,111.95 13.46,111.95 v3(13.63,111.78)
  L6-GND w0.102: v1(8.05,122.25) v3(8.05,121.88) ; v1(13.63,111.34) v3(13.63,111.78)
  L7-SIG w0.084: v1(13.63,110.17) v1(13.63,111.34)
PLTRST#: length 171.4
  L4-SIG w0.109: v3(84.89,39.28) 84.58,39.59 84.58,45.63 86.53,47.58 86.53,57.4 85.6,58.33 v3(85.6,58.51) 85.12,58.98 85.12,64.67 81.59,68.21 80.17,68.21 78.98,69.39 78.98,70.7 80.04,71.75 80.04,72.64 v3(79.78,72.89) ; v3(62.66,59.12) 62.66,59.12 62.82,58.96 62.82,58.28 60.59,56.05 42.49,56.05 39.11,59.44 36.9,59.44 34.6,61.74 34.6,62.93 v3(34.01,63.51) ; v3(71.36,65.73) 71.6,65.49 71.6,62.15 71.96,61.8 v3(71.96,60.06)
  L5-SIG w0.06: 62.85,66.76 62.66,66.76 62.25,67.17 61.72,67.17 61.16,67.73 60.68,67.73 60.32,68.09 59.76,68.09 59.37,68.47 v6(59.37,68.47)
  L5-SIG w0.107: 62.85,66.76 63.27,66.76 63.96,66.06 64.95,66.06
  L5-SIG w0.109: v6(59.53,36.14) 59.77,36.38 60.95,36.38 61.03,36.31 61.22,36.31 61.49,36.59 70.24,36.59 70.65,36.18 72.89,36.18 73.24,35.82 74.35,35.82 75.36,34.81 76.63,34.81 v3(76.81,34.99) 81.1,39.28 v3(84.89,39.28) ; v3(71.36,65.73) 71.2,65.57 69.19,65.57 68.4,66.35 67.72,66.35 67.43,66.06 64.95,66.06 ; v3(62.66,59.12) 63.62,58.15 64.11,58.15 64.72,58.76 71.15,58.76 71.33,58.76 71.72,59.16 71.72,59.82 v3(71.96,60.06) 72.24,60.34 74.88,60.34 76.09,59.12 79.58,59.12 80.41,59.12 82.02,60.73 83.98,60.73 85.6,59.11 v3(85.6,58.51)
  L6-GND w0.102: v3(34.01,63.51) 34.21,63.71 v1(34.21,63.94) ; v3(79.78,72.89) 79.78,73.24 v4(79.79,73.25) ; v1(76.81,34.55) v3(76.81,34.99) ; v3(71.96,60.06) v1(71.42,60.06)
  L7-SIG w0.084: v1(85.55,89.87) 84.95,90.46 83.85,90.46 83.27,89.88 83.27,89.73 81.92,88.39 81.92,86.7 81.92,86.69 81.92,86.3 81.92,86.3 81.92,86.18 81.92,86.18 81.92,86.02 81,85.1 81,83.32 79.07,81.39 79.07,80.73 79.58,80.22 79.58,73.45 v4(79.79,73.25)
PLTRST#_R: length 6.7
  L7-SIG w0.102: v1(71.36,64.78) 70.67,64.09 70.67,62.06 v1(71.04,61.68)
  BOTTOM w0.254: v1(71.04,61.68) R3084.1 71.04,61.38 70.59,60.92 70.59,59.73 70.91,59.41 Q3009.3
PMC_ACPRESENT: length 2.8
  L3-GND w0.06: v8(61.85,67.52) v3(62.21,67.88)
  L5-SIG w0.06: v6(60.21,68.73) 60.47,68.73 60.78,68.41 61.34,68.41 61.75,68.01 62.08,68.01 v3(62.21,67.88)
PMIC_5V_EN: length 81.2
  L2-SIG w0.102: v8(71.66,47.75) 72.59,46.82 72.59,35.42 78.74,29.27 78.74,24.83 78,24.09 78,23.25 75.16,20.41 60.53,20.41 60.19,20.75 v8(60.19,20.76)
  L3-GND w0.102: v8(71.66,47.75) 71.68,47.75 71.87,47.94 v3(71.96,47.94) ; v3(60.4,21.15) 60.4,21.14 60.19,20.93 v8(60.19,20.76)
  L5-SIG w0.06: 60,31.23 59.54,31.68 59.54,33.41 59.37,33.58 59.37,33.82 59.52,33.98 v6(59.52,34.14)
  L5-SIG w0.102: v3(46.45,13.72) 52.55,13.72 57.69,18.86 60.41,18.86 60.99,19.44 60.99,19.95 60.4,20.53 v3(60.4,21.15) 60.4,21.32 60.66,21.57 60.66,30.57 60,31.23
  L6-GND w0.102: v1(72.3,48.09) v3(71.96,47.94) ; v1(46.1,13.37) 46.41,13.68 46.41,13.68 v3(46.45,13.72)
PMIC_AC_OK: length 99.7
  L4-SIG w0.102: v3(37.08,39.33) 37.3,39.33 39.07,37.56 39.07,22.29 39.9,21.45 42.77,21.45 43.71,20.51 45.37,20.51 46.37,19.52 48,19.52 49.34,20.86 53.11,20.86 54.46,19.52 v3(57.43,19.52) ; v3(71,47.59) 70.08,46.67 47.5,46.67 47.35,46.82 47.04,46.82 46.94,46.73 v3(44.2,46.73) ; v3(39.78,39.86) 40.13,40.22 v3(40.13,43.11)
  L5-SIG w0.06: v6(57.52,34.94) 57.49,34.94 57.29,35.13 56.97,35.13 56.4,35.7 56.02,36.08 55.09,36.08
  L5-SIG w0.102: 55.09,36.08 54.97,36.08 54.44,35.54 53.87,35.54 53.16,36.26 46.53,36.26 45.77,37.02 42.8,37.02 42.57,36.79 41.89,36.79 40.12,38.55 40.12,39.52 v3(39.78,39.86) 39.24,39.33 v3(37.08,39.33) ; v3(40.13,43.11) 43.75,46.73 v3(44.2,46.73)
  L6-GND w0.102: v1(71,47.94) v3(71,47.59) ; v3(57.43,19.52) 57.56,19.65 v1(57.56,20)
PMIC_BACKLIGHT_EN: length 67.9
  L4-SIG w0.109: v3(64.89,13.43) 62.87,15.45 57.97,15.45 56.15,17.27 45.94,17.27 42.26,20.96 39.59,20.96 38.47,22.07 38.47,33.27 38.09,33.65 38.09,36.04 38.42,36.37 38.42,37.62 37.34,38.69 36.88,38.69 36.49,39.08 36.49,39.93 34.57,41.85 34.57,42.53 v3(34.29,42.81)
  L5-SIG w0.109: v3(45.9,44.87) 45.75,44.71 44.1,44.71 42.58,43.19 42.14,43.19 41.45,42.5 34.6,42.5 v3(34.29,42.81)
  L6-GND w0.102: v3(64.89,13.43) 65.35,13.9 v1(65.6,13.9) ; v1(46.3,45.12) 46.15,45.12 v3(45.9,44.87)
  L7-SIG w0.084: v1(47.07,45.12) v1(46.3,45.12)
PMIC_BODYSAR_N: length 8.8
  L3-GND w0.102: v3(53.32,41.03) 52.94,41.03 v8(52.91,41.06)
  L5-SIG w0.06: v6(57.92,35.34) 57.92,35.43 57.7,35.66 57.7,35.82 57.58,35.94 57.01,35.94 56.21,36.74 56.21,37.19 55.39,38 55.39,38.59
  L5-SIG w0.102: v3(53.32,41.03) 53.39,41.03 53.67,40.74 54.33,40.74 55.39,39.69 55.39,38.59
PMIC_CHGDET#: length 5.5
  L5-SIG w0.06: v6(61.12,36.54) 61.12,37.33 62.18,38.39 62.18,38.59
  L5-SIG w0.102: v3(62.87,40.93) 62.86,40.93 62.18,40.25 62.18,38.59
  L6-GND w0.102: v1(63.27,40.93) v3(62.87,40.93)
PMIC_CHGRINT#: length 25.9
  L5-SIG w0.102: v3(62.84,40.37) 62.85,40.37 64.24,41.76 64.24,42.46 64.92,43.14 70.2,43.14 73.47,39.87 73.47,36.67 v3(73.91,36.23)
  L6-GND w0.06: 61.43,38.59 60.35,37.51 v6(60.35,37.34)
  L6-GND w0.102: v3(73.91,36.23) 73.89,36.2 v1(73.36,36.2) ; 61.43,38.59 62.36,39.52 62.36,39.89 v3(62.84,40.37)
  BOTTOM w0.102: v1(73.36,36.2) 73.36,35.97 R8457.2 73.34,34.91 74.14,34.91 74.42,34.63 R8458.1 R8456.1
PMIC_ILIM0: length 3.8
  L3-GND w0.102: v3(54.28,35.93) 54.1,36.1 v8(54.1,36.31)
  L5-SIG w0.06: 55.09,36.28 55.99,36.28 56.93,35.34 v6(57.12,35.34)
  L5-SIG w0.102: v3(54.28,35.93) 54.64,36.28 55.09,36.28
PMIC_ILIM1: length 5.3
  L3-GND w0.102: v8(52.71,35.26) 52.96,35.52 v3(52.96,35.57)
  L5-SIG w0.06: 55.09,35.87 56.05,35.87 56.35,35.58 57.02,34.91 v6(57.12,34.91)
  L5-SIG w0.102: v3(52.96,35.57) 53.19,35.34 54.52,35.34 55.06,35.87 55.09,35.87
PMIC_INT: length 76.8
  L4-SIG w0.109: v3(79.88,58.12) 79.88,57.74 82.02,55.61 82.02,54.24 83.02,53.24 83.02,47.21 v3(82.6,46.8)
  L5-SIG w0.06: v6(59.15,35.74) 59.32,35.92 59.32,36.24 59.46,36.38 59.56,36.38 60.27,37.09 60.5,37.09 60.61,37.2
  L5-SIG w0.109: 60.61,37.2 61.67,38.26 61.67,41.11 64.11,43.55 65.38,44.82 66.29,45.73 80.77,45.73 81.84,46.8 v3(82.6,46.8)
  L6-GND w0.102: v3(79.88,58.12) 79.88,57.97 v4(79.71,57.79)
  L7-SIG w0.06: 59.77,61.93 58.81,62.89 58.81,62.98 57.88,63.9 57.88,64.61 57.65,64.84 57.65,65.5 58.05,65.9 58.31,65.9 58.47,66.06 58.47,66.21 58.7,66.43 59.83,66.43 60.09,66.69 60.09,67.44 60.16,67.5 v6(60.16,67.63)
  L7-SIG w0.084: v4(79.71,57.79) 79.71,57.44 79.66,57.39 79.66,56.78 79.46,56.58 71.12,56.58 70.1,57.6 69.54,57.6 68.92,58.22 67.15,58.22 67.02,58.09 64.61,58.09 64.09,57.57 62.63,57.57 62.48,57.73 62.37,57.84 61.71,57.84 61.01,58.54 v1(61.01,58.91) 61.01,59.35 60.68,59.68 60.68,60.06 60.72,60.1 60.72,61.34 60.58,61.48 60.22,61.48 59.77,61.93
PMIC_MEMCFG0: length 18.8
  L5-SIG w0.06: v6(58.27,34.54) 58.07,34.33 57.84,34.33 57.71,34.46 56,34.46 55.8,34.66 55.09,34.66
  L5-SIG w0.102: 55.09,34.66 54.76,34.66 54.2,34.09 51.47,34.09 49.96,35.6 46.23,35.6 45.47,36.36 44.03,36.36 v3(43.27,35.6)
  L6-GND w0.102: v1(42.85,35.6) v3(43.27,35.6)
  BOTTOM w0.102: v9(43.03,34.7) 43.03,35.41 v1(42.85,35.6) 42.85,35.6 R0515.2
PMIC_MEMCFG1: length 15.6
  L5-SIG w0.06: 55.09,34.45 55.18,34.45 55.23,34.5 55.69,34.5 55.86,34.34 57.32,34.34 v6(57.52,34.14)
  L5-SIG w0.102: v3(44.3,35.95) 45.59,35.95 46.14,35.39 49.86,35.39 51.37,33.89 54.28,33.89 54.85,34.45 55.09,34.45
  L6-GND w0.102: v1(44.04,36.33) 44.3,36.08 v3(44.3,35.95)
  BOTTOM w0.102: v1(44.04,36.33) 43.92,36.46 R0514.2
PMIC_MODEM_OFF#: length 3.1
  L3-GND w0.102: v8(59.97,39.18) 59.97,39.53 v3(60.12,39.68)
  L6-GND w0.102: v3(60.12,39.68) 60.12,38.59 59.81,38.28 59.81,37.87 59.57,37.63 v6(59.57,37.34)
PMIC_PANEL_EN: length 22.9
  L5-SIG w0.06: 58.19,31.23 58.27,31.3 58.27,34.03 58.63,34.39 58.8,34.39 58.92,34.51 58.92,35.02 58.92,35.03 58.92,35.43 58.73,35.61 v6(58.73,35.74)
  L5-SIG w0.109: 58.19,31.23 58.17,31.2 58.17,30.74 57.92,30.49 57.92,24.16 57.64,23.88 57.64,21.67 56.86,20.89 56.86,18.89 v2(53.76,15.79)
  BOTTOM w0.31: v2(53.76,15.79) 53.64,15.67 R7147.1
PMIC_PWRBTN#: length 146.1
  L2-SIG w0.102: v2(83.57,88.27) 82.58,87.28 75.64,87.28 v8(75.4,87.52)
  L3-GND w0.102: v8(75.4,87.52) v3(75.03,87.52)
  L4-SIG w0.102: v3(81.31,24.67) 81.46,24.52 81.46,21.93 v3(81.33,21.81) ; v2(83.57,88.27) 84.19,88.27 85.08,89.16 v3(87.28,89.16) ; v3(83.96,67.93) 83.96,67.27 85.96,65.26 85.96,61.65 86.94,60.66 86.94,58.17 87.37,57.75 87.37,34.88 87.02,34.53 87.02,31.68 v3(86.28,30.95)
  L5-SIG w0.06: 62.33,34.3 61.66,34.3 61.36,34.6 60.52,34.6 60.01,35.11 59.61,35.11 59.61,35.11 59.44,35.11 59.26,34.94 v6(59.13,34.94)
  L5-SIG w0.102: 62.33,34.3 62.52,34.3 63.76,33.06 66.97,33.06 67.53,33.61 73.84,33.61 74.5,32.95 74.5,32.11 74.72,31.89 75.04,31.89 75.34,32.19 75.34,32.4 75.59,32.65 75.9,32.65 76.23,32.32 76.23,32.32 76.66,31.89 77.45,31.89 78.59,33.03 79.43,33.03 79.73,33.33 81.29,33.33 81.84,32.79 81.84,25.21 v3(81.31,24.67) ; v3(86.28,30.95) 84.23,28.89 84.23,23.39 82.65,21.81 v3(81.33,21.81)
  L6-GND w0.102: v3(87.28,89.16) 87.37,89.07 v1(87.65,89.07) ; v3(75.03,87.52) 75.02,87.52 v4(74.75,87.26) ; v4(83.58,67.91) 83.94,67.91 v3(83.96,67.93)
  L7-SIG w0.102: v1(77.73,76.78) 77.24,77.27 77.24,79.6 77.03,79.82 76.48,79.82 75.26,81.04 75.26,83.35 74.91,83.7 74.91,85.38 75.07,85.55 75.11,85.58 75.11,86.01 74.67,86.45 74.67,87.18 v4(74.75,87.26) ; v2(83.57,88.27) 84.05,87.79 84.05,86.23 85.27,85.01 85.27,84.78 84.85,84.36 84.43,84.36 82.75,82.69 82.75,70.93 83.58,70.11 v4(83.58,67.91) 81.97,66.31 81.97,65.52 v1(79.39,62.94)
  BOTTOM w0.102: v9(88.85,88.81) 88.59,89.07 v1(87.65,89.07)
PMIC_ROTATION_LOCK: length 4.5
  L3-GND w0.102: v8(57.94,30.72) 57.94,30.9 57.66,31.18 v3(57.66,31.15)
  L5-SIG w0.06: 57.73,31.23 58.14,31.63 58.14,34.07 58.61,34.54 58.66,34.54 v6(58.72,34.6)
  L5-SIG w0.102: 57.73,31.23 v3(57.66,31.15)
PMIC_RTC_POR: length 31.5
  L5-SIG w0.06: v6(58.71,35.34) 58.53,35.52 58.53,36.07 60.53,38.07 60.53,38.59
  L5-SIG w0.109: 60.53,38.59 60.53,39.89 60.08,40.34 60.08,45.62 56.34,49.36 46.21,49.36 v3(45.31,50.25)
  L6-GND w0.102: v4(45.14,50.66) 45.31,50.48 v3(45.31,50.25)
  L7-SIG w0.084: v1(46.4,53.12) 46.4,53.12 46.4,53.02 45.14,51.76 v4(45.14,50.66)
PMIC_SHUTDOWN#: length 8.2
  L3-GND w0.102: v3(55.27,41.44) 55.68,41.44 v8(55.98,41.13)
  L5-SIG w0.06: 56.22,38.59 56.22,38.47 56.75,37.94 56.75,36.92 57.06,36.61 57.75,36.61 58.09,36.26 58.09,36.05 58.32,35.82 v6(58.32,35.74)
  L5-SIG w0.102: v3(55.27,41.44) 56.22,40.49 56.22,38.59
PMIC_THERMTRIP_B: length 113.9
  L4-SIG w0.102: v3(79.87,2.17) 79.87,11.44 84.62,16.2 v3(84.62,23.56) ; v3(71.53,30.42) 72.37,31.25 72.37,33.83 71.87,34.33 71.87,35.53 72.37,36.03 72.37,37.06 73.03,37.72 73.03,40.33 68.72,44.64 v3(60.93,44.64) ; v3(40.54,50.63) 42.01,50.63 43.31,49.34 53.97,49.34 54.63,50 v3(56.08,50)
  L5-SIG w0.06: v6(59.12,35.34) 59.12,35.47 58.94,35.65 58.94,35.99 58.92,36.01 58.92,36.22 61.25,38.56 61.25,38.59
  L5-SIG w0.102: 61.25,38.59 61.25,44.32 v3(60.93,44.64) 60.93,45.46 59.23,47.15 56.39,50 v3(56.08,50) ; v3(81.07,24.05) 79.62,25.49 79.62,27.79 78.36,29.06 72.89,29.06 v3(71.53,30.42)
  L6-GND w0.102: v4(81.07,23.69) v3(81.07,24.05) ; v3(84.62,23.56) v4(84.62,23.2) ; v1(40.26,50.35) v3(40.54,50.63) ; v4(79.87,1.77) v3(79.87,2.17)
  L7-SIG w0.102: v4(81.07,23.69) 82.54,23.69 83.02,23.2 v4(84.62,23.2) ; v1(79.49,3.25) 79.49,2.14 v4(79.87,1.77) 80.04,1.6 87.5,1.6 v1(87.76,1.85) ; v1(41.28,52.5) 40,51.22 40,50.62 v1(40.26,50.35)
PMIC_TOUCH_EN: length 52.3
  L4-SIG w0.109: v3(37.82,36.99) 37.67,36.84 37.67,33.47 38.02,33.12 38.02,21.92 39.44,20.51 40.92,20.51 43.71,17.71 43.71,16.55 v3(45.97,14.28)
  L5-SIG w0.06: v6(57.92,34.54) 57.87,34.59 56.51,34.59 56.41,34.68
  L5-SIG w0.109: v3(37.82,36.99) 40.08,36.99 42.01,35.07 42.02,35.07 42.03,35.06 42.35,35.06 42.57,35.28 42.57,35.29 42.85,35.56 42.85,35.77 43.64,36.56 45.55,36.56 46.31,35.8 50.05,35.8 50.06,35.79 50.19,35.79 51.69,34.3 54.06,34.3 55.09,35.33 55.77,35.33 56.41,34.68
  L6-GND w0.102: v4(45.8,13.95) 45.8,14.11 v3(45.97,14.28)
  L7-SIG w0.084: v4(45.8,13.95) 45.8,12.93 v1(46.1,12.63)
PMIC_VBUS_EN: length 55.3
  L4-SIG w0.102: v3(73.84,49.67) 74.5,49.01 74.5,47.15 73.84,46.49 73.84,42.58 74.5,41.92 74.5,36.24 72.82,34.56 72.82,33.66 72.57,33.41 72.57,29.13 70.2,26.76 68.36,26.76 67.39,25.79 62.22,25.79 59.5,23.07 58.55,23.07 v3(58.04,23.58)
  L5-SIG w0.06: 58.42,31.23 58.4,31.25 58.4,33.94 58.63,34.17 v6(58.72,34.17)
  L5-SIG w0.102: 58.42,31.23 58.42,30.64 58.16,30.38 58.16,23.7 v3(58.04,23.58)
  L6-GND w0.102: v4(73.46,49.67) v3(73.84,49.67)
  L7-SIG w0.102: v4(73.46,49.67) 71.85,51.27 v1(71.85,53.53)
PMIC_VIBRATOR_PWM: length 29.2
  L4-SIG w0.109: v3(39.4,40.68) 39.4,43.07 39.68,43.35 39.68,46.72 38.63,47.76 v3(37.91,48.48)
  L5-SIG w0.06: 55.09,36.94 55.45,36.94 55.68,36.71 56.06,36.71 57,35.78 57.3,35.78 57.35,35.74 v6(57.49,35.74)
  L5-SIG w0.109: 55.09,36.94 46.93,36.94 46.09,37.78 42.81,37.78 42.57,38.02 42.57,38.02 39.91,40.68 v3(39.4,40.68)
  L6-GND w0.102: v1(38.14,48.75) 37.91,48.52 v3(37.91,48.48)
PMIC_VOLUMEDOWN#: length 107.1
  L4-SIG w0.109: v3(68.89,25.49) 68.43,25.03 63.86,25.03 61.55,22.71 58.64,22.71 58.16,22.23 54.65,22.23 54.36,22.51 53.86,23.02 51.94,23.02 50.85,21.93 44.55,21.93 39.98,26.5 39.98,37.92 35.69,42.21 35.69,54.09 v3(34.98,54.8)
  L5-SIG w0.06: 60.66,31.23 59.69,32.2 59.69,33.57 59.57,33.69 v6(59.57,33.74)
  L5-SIG w0.109: v3(68.89,25.49) 66.4,25.49 60.66,31.23 ; v3(22.19,55.05) 22.63,55.49 34.28,55.49 v3(34.98,54.8)
  L6-GND w0.102: v3(68.89,25.49) v1(69.29,25.89) ; v3(22.19,55.05) 21.98,55.26 v4(21.89,55.26)
  L7-SIG w0.084: v1(9.32,59.98) 10.5,61.15 10.5,61.16 10.66,61.33 16.46,61.33 20.68,57.11 20.68,56.48 v4(21.89,55.26)
PMIC_VOLUMEUP#: length 108.7
  L4-SIG w0.109: v3(34.52,54.37) 35.47,53.41 35.47,42.13 39.77,37.83 39.77,26.41 44.47,21.71 50.99,21.71 52.08,22.8 53.77,22.8 54.56,22.02 58.25,22.02 58.73,22.5 61.63,22.5 63.95,24.82 68.76,24.82 69.55,25.6 v3(69.55,26.3)
  L5-SIG w0.06: v6(59.92,33.74) 59.92,32.27 60.96,31.23
  L5-SIG w0.109: 60.96,31.23 66.3,25.89 69.14,25.89 v3(69.55,26.3) ; v3(34.52,54.37) 34.52,54.9 34.14,55.28 23.05,55.28 22.79,55.01 v3(22.77,55.01)
  L6-GND w0.102: v3(22.77,55.01) 22.77,55.02 22.59,55.19 v4(22.59,55.32) ; v1(69.29,26.65) 69.55,26.4 v3(69.55,26.3)
  L7-SIG w0.084: v4(22.59,55.32) 21.36,56.55 21.36,57.26 16.54,62.09 9.6,62.09 v1(9.32,62.37)
PMU_BATTLOW#: length 69.9
  L4-SIG w0.109: v3(70.43,55.09) 70.43,56.79 70.06,57.16 70.06,61.82 67.96,63.91 67.96,64.78 67.31,65.43 67.31,67.14 66.37,68.09 66.37,70.26 67.59,71.48 67.59,72.06 67.55,72.1 v3(67.55,72.16)
  L6-GND w0.06: v6(58.72,36.54) 58.89,36.7 58.89,37.03 58.71,37.21 58.71,38.01
  L6-GND w0.102: v4(70.38,54.71) 70.43,54.77 v3(70.43,55.09) ; v3(67.55,72.16) 67.44,72.27 v1(67.03,72.27) ; v4(81.77,55.69) 81.77,54.61 v4(81.92,54.45) ; 58.71,38.01 58.71,38.1 59.28,38.67 59.28,39.96 59.67,40.34 59.67,42.11 60.05,42.49 60.05,45.07 v4(59.59,45.53)
  L7-SIG w0.084: v4(70.38,54.71) 70.42,54.71 70.93,54.2 79.99,54.2 81.48,55.69 v4(81.77,55.69) ; v4(59.59,45.53) 60.25,46.19 66.76,46.19 67.15,46.57 71.53,46.57 72.57,47.61 75.52,47.61 78.35,50.45 78.35,50.66 81.92,54.23 v4(81.92,54.45)
PMU_BATTLOW#_R: length 14.8
  L4-SIG w0.109: v3(67.69,70.7) 68.01,70.7 v3(68.4,71.09)
  L6-GND w0.102: v3(68.4,71.09) 68.73,71.09 69.25,71.61 69.25,72.28 v4(68.97,72.56) ; v4(67.79,70.34) 67.79,70.6 v3(67.69,70.7)
  L7-SIG w0.06: 60.86,69.76 60.43,69.33 v6(60.25,69.33)
  L7-SIG w0.084: 60.86,69.76 60.94,69.83 61.42,69.83 61.49,69.76 62.83,69.76 63.22,70.16 65.61,70.16 65.79,70.33 65.79,70.67 65.96,70.85 66.44,70.85 66.95,70.34 v4(67.79,70.34) ; v4(68.97,72.56) 68.88,72.47 67.34,72.47 v1(67.03,72.78) v1(66.4,72.78)
PROCHOT#: length 119.6
  L4-SIG w0.109: v3(84.86,38.47) 85.21,38.47 87.16,40.42 87.16,57.66 86.59,58.23 86.59,59.17 85.76,60 85.76,65.18 81.15,69.79 v3(80.38,69.79) ; v3(80.22,89.05) 79.7,89.05 75.32,84.66 75.32,80.53 74.73,79.94 73.56,79.94 69.73,76.11 69.73,73.03 70.54,72.22 70.54,71.38 v3(70.31,71.15)
  L5-SIG w0.06: 61.91,35.51 60.51,35.51 60.07,35.94 59.72,35.94 v6(59.52,35.74)
  L5-SIG w0.109: v3(80.38,69.79) 79.85,70.32 79.85,71.56 81.89,73.6 81.89,87.86 80.7,89.05 v3(80.22,89.05) ; v3(84.86,38.47) 84.69,38.3 81.05,38.3 77.14,34.39 74.31,34.39 73.53,35.16 73.08,35.16 72.48,35.76 70.48,35.76 70.14,36.09 62.5,36.09 61.91,35.51
  L6-GND w0.102: v3(70.31,71.15) 70.09,71.15 v4(69.98,71.27)
  L7-SIG w0.06: v6(60.21,71.61) 60.26,71.66 61.73,71.66 61.85,71.54 62.08,71.54 62.13,71.59
  L7-SIG w0.084: v4(69.98,71.27) 67.75,71.27 67.6,71.43 66.24,71.43 66.05,71.62 65.42,71.62 65.1,71.31 v6(64.87,71.31) 64.52,71.31 64.24,71.59 62.13,71.59
PROG_SPI_CS#: length 16.5
  L7-SIG w0.084: v1(87.65,91.47) 87.03,90.85 83.72,90.85 82.89,90.03 82.89,89.89 82.63,89.62 82.49,89.62 80.89,88.02 80.89,86.14 79.96,85.21 79.28,85.21 78.93,85.56 77.34,85.56 76.04,86.86 v1(76.04,87.24)
PROG_SPI_IO3: length 37.1
  L5-SIG w0.109: v3(80.69,78.31) 80.69,79.67 78.75,81.61 78.75,84.83 v2(78.92,85)
  L6-GND w0.102: v1(80.69,77.92) v3(80.69,78.31)
  L7-SIG w0.084: v1(77.04,87.24) 76.78,87.5 76.78,88 v1(76.54,88.24) 75.77,87.47 75.77,86.62 76.29,86.1 v1(76.29,85.13) ; v1(87.65,90.67) 87.18,90.67 87.18,90.66 83.79,90.66 83.08,89.95 83.08,89.81 82.71,89.44 82.56,89.44 81.07,87.95 81.07,86.06 80.01,85 v2(78.92,85) 77.45,85 76.94,85.51 76.67,85.51 v1(76.29,85.13) ; v1(76.29,85.13) 75.77,85.13 v1(75.75,85.11) 76.01,84.84 76.01,81.25 77.05,80.21 77.19,80.21 77.59,79.82 77.7,79.71 77.7,78.26 v1(78.24,77.72)
PROG_SPI_MISO: length 15.6
  L7-SIG w0.084: v1(76.54,86.74) 77.52,85.76 79.02,85.76 79.39,85.39 79.88,85.39 80.7,86.21 80.7,88.1 82.41,89.81 82.55,89.81 82.71,89.97 82.71,90.11 83.64,91.04 86.95,91.04 87.38,91.46 87.38,91.6 v1(87.65,91.87)
PROG_SPI_MOSI: length 16.7
  L7-SIG w0.084: v1(87.65,92.27) 87.19,91.81 87.19,91.54 86.87,91.22 83.43,91.22 82.99,91.67 82.1,91.67 81.78,91.35 81.78,89.46 80.52,88.2 80.52,86.29 79.81,85.58 79.48,85.58 79.07,85.99 77.75,85.99 77.01,86.72 v1(77.01,86.74)
PSEL: length 3.6
  L7-SIG w0.084: v1(34.49,18.41) 35.09,19.02 35.09,20.36 v1(34.64,20.81) 34.64,21.49 v1(34.72,21.58)
PWR_3P3_SX_EN: length 52.7
  L4-SIG w0.109: v3(43.76,53.02) 43.99,52.8 45.23,52.8 45.87,52.16 63.21,52.16 64.08,53.03 64.08,54 67.14,57.06 67.14,61.06 65.6,62.61 65.6,63.84 63.47,65.96 62.73,66.7 62.5,66.7 61.48,67.72 61.48,69.18 61.7,69.4 62.44,69.4 v3(62.81,69.77)
  L6-GND w0.102: v3(43.76,53.02) 43.46,53.32 v4(43.41,53.32) ; v3(62.81,69.77) 62.69,69.77 v5(62.47,69.99)
  L7-SIG w0.06: v6(59.08,70.39) 59.87,70.39 60.28,69.99 v5(62.47,69.99)
  L7-SIG w0.084: v1(39.5,50.35) 39.5,51.35 v1(40,51.85) 41.47,53.32 v4(43.41,53.32)
PWR_AMBER_LED#: length 108.7
  L4-SIG w0.102: v2(73.86,69.5) 73.41,69.05 73.41,68.66 73.41,68.66 73.41,67.5 73.33,67.42 73.33,66.56 74.4,65.49 74.4,63.95 74.43,63.91 74.43,63.15 74.78,62.8 74.78,60.24 75.06,59.96 75.06,58.86 73.16,56.96 73.16,51.33 69.06,47.23 48.05,47.23 47.16,48.12 42.87,48.12 41.34,49.65 39.65,49.65 39.19,49.18 38.65,49.18 38.33,49.51 38.33,51.13 39.28,52.08 v3(39.28,54.77)
  L5-SIG w0.102: v3(23.95,56.18) 24.15,56.38 34.3,56.38 35.88,54.8 39.25,54.8 v3(39.28,54.77)
  L6-GND w0.102: v4(23.68,55.94) 23.92,56.18 v3(23.95,56.18)
  L7-SIG w0.102: v1(4.15,62.85) 4.73,62.85 5.1,63.22 9.67,63.22 10.04,62.84 16.67,62.84 22.28,57.24 22.28,56.6 22.94,55.94 v4(23.68,55.94)
  BOTTOM w0.102: U3001.57 73.1,68.74 v2(73.86,69.5)
PWR_BLUE_LED#: length 94.6
  L4-SIG w0.102: v3(74.17,59.68) 73.43,58.93 73.43,58.46 72.59,57.62 72.59,51.59 v3(71.96,50.96)
  L5-SIG w0.102: v3(23.32,56.22) 23.68,56.58 34.38,56.58 35.89,55.08 39.05,55.08 39.12,55.15 39.5,55.15 40.08,54.57 42.99,54.57 43.6,53.96 46.79,53.96 48.76,51.99 53.72,51.99 53.72,51.99 54.8,51.99 57.46,51.99 59.32,50.12 71.07,50.12 71.91,50.96 v3(71.96,50.96)
  L6-GND w0.102: v3(74.17,59.68) 74.17,59.68 v4(74.17,60.03) ; v3(23.32,56.22) 23.24,56.3 22.98,56.3 v4(22.97,56.3)
  L7-SIG w0.102: v4(74.17,60.03) 74.42,60.03 74.83,60.44 74.83,62.43 74.53,62.74 74.53,66 76,67.47 76,67.88 76.46,68.34 v1(76.86,68.34) ; v4(22.97,56.3) 22.97,56.94 16.74,63.16 10.13,63.16 9.78,63.51 4.96,63.51 4.79,63.35 v1(4.15,63.35)
PWRBTN#: length 94.2
  L4-SIG w0.102: v3(75.51,49.92) 75.51,56.61 76.23,57.33 76.23,61.82 v3(76.51,62.09)
  L5-SIG w0.102: v3(24.69,56) 24.75,55.94 34.44,55.94 35.79,54.6 37.3,54.6 37.53,54.37 42.91,54.37 43.52,53.76 46.71,53.76 48.67,51.79 53.81,51.79 57.37,51.79 59.24,49.92 71.25,49.92 71.45,50.12 75.31,50.12 v3(75.51,49.92)
  L6-GND w0.102: v3(24.69,56) 24.42,56 v4(24.33,55.92) ; v1(77.78,62.85) 77.24,62.85 76.51,62.11 v3(76.51,62.09)
  L7-SIG w0.102: v4(24.33,55.92) 24.08,55.66 22.93,55.66 21.9,56.69 21.9,57.31 16.64,62.57 9.91,62.57 9.65,62.83 v1(7.27,62.83) 5.13,62.83 v1(4.15,61.85)
  BOTTOM w0.102: T2012.1 7.89,63.46 v1(7.27,62.83) ; R3046.1 v1(77.78,62.85)
PWRBTN#_EC: length 14.3
  BOTTOM w0.102: R3047.2 R3045.1 76.25,64.12 76.12,64.25 76.12,66.31 74.43,68 73.66,68 73.29,67.63 73.29,65.98 72.59,65.29 70.03,65.29 69.76,65.02 U3001.48
R_BT_PCM_IN: length 13.4
  L5-SIG w0.109: v3(16.36,85.05) 14.94,85.05 13.3,83.42 v3(4.4,83.42)
  L6-GND w0.102: v3(4.4,83.42) 4.28,83.29 v1(4,83.29) ; v1(16.71,85.05) v3(16.36,85.05)
R_BT_PCM_OUT: length 13.7
  L5-SIG w0.109: v3(4.33,83.97) 13.35,83.97 15.37,85.99 v3(16.36,85.99)
  L6-GND w0.102: v1(4,83.79) 4.15,83.79 v3(4.33,83.97) ; v1(16.71,85.81) 16.54,85.81 v3(16.36,85.99)
R_BT_UART_CTS_N: length 13.1
  L5-SIG w0.109: v3(4.52,80.81) 4.79,81.07 15.81,81.07 v3(16.36,80.53)
  L6-GND w0.102: v3(4.52,80.81) 4.5,80.79 v1(4,80.79) ; v1(16.71,80.53) v3(16.36,80.53)
R_BT_UART_RTS_N: length 12.9
  L5-SIG w0.109: v3(4.74,82.42) 13.66,82.42 14.05,82.81 v3(16.36,82.81)
  L6-GND w0.102: v1(16.71,82.81) v3(16.36,82.81) ; v3(4.74,82.42) 4.33,82.42 4.2,82.29 v1(4,82.29)
R_BT_UART_RXD: length 12.9
  L5-SIG w0.109: v3(16.36,82.05) 16.13,81.82 4.52,81.82 v3(4.39,81.95)
  L6-GND w0.102: v1(16.71,82.05) v3(16.36,82.05) ; v3(4.39,81.95) 4.23,81.79 v1(4,81.79)
R_BT_UART_TXD: length 12.9
  L5-SIG w0.109: v3(4.48,81.4) 4.65,81.57 16.08,81.57 v3(16.36,81.29)
  L6-GND w0.102: v3(4.48,81.4) 4.37,81.29 v1(4,81.29) ; v1(16.71,81.29) v3(16.36,81.29)
R_I2S_1_RXD: length 47.2
  L4-SIG w0.109: v3(45.01,65.31) 44.74,65.58 44.74,65.61 44.41,65.95 38.46,65.95 35.62,68.78 33.1,68.78 31.31,70.57 30.96,70.57 26.83,74.7 26.25,74.7 v2(23.29,77.66)
  L5-SIG w0.06: v3(45.01,65.31) 45.38,65.31 46.2,66.13 46.2,66.78 46.7,67.28 46.93,67.28 47.04,67.39 47.68,67.39 47.83,67.24 v6(48.03,67.24)
  L7-SIG w0.084: v1(17.58,85.81) 17.21,85.44 16.41,85.44 15.47,84.5 15.47,81.13 16.8,79.79 17.72,79.79 18.44,79.08 19.05,79.08 20.47,77.66 v2(23.29,77.66)
  BOTTOM w0.31: v9(22.76,77.12) v2(23.29,77.66)
