# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Nets (continued)
GND: C0706.2 C0707.2 C0708.2 C0710.2 C0713.2 C0714.2 C0715.2 C0722.1 C0787.2 C0901.2 C0910.2 C0951.2 C0952.2 C1010.2 C1020.1 C1021.1 C1022.2 C1023.1 C1024.2 C1029.2 C1030.2 C1044.2 C1045.2 C1046.2 C1047.2 C1060.2 C1061.2 C1062.2 C1063.2 C1601.2 C1602.2 C1603.2 C1604.2 C1605.2 C1606.2 C1607.2 C1608.2 C1609.2 C1614.2 C1615.2 C1616.2 C1617.2 C1618.2 C1619.2 C1622.2 C1623.2 C1624.2 C1625.2 C1701.2 C1702.2 C1703.2 C1704.2 C1705.2 C1707.2 C1709.2 C1710.2 C1711.2 C1712.2 C1713.2 C1714.2 C1715.2 C1716.2 C1717.2 C1722.2 C1723.2 C1724.2 C1725.2 C1900.2 C1902.2 C1903.2 C1904.2 C1905.2 C1909.2 C1911.2 C1912.2 C1913.2 C1914.2 C1915.2 C1916.2 C2011.2 C2036.2 C2101.2 C2102.2 C2122.2 C2124.2 C2125.2 C2126.1 C2127.2 C2301.1 C2401.2 C2600.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2606.2 C2608.2 C2610.2 C2611.2 C2612.2 C2701.2 C2706.2 C2707.2 C2709.2 C2710.2 C2713.2 C2717.2 C2718.2 C2722.2 C2723.2 C2724.2 C2727.2 C2728.2 C2729.2 C2730.2 C2732.2 C2733.2 C2734.2 C2735.2 C2736.2 C2737.2 C2747.2 C2748.2 C2752.2 C2753.2 C2754.2 C2758.2 C2759.2 C2760.2 C2761.2 C2762.2 C2763.2 C2766.2 C2767.2 C2768.2 C2771.2 C2772.2 C2773.2 C2774.2 C2776.2 C2777.2 C2800.2 C2802.2 C2803.2 C2804.2 C2806.2 C2807.2 C2808.2 C2809.2 C2810.2 C2811.2 C2814.2 C2815.2 C2816.2 C2817.2 C2818.2 C2819.2 C2820.2 C2821.2 C2822.2 C2823.2 C2824.2 C2825.2 C3001.2 C3004.2 C3005.2 C3006.2 C3007.2 C3008.2 C3009.2 C3010.2 C3011.2 C3101.2 C3311.2 C3316.2 C3317.1 C3318.2 C3319.2 C3801.2 C5101.2 C5102.2 C5103.2 C5209.2 C5210.2 C5211.2 C5212.2 C5214.2 C5215.2 C5216.2 C5217.2 C5401.2 C5402.2 C5403.2 C5404.2 C5405.2 C5406.2 C5407.2 C5410.2 C5411.2 C5412.2 C5413.2 C5414.2 C5415.2 C5416.2 C5417.2 C5810.2 C5811.2 C5812.2 C5813.2 C5819.2 C5820.2 C5841.2 C5866.2 C5867.2 C5878.2 C7001.2 C7002.2 C7003.2 C7010.2 C7011.2 C7103.2 C7104.2 C7105.2 C7106.2 C7117.2 C7118.2 C7119.1 C7120.1 C7126.2 C7150.2 C7312.2 C7313.2 C7316.2 C7317.2 C7318.2 C7321.2 C7322.2 C7323.2 C7324.2 C7330.2 C7331.2 C7341.2 C7342.2 C7350.2 C7351.2 C7352.2 C7353.2 C7354.2 C7355.2 C7356.2 C7357.2 C7358.1 C7359.1 C7364.2 C7377.2 C7385.2 C7388.2 C7389.2 C7390.2 C7391.2 C8001.2 C8002.2 C8003.2 C8004.2 C8005.2 C8101.2 C8102.2 C8105.2 C8106.2 C8107.2 C8108.2 C8109.2 C8110.2 C8111.2 C8112.2 C8113.2 C8114.2 C8115.2 C8116.2 C8201.2 C8202.2 C8203.2 C8204.2 C8205.2 C8206.2 C8207.2 C8208.2 C8209.2 C8210.2 C8211.2 C8212.2 C8213.2 C8214.2 C8215.2 C8216.2 C8217.2 C8218.2 C8219.1 C8220.2 C8221.2 C8222.2 C8223.2 C8224.2 C8225.2 C8226.2 C8227.2 C8228.1 C8229.2 C8230.2 C8231.2 C8232.2 C8233.2 C8235.2 C8237.2 C8239.2 C8241.2 C8242.2 C8244.2 C8245.2 C8246.2 C8248.2 C8249.2 C8250.2 C8251.2 C8253.2 C8254.2 C8255.2 C8256.2 C8257.2 C8258.2 C8260.2 C8261.2 C8262.2 C8263.2 C8264.2 C8265.2 C8266.2 C8267.2 C8268.2 C8269.2 C8270.2 C8271.2 C8273.2 C8274.2 C8275.2 C8276.2 C8277.2 C8278.2 C8279.2 C8280.2 C8281.2 C8282.2 C8283.2 C8284.2 C8285.2 C8286.2 C8287.2 C8288.2 C8289.2 C8290.2 C8291.2 C8299.2 C8301.2 C8302.2 C8303.2 C8304.2 C8305.2 C8306.2 C8307.2 C8308.2 C8309.2 C8310.2 C8311.2 C8312.2 C8313.2 C8314.2 C8315.2 C8316.2 C8317.2 C8318.2 C8319.2 C8320.2 C8321.2 C8322.2 C8323.2 C8324.2 C8325.2 C8326.2 C8327.2 C8329.2 C8330.2 C8331.2 C8332.2 C8333.2 C8334.2 C8335.2 C8336.2 C8341.1 C8342.2 C8343.1 C8344.1 C8345.1 C8346.1 C8348.2 C8349.2 C8367.2 C8401.2 C8402.2 C8405.2 C8406.2 C8407.2 C8408.2 C8409.2 C8410.2 C8411.2 C8412.2 C8800.1 C8801.1 C8803.2 C8804.2 C8805.2 C8806.2 C8807.2 C8808.2 C8809.2 C8810.2 C8811.2 C8812.2 C8814.2 C8816.2 C8817.2 C8818.2 C8905.2 C8906.2 C9000.2 C9001.2 C9002.2 C9004.2 C9005.2 C9006.2 C9007.2 C9008.2 C9009.2 C9010.2 CE5201.2 CE5202.2 CE8100.2 CE8101.2 CE8102.2 CON0700.6 CON0700.9 CON0700.10 CON0700.11 CON0700.12 CON0700.13 CON0700.14 CON0700.15 CON0700.16 CON0700.17 CON0700.18 CON0901.4 CON0901.7 CON0901.10 CON0901.13 CON0901.16 CON0901.20 CON0901.21 CON0901.22 CON0901.23 CON1102.5 CON1102.6 CON2002.8 CON2002.9 CON2002.18 CON2002.19 CON2002.20 CON2003.3 CON2003.7 CON2003.8 CON2101.5 CON2101.7 CON2101.14 CON2101.17 CON2101.20 CON2101.22 CON2101.23 CON3301.9 CON3301.11 CON3301.13 CON3301.14 CON3800.17 CON3800.30 CON3800.44 CON3800.59 CON3800.60 CON3800.61 CON3800.62 CON3800.63 CON3800.64 CON5101.1 CON5101.9 CON5101.10 CON5101.11 CON5201.5 CON5201.6 CON5201.7 CON5201.8 CON5201.9 CON7305.10 CON7305.13 CON7305.16 CON7305.19 CON7305.22 CON7305.25 CON7305.40 CON7305.41 CON8001.3 CON8001.4 CON8001.5 CON8001.6 CON8902.7 CON8902.8 D0700.2 D0701.2 D0702.2 D0703.2 D0704.2 D0705.2 D0706.2 D1101.2 D1102.2 D1103.2 D1104.2 D2003.2 D5103.2 D8201.1 D9000.1 H7907.1 H7910.2 H7910.3 H7910.4 H7910.5 H7911.2 H7911.3 H7911.4 H7911.5 J3101.24 J3101.26 J3101.35 J3101.36 JP8207.2 JP8900.2 L3002.1 Q0704.1 Q0704.4 Q0901.1 Q0901.4 Q2001.1 Q2001.4 Q2644.1 Q3004.1 Q3004.4 Q3006.1 Q3006.4 Q3008.1 Q3008.4 Q3009.1 Q3009.4 Q3301.2 Q7003.1 Q7104.2 Q7142.4 Q7187.1 Q7187.4 Q8100.1 Q8100.4 Q8101.1 Q8101.4 Q8102.1 Q8203.1 Q8406.1 Q8805.1 R0501.2 R0502.2 R0503.2 R0504.2 R0505.2 R0506.2 R0507.2 R0911.2 R1006.1 R1007.1 R1008.1 R1602.2 R1603.2 R1604.2 R1605.2 R1611.1 R1613.2 R1702.2 R1704.1 R1709.2 R1710.2 R1711.2 R1712.2 R2104.1 R2130.2 R2131.2 R2301.2 R2401.1 R2402.2 R2403.2 R2404.2 R2405.1 R2406.1 R2407.2 R2408.2 R2506.2 R2507.2 R2509.2 R2510.1 R2511.1 R2516.2 R2517.2 R2518.2 R2540.2 R2550.2 R2601.1 R2603.2 R2604.2 R2608.2 R2612.2 R2613.2 R2614.2 R2615.2 R2617.1 R2622.2 R2623.2 R2629.2 R2631.1 R2632.2 R2634.1 R2638.2 R2641.2 R2642.2 R2658.1 R2690.2 R2703.2 R2714.2 R2716.2 R3056.1 R3350.2 R3351.2 R5847.2 R5848.1 R5870.2 R5899.1 R7006.2 R7102.1 R7108.1 R7109.1 R7119.1 R7139.1 R7142.2 R7144.1 R7145.1 R7154.2 R7184.2 R7195.2 R7199.2 R7357.2 R8100.2 R8111.2 R8112.2 R8118.2 R8123.2 R8125.1 R8133.2 R8314.2 R8315.2 R8323.1 R8324.1 R8327.1 R8368.2 R8369.2 R8373.1 R8406.2 R8417.2 R8449.2 R8458.2 R8508.2 R8509.2 R8517.1 R8804.2 R8805.2 R8806.2 R8809.2 R8810.2 R8812.2 R8813.2 R8908.2 R9000.2 R9002.2 R9003.2 SR8501.2 SR8900.2 SW2004.1 SW2004.3 SW2004.4 SW2004.5 T1611.1 T2006.1 T2009.1 T2010.1 T2013.1 T2302.1 T2707.1 T3008.1 T8004.1 T8005.1 T8006.1 T8106.1 T8107.1 T8207.1 T8315.1 T8316.1 T8317.1 T8319.1 T8418.1 T8420.1 T8802.1 T8905.1 U1001.49 U1001.50 U1001.51 U1001.52 U1001.53 U1001.54 U1001.55 U1001.56 U1001.57 U1001.58 U1001.59 U1101.1 U1101.3 U1601.A2 U1601.A3 U1601.A4 U1601.A5 U1601.A8 U1601.A12 U1601.A14 U1601.B1 U1601.B3 U1601.B4 U1601.C1 U1601.C2 U1601.C4 U1601.D1 U1601.D2 U1601.D3 U1601.D4 U1601.D12 U1601.D17 U1601.E5 U1601.E6 U1601.E7 U1601.E8 U1601.E9 U1601.E10 U1601.E11 U1601.E12 U1601.F1 U1601.F5 U1601.F12 U1601.F17 U1601.G1 U1601.G5 U1601.G15 U1601.G16 U1601.H5 U1601.H12 U1601.H15 U1601.J5 U1601.J17 U1601.K5 U1601.L5 U1601.L12 U1601.M1 U1601.M4 U1601.M5 U1601.M6 U1601.M8 U1601.M11 U1601.M17 U1601.N13 U1601.N17 U1601.P1 U1601.P14 U1601.R7 U1601.R8 U1601.R16 U1601.R17 U1601.T7 U1601.T15 U1601.T17 U1601.U4 U1601.U6 U1601.U9 U1601.U12 U1601.U13 U1601.U15 U1601.U16 U1701.A2 U1701.A3 U1701.A4 U1701.A5 U1701.A8 U1701.A12 U1701.A14 U1701.B1 U1701.B3 U1701.B4 U1701.C1 U1701.C2 U1701.C4 U1701.D1 U1701.D2 U1701.D3 U1701.D4 U1701.D12 U1701.D17 U1701.E5 U1701.E6 U1701.E7 U1701.E8 U1701.E9 U1701.E10 U1701.E11 U1701.E12 U1701.F1 U1701.F5 U1701.F12 U1701.F17 U1701.G1 U1701.G5 U1701.G15 U1701.G16 U1701.H5 U1701.H12 U1701.H15 U1701.J5 U1701.J17 U1701.K5 U1701.L5 U1701.L12 U1701.M1 U1701.M4 U1701.M5 U1701.M6 U1701.M8 U1701.M11 U1701.M17 U1701.N13 U1701.N17 U1701.P1 U1701.P14 U1701.R7 U1701.R8 U1701.R16 U1701.R17 U1701.T7 U1701.T15 U1701.T17 U1701.U4 U1701.U6 U1701.U9 U1701.U12 U1701.U13 U1701.U15 U1701.U16 U1915.A4 U1915.A6 U1915.A9 U1915.A11 U1915.AA4 U1915.AA6 U1915.AE1 U1915.AE14 U1915.AG2 U1915.AG13 U1915.AH4 U1915.AH6 U1915.AH9 U1915.AH11 U1915.B2 U1915.B13 U1915.D1 U1915.D14 U1915.K4 U1915.M7 U1915.P5 U1915.R10 U1915.U8 U1915.Y2 U1915.Y5 U2101.2 U2301.2 U2301.4 U2400.A3 U2400.A5 U2400.A7 U2400.A11 U2400.A15 U2400.A27 U2400.A37 U2400.A39 U2400.A45 U2400.A47 U2400.A49 U2400.A51 U2400.A53 U2400.A55 U2400.A57 U2400.AA7 U2400.AA11 U2400.AA15 U2400.AA23 U2400.AA27 U2400.AA29 U2400.AA38 U2400.AA40 U2400.AA42 U2400.AA46 U2400.AB2 U2400.AB6 U2400.AB12 U2400.AB52 U2400.AB58 U2400.AC1 U2400.AC7 U2400.AC14 U2400.AC18 U2400.AC24 U2400.AC28 U2400.AC31 U2400.AC39 U2400.AC41 U2400.AC49 U2400.AC53 U2400.AD2 U2400.AD6 U2400.AD8 U2400.AD17 U2400.AD23 U2400.AD38 U2400.AD40 U2400.AD42 U2400.AD44 U2400.AD46 U2400.AD52 U2400.AD54 U2400.AD56 U2400.AE7 U2400.AE11 U2400.AF6 U2400.AF12 U2400.AF16 U2400.AF18 U2400.AF24 U2400.AF28 U2400.AF31 U2400.AF37 U2400.AF41 U2400.AF43 U2400.AF45 U2400.AF54 U2400.AF58 U2400.AG7 U2400.AG49 U2400.AG51 U2400.AG53 U2400.AG59 U2400.AH2 U2400.AH6 U2400.AH8 U2400.AH15 U2400.AH17 U2400.AH23 U2400.AH29 U2400.AH40 U2400.AH42 U2400.AH46 U2400.AH52 U2400.AH54 U2400.AH56 U2400.AH58 U2400.AK1 U2400.AK5 U2400.AK11 U2400.AK16 U2400.AK18 U2400.AK24 U2400.AK28 U2400.AK33 U2400.AK41 U2400.AK43 U2400.AK53 U2400.AK59 U2400.AM6 U2400.AM12 U2400.AM17 U2400.AM23 U2400.AM27 U2400.AM34 U2400.AM38 U2400.AM40 U2400.AM42 U2400.AM44 U2400.AM46 U2400.AM52 U2400.AM54 U2400.AM56 U2400.AM58 U2400.AN49 U2400.AN51 U2400.AN53 U2400.AN59 U2400.AP6 U2400.AP8 U2400.AP14 U2400.AP24 U2400.AP28 U2400.AP37 U2400.AP39 U2400.AP41 U2400.AP54 U2400.AP58 U2400.AR1 U2400.AR5 U2400.AR9 U2400.AR11 U2400.AT6 U2400.AT10 U2400.AT12 U2400.AT15 U2400.AT25 U2400.AT29 U2400.AT40 U2400.AT42 U2400.AT52 U2400.AT54 U2400.AT56 U2400.AU1 U2400.AU7 U2400.AU9 U2400.AU16 U2400.AU18 U2400.AU24 U2400.AU31 U2400.AU33 U2400.AU35 U2400.AU37 U2400.AU39 U2400.AU41 U2400.AU43 U2400.AU45 U2400.AU49 U2400.AU53 U2400.AV8 U2400.AV12 U2400.AV52 U2400.AV58 U2400.AW5 U2400.AW7 U2400.AW9 U2400.AW11 U2400.AW17 U2400.AW23 U2400.AW42 U2400.AW46 U2400.AY6 U2400.AY8 U2400.AY12 U2400.AY56 U2400.B2 U2400.B4 U2400.B6 U2400.B20 U2400.B32 U2400.B44 U2400.B48 U2400.B52 U2400.B58 U2400.BA1 U2400.BA7 U2400.BA14 U2400.BA16 U2400.BA18 U2400.BA24 U2400.BA26 U2400.BA31 U2400.BA33 U2400.BA37 U2400.BA43 U2400.BA49 U2400.BA53 U2400.BB6 U2400.BB10 U2400.BB12 U2400.BB17 U2400.BB23 U2400.BB27 U2400.BB29 U2400.BB34 U2400.BB36 U2400.BB42 U2400.BB46 U2400.BB52 U2400.BB54 U2400.BB58 U2400.BC5 U2400.BC7 U2400.BC9 U2400.BC49 U2400.BC51 U2400.BC53 U2400.BC59 U2400.BD6 U2400.BD8 U2400.BD12 U2400.BD16 U2400.BD18 U2400.BD41 U2400.BD43 U2400.BD45 U2400.BD56 U2400.BE1 U2400.BE7 U2400.BE11 U2400.BE57 U2400.BE59 U2400.BF6 U2400.BF12 U2400.BF15 U2400.BF17 U2400.BF19 U2400.BF21 U2400.BF23 U2400.BF25 U2400.BF27 U2400.BF29 U2400.BF34 U2400.BF38 U2400.BF40 U2400.BF42 U2400.BF44 U2400.BF46 U2400.BF52 U2400.BF58 U2400.BG5 U2400.BG7 U2400.BG49 U2400.BG53 U2400.BH6 U2400.BH8 U2400.BH12 U2400.BH20 U2400.BH32 U2400.BH38 U2400.BH40 U2400.BH42 U2400.BH52 U2400.BH56 U2400.BH58 U2400.BJ1 U2400.BJ7 U2400.BJ11 U2400.BJ13 U2400.BJ15 U2400.BJ17 U2400.BJ23 U2400.BJ27 U2400.BJ35 U2400.BJ39 U2400.BJ41 U2400.BJ45 U2400.BK6 U2400.BK20 U2400.BK48 U2400.BK50 U2400.BK54 U2400.BK58 U2400.BL3 U2400.BL5 U2400.BL7 U2400.BL13 U2400.BL23 U2400.BL30 U2400.BL41 U2400.BM2 U2400.BM6 U2400.BM8 U2400.BM10 U2400.BM16 U2400.BM18 U2400.BM22 U2400.BM26 U2400.BM28 U2400.BM34 U2400.BM36 U2400.BM40 U2400.BM44 U2400.BM46 U2400.BM56 U2400.BN13 U2400.BN17 U2400.BN21 U2400.BN23 U2400.BN27 U2400.BN30 U2400.BN35 U2400.BN39 U2400.BN41 U2400.BN45 U2400.BN53 U2400.BP2 U2400.BP6 U2400.BP10 U2400.BP18 U2400.BP26 U2400.BP32 U2400.BP40 U2400.BP48 U2400.BP58 U2400.BR1 U2400.BR5 U2400.BR41 U2400.BR53 U2400.BR59 U2400.BT2 U2400.BT8 U2400.BT12 U2400.BT16 U2400.BT20 U2400.BT24 U2400.BT28 U2400.BT34 U2400.BT38 U2400.BT42 U2400.BT46 U2400.BT50 U2400.BT54 U2400.BT56 U2400.BU1 U2400.BU3 U2400.BU41 U2400.BU59 U2400.BV2 U2400.BV6 U2400.BV8 U2400.BV12 U2400.BV16 U2400.BV20 U2400.BV24 U2400.BV28 U2400.BV34 U2400.BV44 U2400.BV48 U2400.BV52 U2400.BV58 U2400.BW3 U2400.BW5 U2400.BW7 U2400.BW15 U2400.BW19 U2400.BW25 U2400.BW30 U2400.BW37 U2400.BW45 U2400.BW47 U2400.BW49 U2400.BW51 U2400.BW53 U2400.BW55 U2400.BW57 U2400.C1 U2400.C41 U2400.C59 U2400.D8 U2400.D12 U2400.D16 U2400.D20 U2400.D24 U2400.D28 U2400.D34 U2400.D38 U2400.D42 U2400.D46 U2400.D50 U2400.D54 U2400.D56 U2400.E1 U2400.E41 U2400.E53 U2400.E59 U2400.F2 U2400.F6 U2400.F8 U2400.F10 U2400.F18 U2400.F32 U2400.F40 U2400.F48 U2400.F58 U2400.G5 U2400.G13 U2400.G17 U2400.G21 U2400.G23 U2400.G27 U2400.G30 U2400.G35 U2400.G39 U2400.G41 U2400.G45 U2400.G53 U2400.H10 U2400.H16 U2400.H18 U2400.H22 U2400.H28 U2400.H34 U2400.H36 U2400.H40 U2400.H44 U2400.H46 U2400.H56 U2400.J13 U2400.J30 U2400.J41 U2400.K6 U2400.K10 U2400.K24 U2400.K48 U2400.K50 U2400.K54 U2400.K58 U2400.L1 U2400.L5 U2400.L7 U2400.L11 U2400.L13 U2400.L15 U2400.L17 U2400.L19 U2400.L21 U2400.L23 U2400.L33 U2400.L35 U2400.L37 U2400.L39 U2400.L41 U2400.L45 U2400.M6 U2400.M12 U2400.M16 U2400.M18 U2400.M24 U2400.M32 U2400.M38 U2400.M42 U2400.M52 U2400.M56 U2400.M58 U2400.N7 U2400.N49 U2400.N53 U2400.P6 U2400.P8 U2400.P12 U2400.P25 U2400.P34 U2400.P36 U2400.P38 U2400.P40 U2400.P46 U2400.P52 U2400.P58 U2400.R5 U2400.R7 U2400.R9 U2400.R11 U2400.R57 U2400.R59 U2400.T16 U2400.T20 U2400.T22 U2400.T24 U2400.T26 U2400.T28 U2400.T41 U2400.T43 U2400.T45 U2400.T56 U2400.U1 U2400.U7 U2400.U11 U2400.U49 U2400.U51 U2400.U53 U2400.U59 U2400.V2 U2400.V6 U2400.V15 U2400.V17 U2400.V19 U2400.V27 U2400.V34 U2400.V38 U2400.V42 U2400.V44 U2400.V46 U2400.V52 U2400.V54 U2400.V58 U2400.W14 U2400.W16 U2400.W18 U2400.W26 U2400.W28 U2400.W33 U2400.W41 U2400.W43 U2400.W45 U2400.W49 U2400.W53 U2400.Y2 U2400.Y6 U2400.Y8 U2400.Y10 U2400.Y12 U2400.Y56 U3001.8 U3001.29 U3001.64 U3301.C3 U3301.C4 U3302.4 U3302.9 U3304.6 U5101.5 U5203.1 U5401.6 U5401.17 U5401.20 U5401.23 U5401.26 U5401.32 U5401.35 U5401.38 U5401.41 U5401.62 U5401.68 U5401.71 U5401.74 U5401.75 U5401.76 U5401.77 U5401.78 U5401.79 U5401.80 U5401.81 U5401.82 U5401.83 U5401.84 U5401.85 U5401.86 U5401.87 U5401.88 U5401.89 U5401.90 U5401.91 U5401.92 U5401.93 U5401.94 U5401.95 U5401.96 U5401.G1 U5401.G2 U5401.G3 U5401.G4 U5401.G5 U5401.G6 U5401.G7 U5401.G8 U5401.G9 U5401.G10 U5401.G11 U5401.G12 U5801.18 U5803.1 U5804.B1 U5806.3 U7107.14 U7107.49 U7107.50 U7107.51 U7107.52 U7107.53 U7107.54 U7107.55 U7107.56 U7107.57 U7107.58 U7107.59 U7107.60 U7107.61 U7107.62 U7107.63 U7107.64 U7107.65 U7112.3 U7112.4 U7141.2 U7311.2 U7320.B1 U7320.B2 U7321.B1 U7322.B1 U7903.1 U7903.2 U7903.3 U7903.4 U7903.5 U7903.6 U7903.7 U7903.8 U7903.9 U7903.10 U7903.11 U7903.12 U7903.13 U7903.14 U7903.15 U7903.16 U7903.17 U7903.18 U7903.19 U7903.20 U7903.21 U7903.22 U7903.23 U7903.24 U7903.25 U7903.26 U7903.27 U7903.28 U7903.29 U7903.30 U7903.31 U7903.32 U7903.33 U7903.34 U7903.35 U7903.36 U7903.37 U7903.38 U7903.39 U7903.40 U7903.41 U7903.42 U7903.43 U7903.44 U7903.45 U7903.46 U7903.47 U7903.48 U7903.49 U7903.50 U7903.51 U7903.52 U7911.1 U7913.1 U7920.1 U7921.1 U7922.1 U7931.1 U7932.1 U7942.1 U7942.2 U7942.3 U7942.4 U7942.5 U7942.6 U7942.7 U7942.8 U7942.9 U7942.10 U7942.11 U7942.12 U7942.13 U7942.14 U7942.15 U7942.16 U7942.17 U7942.18 U7942.19 U7942.20 U7942.21 U7942.22 U7942.23 U7942.24 U7942.25 U7942.26 U7942.27 U7942.28 U7942.29 U7942.30 U7942.31 U7942.32 U7942.33 U7942.34 U7942.35 U7942.36 U7942.37 U7942.38 U7942.39 U7942.40 U7942.41 U7942.42 U7942.43 U7942.44 U7942.45 U7942.46 U7942.47 U7942.48 U7942.49 U7942.50 U7942.51 U7942.52 U7942.53 U7942.54 U7942.55 U7942.56 U7942.57 U7942.58 U8100.5 U8100.6 U8100.7 U8100.10 U8100.13 U8100.17 U8100.18 U8100.19 U8100.20 U8100.21 U8101.B1 U8101.C2 U8102.2 U8201.A6 U8201.A7 U8201.A13 U8201.A15 U8201.B2 U8201.B3 U8201.B13 U8201.B14 U8201.B15 U8201.C2 U8201.C3 U8201.C13 U8201.D15 U8201.E9 U8201.F1 U8201.G10 U8201.G11 U8201.G12 U8201.H15 U8201.J1 U8201.K1 U8201.N2 U8201.N3 U8201.N14 U8201.N15 U8201.P2 U8201.P3 U8201.P6 U8201.P7 U8201.P13 U8201.P15 U8201.R6 U8201.R9 U8201.R13 U8201.R14 U8201.R15 U8800.17 U8800.18 U8800.25 U8800.26 U8800.27 U8800.28 U8800.29 U9000.5 U9000.6 U9000.8 U9000.13 U9000.17 U9000.18 U9000.19 U9000.20 U9000.21 U9000.22 X2600.2 X2600.4
GND_SIGNAL: SR8501.1 U8201.C4 U8201.D13 U8201.F3 U8201.N8 U8201.N10 U8201.N12
V3.3_LVDS_AVDD: C7316.1 C7317.1 C7364.1 C7385.1 CON7305.2 CON7305.3 L7303.2
VBAT_SENSE_BUF: R8340.1 U8201.K9
VDD_3V3_EDID: C7377.1 CON7305.4 L7306.2 L7350.2
VDD_WL_PA: C5401.1 C5402.1 C5403.1 C5405.1 C5406.1 C5412.1 C5413.1 R5415.1 R5418.1 R5424.2 U5401.4 U5401.5 U5401.72 U5401.73
42_M0_CA0: R1624.1 U1601.B5 U1601.L2 U2400.M50
42_M0_CA1: R1623.1 U1601.C5 U1601.L3 U2400.N51
42_M0_CA2: R1622.1 U1601.D5 U1601.L4 U2400.L51
42_M0_CA3: R1621.1 U1601.B6 U1601.K2 U2400.L55
42_M0_CA4: R1620.1 U1601.C6 U1601.K3 U2400.R49
42_M0_CA5: R1619.1 U1601.C9 U1601.G3 U2400.R51
42_M0_CA6: R1618.1 U1601.D9 U1601.G4 U2400.P50
42_M0_CA7: R1617.1 U1601.B10 U1601.F2 U2400.L57
42_M0_CA8: R1616.1 U1601.C10 U1601.F3 U2400.P48
42_M0_CA9: R1615.1 U1601.D10 U1601.F4 U2400.T52
42_M0_CKE0: U1601.C7 U2400.H58
42_M0_CKE1: U1601.J3 U2400.C57
42_M0_CKE2: U1601.D7 U2400.K56
42_M0_CKE3: U1601.J4 U2400.D58
42_M0_CS0_N: U1601.D6 U1601.K4 U2400.J57
42_M0_CS2_N: U1601.B7 U1601.J2 U2400.B56
42_M0_DATA0: U1601.N4 U2400.H42
42_M0_DATA1: U1601.T5 U2400.M46
42_M0_DATA2: U1601.R5 U2400.J47
42_M0_DATA3: U1601.P5 U2400.L43
42_M0_DATA4: U1601.N5 U2400.K42
42_M0_DATA5: U1601.T6 U2400.K46
42_M0_DATA6: U1601.R6 U2400.J45
42_M0_DATA7: U1601.P6 U2400.G43
42_M0_DATA8: U1601.P2 U2400.B42
42_M0_DATA9: U1601.N3 U2400.C47
42_M0_DATA10: U1601.T2 U2400.C43
42_M0_DATA11: U1601.R3 U2400.B46
42_M0_DATA12: U1601.P3 U2400.F46
42_M0_DATA13: U1601.T3 U2400.F44
42_M0_DATA14: U1601.R2 U2400.E43
42_M0_DATA15: U1601.N2 U2400.F42
42_M0_DATA16: U1601.P13 U2400.E49
42_M0_DATA17: U1601.N12 U2400.E47
42_M0_DATA18: U1601.N11 U2400.D48
42_M0_DATA19: U1601.T14 U2400.C53
42_M0_DATA20: U1601.P12 U2400.C49
42_M0_DATA21: U1601.R14 U2400.F52
42_M0_DATA22: U1601.T13 U2400.F50
42_M0_DATA23: U1601.R13 U2400.D52
42_M0_DATA24: U1601.R11 U2400.H52
42_M0_DATA25: U1601.R9 U2400.H48
42_M0_DATA26: U1601.N10 U2400.G47
42_M0_DATA27: U1601.T11 U2400.L47
42_M0_DATA28: U1601.T10 U2400.J49
42_M0_DATA29: U1601.R10 U2400.K52
42_M0_DATA30: U1601.T9 U2400.G49
42_M0_DATA31: U1601.P10 U2400.J53
42_M0_DATA32: U1601.M13 U2400.T50
42_M0_DATA33: U1601.L13 U2400.T48
42_M0_DATA34: U1601.N16 U2400.AA49
42_M0_DATA35: U1601.M14 U2400.V50
42_M0_DATA36: U1601.N14 U2400.V48
42_M0_DATA37: U1601.N15 U2400.AA53
42_M0_DATA38: U1601.P15 U2400.AA51
42_M0_DATA39: U1601.P16 U2400.Y48
42_M0_DATA40: U1601.K15 U2400.U55
42_M0_DATA41: U1601.K16 U2400.U57
42_M0_DATA42: U1601.K13 U2400.R55
42_M0_DATA43: U1601.K14 U2400.T54
42_M0_DATA44: U1601.J15 U2400.Y58
42_M0_DATA45: U1601.J16 U2400.AA55
42_M0_DATA46: U1601.L16 U2400.Y54
42_M0_DATA47: U1601.L15 U2400.T58
42_M0_DATA48: U1601.C13 U2400.AB54
42_M0_DATA49: U1601.C15 U2400.AC57
42_M0_DATA50: U1601.B16 U2400.AG55
42_M0_DATA51: U1601.C14 U2400.AB56
42_M0_DATA52: U1601.C16 U2400.AC55
42_M0_DATA53: U1601.B13 U2400.AA57
42_M0_DATA54: U1601.B15 U2400.AG57
42_M0_DATA55: U1601.B14 U2400.AF56
42_M0_DATA56: U1601.F15 U2400.AF52
42_M0_DATA57: U1601.E13 U2400.AB48
42_M0_DATA58: U1601.F16 U2400.AE49
42_M0_DATA59: U1601.E15 U2400.AF50
42_M0_DATA60: U1601.E14 U2400.AC51
42_M0_DATA61: U1601.E16 U2400.AF48
42_M0_DATA62: U1601.F14 U2400.AD48
42_M0_DATA63: U1601.D13 U2400.AB50
42_M0_DM0: U1601.N6 U2400.M44
42_M0_DM1: U1601.P4 U2400.E45
42_M0_DM2: U1601.P11 U2400.E51
42_M0_DM3: U1601.P8 U2400.J51
42_M0_DM4: U1601.L14 U2400.Y52
42_M0_DM5: U1601.H14 U2400.W57
42_M0_DM6: U1601.D14 U2400.AE55
42_M0_DM7: U1601.F13 U2400.AE53
42_M0_ODT0: U1601.N8 U2400.B54
42_M0_ODT2: U1601.H13 U2400.C55
42_M1_CA0: R1722.1 U1701.B5 U1701.L2 U2400.BH50
42_M1_CA1: R1721.1 U1701.C5 U1701.L3 U2400.BG51
42_M1_CA2: R1720.1 U1701.D5 U1701.L4 U2400.BJ51
42_M1_CA3: R1719.1 U1701.B6 U1701.K2 U2400.BJ55
42_M1_CA4: R1718.1 U1701.C6 U1701.K3 U2400.BE49
42_M1_CA5: R1717.1 U1701.C9 U1701.G3 U2400.BE51
42_M1_CA6: R1716.1 U1701.D9 U1701.G4 U2400.BF50
42_M1_CA7: R1715.1 U1701.B10 U1701.F2 U2400.BJ57
42_M1_CA8: R1714.1 U1701.C10 U1701.F3 U2400.BF48
42_M1_CA9: R1713.1 U1701.D10 U1701.F4 U2400.BD52
42_M1_CKE0: U1701.J3 U2400.BM58
42_M1_CKE1: U1701.C7 U2400.BU57
42_M1_CKE2: U1701.J4 U2400.BK56
42_M1_CKE3: U1701.D7 U2400.BT58
42_M1_CS0_N: U1701.D6 U1701.K4 U2400.BL57
42_M1_CS2_N: U1701.B7 U1701.J2 U2400.BV56
42_M1_DATA0: U1701.L15 U2400.BU53
42_M1_DATA1: U1701.L16 U2400.BP50
42_M1_DATA2: U1701.K13 U2400.BT52
42_M1_DATA3: U1701.K14 U2400.BP52
42_M1_DATA4: U1701.K15 U2400.BR47
42_M1_DATA5: U1701.K16 U2400.BR49
42_M1_DATA6: U1701.J15 U2400.BT48
42_M1_DATA7: U1701.J16 U2400.BU49
42_M1_DATA8: U1701.B15 U2400.BV42
42_M1_DATA9: U1701.B13 U2400.BU47
42_M1_DATA10: U1701.C15 U2400.BU43
42_M1_DATA11: U1701.B14 U2400.BV46
42_M1_DATA12: U1701.C13 U2400.BP46
42_M1_DATA13: U1701.C16 U2400.BP44
42_M1_DATA14: U1701.B16 U2400.BR43
42_M1_DATA15: U1701.C14 U2400.BP42
42_M1_DATA16: U1701.E16 U2400.BK42
42_M1_DATA17: U1701.F15 U2400.BN43
42_M1_DATA18: U1701.F14 U2400.BL45
42_M1_DATA19: U1701.E13 U2400.BH46
42_M1_DATA20: U1701.D13 U2400.BL47
42_M1_DATA21: U1701.F16 U2400.BJ43
42_M1_DATA22: U1701.E15 U2400.BM42
42_M1_DATA23: U1701.E14 U2400.BK46
42_M1_DATA24: U1701.N16 U2400.BM52
42_M1_DATA25: U1701.M13 U2400.BM48
42_M1_DATA26: U1701.N14 U2400.BN47
42_M1_DATA27: U1701.P15 U2400.BJ47
42_M1_DATA28: U1701.M14 U2400.BL49
42_M1_DATA29: U1701.P16 U2400.BK52
42_M1_DATA30: U1701.L13 U2400.BN49
42_M1_DATA31: U1701.N15 U2400.BL53
42_M1_DATA32: U1701.R11 U2400.BD50
42_M1_DATA33: U1701.T11 U2400.BD48
42_M1_DATA34: U1701.R9 U2400.AW49
42_M1_DATA35: U1701.T9 U2400.BB50
42_M1_DATA36: U1701.T10 U2400.BB48
42_M1_DATA37: U1701.P10 U2400.AW53
42_M1_DATA38: U1701.N10 U2400.AW51
42_M1_DATA39: U1701.R10 U2400.AY48
42_M1_DATA40: U1701.T13 U2400.BC55
42_M1_DATA41: U1701.R13 U2400.BC57
42_M1_DATA42: U1701.P13 U2400.BE55
42_M1_DATA43: U1701.T14 U2400.BD54
42_M1_DATA44: U1701.N12 U2400.AY58
42_M1_DATA45: U1701.N11 U2400.AW55
42_M1_DATA46: U1701.P12 U2400.AY54
42_M1_DATA47: U1701.R14 U2400.BD58
42_M1_DATA48: U1701.R6 U2400.AV54
42_M1_DATA49: U1701.R5 U2400.AU57
42_M1_DATA50: U1701.N5 U2400.AN55
42_M1_DATA51: U1701.T6 U2400.AV56
42_M1_DATA52: U1701.T5 U2400.AU55
42_M1_DATA53: U1701.P6 U2400.AW57
42_M1_DATA54: U1701.N4 U2400.AN57
42_M1_DATA55: U1701.P5 U2400.AP56
42_M1_DATA56: U1701.T2 U2400.AP52
42_M1_DATA57: U1701.N3 U2400.AV48
42_M1_DATA58: U1701.T3 U2400.AR49
42_M1_DATA59: U1701.R2 U2400.AP50
42_M1_DATA60: U1701.P3 U2400.AU51
42_M1_DATA61: U1701.P2 U2400.AP48
42_M1_DATA62: U1701.R3 U2400.AT48
42_M1_DATA63: U1701.N2 U2400.AV50
42_M1_DM0: U1701.H14 U2400.BR51
42_M1_DM1: U1701.D14 U2400.BR45
42_M1_DM2: U1701.F13 U2400.BH44
42_M1_DM3: U1701.L14 U2400.BL51
42_M1_DM4: U1701.P8 U2400.AY52
42_M1_DM5: U1701.P11 U2400.BA57
42_M1_DM6: U1701.N6 U2400.AR55
42_M1_DM7: U1701.P4 U2400.AR53
42_M1_ODT0: U1701.H13 U2400.BV54
42_M1_ODT2: U1701.N8 U2400.BU55
76_DDR3_REF_DN: R2403.1 U2400.AM50
76_DDR3_REF_DP: R2402.1 U2400.AM48
76_M0_CLK0_DN: R1614.1 U1601.C8 U2400.N57
76_M0_CLK0_DP: R1614.2 U1601.B8 U2400.N55
76_M0_CLK2_DN: R1601.1 U1601.H2 U2400.P56
76_M0_CLK2_DP: R1601.2 U1601.H3 U2400.P54
76_M0_DQS0_DN: U1601.N7 U2400.K44
76_M0_DQS0_DP: U1601.P7 U2400.J43
76_M0_DQS1_DN: U1601.R4 U2400.C45
76_M0_DQS1_DP: U1601.T4 U2400.D44
76_M0_DQS2_DN: U1601.R12 U2400.C51
76_M0_DQS2_DP: U1601.T12 U2400.B50
76_M0_DQS3_DN: U1601.N9 U2400.G51
76_M0_DQS3_DP: U1601.P9 U2400.H50
76_M0_DQS4_DN: U1601.M15 U2400.Y50
76_M0_DQS4_DP: U1601.M16 U2400.W51
76_M0_DQS5_DN: U1601.J13 U2400.V56
76_M0_DQS5_DP: U1601.J14 U2400.W55
76_M0_DQS6_DN: U1601.D15 U2400.AE57
76_M0_DQS6_DP: U1601.D16 U2400.AD58
76_M0_DQS7_DN: U1601.G13 U2400.AD50
76_M0_DQS7_DP: U1601.G14 U2400.AE51
76_M1_CLK0_DN: R1725.1 U1701.H2 U2400.BG55
76_M1_CLK0_DP: R1725.2 U1701.H3 U2400.BG57
76_M1_CLK2_DN: R1724.1 U1701.C8 U2400.BF56
76_M1_CLK2_DP: R1724.2 U1701.B8 U2400.BF54
76_M1_DQS0_DN: U1701.J13 U2400.BU51
76_M1_DQS0_DP: U1701.J14 U2400.BV50
76_M1_DQS1_DN: U1701.D15 U2400.BU45
76_M1_DQS1_DP: U1701.D16 U2400.BT44
76_M1_DQS2_DN: U1701.G13 U2400.BK44
76_M1_DQS2_DP: U1701.G14 U2400.BL43
76_M1_DQS3_DN: U1701.M15 U2400.BN51
76_M1_DQS3_DP: U1701.M16 U2400.BM50
76_M1_DQS4_DN: U1701.N9 U2400.AY50
76_M1_DQS4_DP: U1701.P9 U2400.BA51
76_M1_DQS5_DN: U1701.R12 U2400.BB56
76_M1_DQS5_DP: U1701.T12 U2400.BA55
76_M1_DQS6_DN: U1701.N7 U2400.AR57
76_M1_DQS6_DP: U1701.P7 U2400.AT58
76_M1_DQS7_DN: U1701.R4 U2400.AR51
76_M1_DQS7_DP: U1701.T4 U2400.AT50
85_USB2_CPU_P1_DN_C: C5212.1 CON5201.2 L5201.4 RNX5227.2
85_USB2_CPU_P1_DP_C: C5211.1 CON5201.3 L5201.1 RNX5227.4
+AC_ADAPTER: C8003.1 C8803.1 C8804.1 C8805.1 C8806.1 L8001.2 R8367.1 R8370.1 R8801.2 T8801.1 U8800.1 U8800.24
+BATT_CN: C8905.1 C8906.1 C8907.1 C8911.1 CON8902.5 CON8902.6 JP8800.2 R8340.2 R8907.1 T8904.1 U8901.E1 U8901.E2
+DC_IN_12V: C8001.1 C8002.1 C8004.1 C8005.1 CON8001.1 CON8001.2 L8001.1 T8001.1 T8002.1
+DCVDD: C1023.2 C1024.1 U1001.42
+ENPVCC: C7117.1 C7118.1 C7119.2 L7303.1 R7141.2 U7141.1
+GPIO0VDD: C8410.1 R8448.2 U8201.J13
+HOME_POWER: CON2003.6 R2015.2 R2016.2 R2088.2 R2098.2
+LCD_VDD_R: R7141.1 U7141.4
+SW_OUT: L7111.1 U7107.13
+V_VCC: C2800.1 C2802.1 C2803.1 C2804.1 C2806.1 C2807.1 C8268.1 R8203.2 U2400.A17 U2400.A19 U2400.A21 U2400.A23 U2400.A25 U2400.AA32 U2400.AA34 U2400.AA36 U2400.AC33 U2400.AC35 U2400.AF33 U2400.AF35 U2400.AH32 U2400.AH34 U2400.AH36 U2400.AK31 U2400.AK35 U2400.AK37 U2400.AM29 U2400.AM32 U2400.AM36 U2400.AP31 U2400.AP33 U2400.AP35 U2400.AT32 U2400.AT34 U2400.B18 U2400.B22 U2400.B26 U2400.C25 U2400.D26 U2400.E25 U2400.F26 U2400.G25 U2400.H26 U2400.J25 U2400.K26 U2400.L25 U2400.L27 U2400.L30 U2400.M26 U2400.M28 U2400.P29 U2400.P32 U2400.T31 U2400.T33 U2400.T35 U2400.T37 U2400.V29 U2400.V32 U2400.V36 U2400.W31 U2400.W35 U2400.W37
+V_VCC_PMIC: C8211.1 C8212.1 C8213.1 C8214.1 C8215.1 C8216.1 C8217.1 C8218.1 C8266.1 C8267.1 C8274.1 C8275.1 C8276.1 C8277.1 C8278.1 C8279.1 C8280.1 C8281.1 L8201.1 L8202.1 L8203.1 L8204.1 L8205.1 R8203.1 R8211.2
+V_VCC_SENSE: R8211.1 U2400.AT38 U8201.J2
+V_VNN: C2808.1 C2809.1 C2810.1 C2811.1 C2814.1 C2815.1 C8271.1 R8205.2 U2400.AA19 U2400.AA21 U2400.AA25 U2400.AC20 U2400.AC22 U2400.AC26 U2400.AD19 U2400.AD21 U2400.AD25 U2400.AD27 U2400.AD29 U2400.AD32 U2400.AD34 U2400.AF20 U2400.AF22 U2400.AF26 U2400.AH19 U2400.AH21 U2400.AH25 U2400.AK20 U2400.AK22 U2400.AK26 U2400.AM19 U2400.AM21 U2400.AM25 U2400.AP20 U2400.AP22 U2400.AP26 U2400.AT23 U2400.AT27 U2400.AU20 U2400.AU22 U2400.AU26 U2400.AU28 U2400.AW19 U2400.AW21 U2400.AW25 U2400.AW27 U2400.AW29 U2400.AW32 U2400.AW34 U2400.AW36 U2400.AW38 U2400.AW40 U2400.BA20 U2400.BA28 U2400.BA35 U2400.BA39 U2400.BA41 U2400.BB19 U2400.BB21 U2400.BB25 U2400.BB32 U2400.BB38 U2400.BB40 U2400.BD20 U2400.BD22 U2400.BD24 U2400.BD26 U2400.BD28 U2400.BD31 U2400.BD33 U2400.BD35 U2400.BD37 U2400.BD39 U2400.BK2 U2400.BL1 U2400.BN1 U2400.BV10 U2400.BV14 U2400.BW9 U2400.BW11 U2400.BW13 U2400.V21 U2400.V23 U2400.V25 U2400.W20 U2400.W22 U2400.W24
+V_VNN_PMIC: C8220.1 C8221.1 C8222.1 C8223.1 C8224.1 C8225.1 C8226.1 C8227.1 C8269.1 C8270.1 C8282.1 C8283.1 C8284.1 C8285.1 C8286.1 C8287.1 C8288.1 C8289.1 L8206.1 L8207.1 L8208.1 L8209.1 L8210.1 R8205.1 R8210.1
+V_VNN_SENSE: R8210.2 U2400.BA22 U8201.F2
+V_VSS_SENSE: R8214.1 U2400.AT36 U8201.G4
+VHDMI: F0921.1 R8365.1 T8313.1
+VHDMI_OUT: C0901.1 CON0901.19 D0905.3 F0921.2
+VHDMI_VIN: C8307.1 C8308.1 R8302.2 U8201.L13
+VHOST_EN: T8426.1 U8201.H11
+VNN_COMP: C8228.2 U8201.D3
+VNN_LX0: L8207.2 U8201.H1
+VNN_LX1: L8206.2 U8201.E1
+VNN_LX2: L8208.2 U8201.C1
+VNN_LX3: L8209.2 U8201.A3
+VNN_LX4: L8210.2 U8201.A5
+VREF25: C8342.1 C8409.1 U8201.D9 U8201.J3 U8201.N6 U8201.N9 U8201.N13
+VREF_DQ0: R1630.2 R8375.2
+VREF_DQ0_DDR: C1616.1 C1617.1 R1612.2 R1613.1 R1630.1 U1601.H17 U1601.U8
+VREF_DQ1: R1730.2 R8376.2
+VREF_DQ1_DDR: C1703.1 C1704.1 R1701.2 R1702.1 R1730.1 U1701.H17 U1701.U8
+VREFB: C8343.2 R8330.2 U8201.M8
+VREFCA_0: C1614.1 C1615.1 R1610.1 R1611.2 U1601.A10 U1601.J1
+VREFCA_1: C1701.1 C1702.1 R1703.1 R1704.2 U1701.A10 U1701.J1
+VREFDQ_0_PMIC: C8312.1 R8375.1 T8322.1 U8201.B6
+VREFDQ_1_PMIC: C8311.1 R8376.1 T8323.1 U8201.C6
+VREFT: C8341.2 R8325.2 R8326.2 R8328.2 R8329.2 R8372.2 U8201.N7
+VRTC: C2701.1 D2701.3 R2626.1 R2627.1 R2701.2 U2400.M22
+VSDIO: C2762.1 R0724.1 R8366.1 T8311.1 U2400.BW23
+VSPI: C3311.1 C3316.1 C3317.2 CON3301.1 CON3301.3 R3338.1 R3339.1 R3340.1 R3342.1 R3344.2 R3348.2 U3301.C2 U3302.8
+VSPI_PROG: C3319.1 CON3800.43 U3304.4
+VSPI_R: R3348.1 U3304.5 U3304.8
+VSYS: C8201.1 C8202.1 C8203.1 C8204.1 C8205.1 C8206.1 C8207.1 C8208.1 C8209.1 C8210.1 C8229.1 C8235.1 C8239.1 C8246.1 C8251.1 C8258.1 C8299.1 C8327.1 C8807.1 C8808.1 C8809.1 C8810.1 C8816.1 C9000.1 C9001.1 C9003.1 JP8101.1 L8216.2 L8801.2 Q8804.4 Q8804.8 Q9000.2 R2021.1 R8116.1 R8117.1 R8129.1 R8130.1 R8132.2 R8320.1 R8450.1 R8457.1 R8507.1 R8510.1 R8511.1 R8803.1 R8820.1 R8825.2 R8834.1 R9004.1 R9005.1 T8201.1 T8318.1 U8201.A4 U8201.A9 U8201.A11 U8201.B5 U8201.B11 U8201.D1 U8201.E2 U8201.E15 U8201.H2 U8201.K14 U8201.K15 U8201.L2 U8201.M1 U8201.P5 U8201.P11 U8201.R4 U8201.R8 U8201.R10 U8201.R11 U8800.15 U8800.16
+VSYS_DOCKING: C8817.1 CON5101.3 CON5101.7 D5103.1 Q8804.1 Q8804.2 Q8804.5 Q8804.6 Q8804.7
+VSYS_S: C8330.1 U8201.J12
+VSYS_SX_EN#: T8320.1 U8201.E12
+VSYS_U_EN#: T8321.1 U8201.F10
+VUSBPHY_PMIC: C8329.1 R8312.1 U8201.H13
A_BAT_THERM: R8804.1 R8807.1 R8822.2 U8800.11
A_BPTHERM_R: Q8900.3 R8807.2 U3001.39
A_BT_PCM_CLK: R5412.2 U5401.61
A_BT_PCM_SYNC: R5413.2 U5401.58
A_CLK_32K_OUT_WIFI: C5411.1 R5422.2 U5401.27
A_I2S_1_CLK: R5412.1 U2400.BT26
A_I2S_1_FS: R5413.1 U2400.BK28
A_LCD_BKLT_EN_PWM: C7150.1 Q7187.6 R7154.1 R7178.2 R7189.2 U9000.1
A_LCD_BKLT_PWM_EDP: R7153.1 U7107.29
A_PLT_CLK3_I2SMCLK: R1010.2 U2400.BT6
A_PROG_SPI_CLK: CON3800.39 U3301.E2
A_RTC_XTAL_IN: R2633.2 SP2601.2 U2400.B8
A_RTC_XTAL_OUT: C2606.1 R2633.1 U2400.C7 X2601.2
A_SDIO2_CLK: R5401.1 U2400.BU23
A_SDIO2_CMD: R5402.1 R5429.2 U2400.BR23
A_SDIO2_DATA_0: R5403.1 R5430.2 U2400.BT22
A_SDIO2_DATA_1: R5404.1 R5431.2 U2400.BM24
A_SDIO2_DATA_2: R5405.1 R5432.2 U2400.BP22
A_SDIO2_DATA_3: R5406.1 R5433.2 U2400.BK24
A_SOC_SPI_CLK: R3341.1 U2400.F28 U3301.B3
A_SOC_XTAL_IN: R2600.1 SP2602.2 U2400.AR7
A_SOC_XTAL_OUT: C2601.1 R2600.2 U2400.AT8 X2600.3
A_SPI_CLK: CON3301.7 R3341.2 U3301.A1 U3302.6
A_SUS_CLK_GPS: T2618.1 U2400.J15
A_SUS_CLK_WLAN: R5422.1 U2400.F14
A_SVID_ALERT#: R2687.2 R8502.1 R8505.2
A_SVID_CLK: R8501.2 R8504.1 U2400.C30
A_SVID_DATA: R2678.2 R8503.1 R8506.2
A_WIFI_SD_CLK: C5404.1 R5401.2 U5401.52
A_WIFI_SD_CMD: R5402.2 U5401.51
A_WIFI_SD_D0: R5403.2 U5401.50
A_WIFI_SD_D1: R5404.2 U5401.49
A_WIFI_SD_D2: R5405.2 U5401.48
A_WIFI_SD_D3: R5406.2 U5401.47
AC_PRESENT_EC: R8379.1 U3001.24
AC_PRESENT_SOC: R8377.1 T2670.1 U2400.F20
ADCDAT2: C1062.1 R1050.1 U1001.34
AU_COMBO_MIC: C1105.2 CON2002.13 R1116.1 T2011.1
AU_HP_JD#: CON2002.12 R1101.1 R1119.2 R1126.1 T1101.1
AU_HP_L: CON2002.10 T2007.1 U1001.28
AU_HP_R: CON2002.11 T2008.1 U1001.26
BAT_ID: CON8902.4 R8910.2 R8974.2
BATID: R8330.1 R8910.1 U8201.M7
BATID_EC: R3070.1 R8974.1 U3001.42
BATT_NTC: CON8902.3 R8903.2 R8904.1
BCLK2: C1060.1 R1052.1 U1001.36
BKLT_EN_PWM_R: Q7142.2 R7153.2 R7156.2 R7171.2 R7178.1
BKLT_PWM_PMIC: R7171.1 U8201.F6
BOARD_ID_0: R0501.1 R0508.2 U8201.J9
BOARD_ID_1: R0502.1 R0509.2 U8201.J10
BOARD_ID_2: R0510.2 R8417.1 U8201.J11
BOARD_ID_3: R0503.1 R0511.2 U8201.F8
BOARD_ID_4: R0504.1 R0512.2 U8201.G8
BOARD_ID_5: R0505.1 R0513.2 U8201.E11
BPTHERM_0: R8329.1 R8373.2 U8201.M9
BPTHERM_1: R8372.1 U8201.L9
BRTC_EXTPAD: C2604.1 C2612.1 U2400.E9
BT_DEV_EN: Q2644.3 R2683.1 R5420.1 T5404.1
BT_DEV_EN_D: Q2644.4 U2400.BM14
BT_DEV_WAKE: Q2655.3 R2690.1 R5417.1 T5403.1
BT_DEV_WAKE_1: R5417.2 U5401.24
BT_DEV_WAKE_R: Q2655.2 U2400.BL15
BT_HOST_WAKE#: Q2644.6 R2604.1 R2659.1 U2400.J23
BT_HOST_WAKE_1: Q2644.2 R5416.1 T5402.1
BT_HOST_WAKE_2: R5415.2 R5416.2 U5401.53
C0_VDDI: C1909.1 U1915.K2
CAM_2M_PD: CON2101.11 R2179.1 U2400.G37
CAM_2M_RESET#: R2103.1 U2400.K38
CAM_2M_RESET#_R: C2101.1 CON2101.8 R2102.2 R2103.2
CAM_ON_SOC: T2542.1 U2400.E39
CAP_WAKE: CON2003.2 U2400.BR13
CE#: R8808.2 R8809.1 R8835.2 U8800.9
CHG#_3V3: CON7305.28 SP7306.2
CHG_CE#: R2637.2 R8808.1 U3001.21
CHG_INT#: R3015.1 R8456.2 R8825.1 R8826.1 R8833.1 U3001.22
CHG_SCL: R8875.2 R8878.2 U8800.5
CHG_SDA: R8874.2 R8876.2 U8800.6
CLK_DEBUG: J3101.23 SP2603.1
CODEC_RESET#: R1014.1 R8449.1 U8201.L10
COMPASS_RSTN#: R5824.2 U2400.H38 U5804.C2
CORE_PWROK: CON3800.51 T2625.1 U2400.G9 U3001.47 U8201.K4
CPS_I2C_SCL: R5818.2 R5820.2 U5804.B3
CPS_I2C_SDA: R5819.2 R5821.2 U5804.C3
CPU_VREF: C2401.1 R2400.1 R2401.2 U2400.AK57
CPVEE: C1006.1 U1001.27
CPVPP: C1005.1 U1001.24
DACDAT2: R1051.1 U1001.33
DBG_RESETBTN#: CON3800.48 U2400.BN7
DDI0_DDC_SCL: Q0902.2 R0909.2 U2400.D32
DDI0_DDC_SDA: Q0903.2 R0912.2 U2400.H32
DDI0_HPD#: Q0901.6 R0908.2 U2400.K32
DDI0_RCOMP_DN: R2410.1 U2400.BB8
DDI0_RCOMP_DP: R2410.2 U2400.BA9
DDI0_TX0_DN: C0903.1 U2400.BE9
DDI0_TX0_DN_R: C0903.2 L0900.4 RN0900.3
DDI0_TX0_DP: C0902.1 U2400.BF8
DDI0_TX0_DP_R: C0902.2 L0900.1 RN0900.1
DDI0_TX1_DN: C0905.1 U2400.BD4
DDI0_TX1_DN_R: C0905.2 L0901.4 RN0901.3
DDI0_TX1_DP: C0904.1 U2400.BE3
DDI0_TX1_DP_R: C0904.2 L0901.1 RN0901.1
DDI0_TX2_DN: C0907.1 U2400.BE5
DDI0_TX2_DN_R: C0907.2 L0902.4 RN0902.3
DDI0_TX2_DP: C0906.1 U2400.BF4
DDI0_TX2_DP_R: C0906.2 L0902.1 RN0902.1
DDI0_TX3_DN: C0909.1 U2400.BB4
DDI0_TX3_DN_R: C0909.2 L0903.4 RN0903.3
DDI0_TX3_DP: C0908.1 U2400.BA5
DDI0_TX3_DP_R: C0908.2 L0903.1 RN0903.1
DDI1_AUX_DN: C7147.2 U2400.AY10
DDI1_AUX_DN_R: C7147.1 R7143.2 R7199.1 U7107.1
DDI1_AUX_DP: C7148.2 U2400.BA11
DDI1_AUX_DP_R: C7148.1 R7142.1 R7194.2 U7107.2
DDI1_BKLT_EN: R2517.1 R7177.1 U2400.K36
DDI1_BKLTCTL: R2518.1 R7156.1 U2400.J35 U7107.37
DDI1_DDC_SCL: R2522.2 U2400.C35
DDI1_DDC_SDA: R2521.2 U2400.F36
DDI1_HPD: Q7104.1 R7195.1 U7107.9
DDI1_HPD_N: Q7104.3 R2515.2 R7166.2 U2400.E35
DDI1_TX0_DN: C7146.2 U2400.AU3
DDI1_TX0_DN_R: C7146.1 U7107.5
DDI1_TX0_DP: C7149.2 U2400.AT4
DDI1_TX0_DP_R: C7149.1 U7107.4
DDI1_VDDEN: R2516.1 R7138.1 R7190.1 U2400.K34
DDR3L_PWROK: R2408.1 U2400.AK49 U8201.K3
DDR3L_VCCA_PWROK: R2407.1 U2400.AK55 U8201.J5
DEBUG_I2C_CLK: R8529.2 T8502.1 U8201.R1
DEBUG_I2C_DATA: R8528.2 T8501.1 U8201.P1
DEBUG_SVID_ALERT_B: R8530.2 T8503.1 U8201.A2
DEBUG_SVID_CLK: R8526.2 T8505.1 U8201.A1
DEBUG_SVID_DATA: R8527.2 T8504.1 U8201.B1
DET1#: C5103.1 CON5101.2 D5102.1 D5104.1 Q2660.6 R5107.1
DET1#_SOC: Q2660.1 R2650.1 U2400.BM12
DET2#: C5102.1 CON5101.8 D5102.2 Q2660.3 R5106.1 U5101.9
DET2#_SOC: Q2660.4 R2651.1 U2400.BK14
DMIC1_DAT: U1001.5 U1101.5
DMIC1_SCL: U1001.41 U1101.4
DOCK_PWR_EN: Q8805.2 U2400.K40
DOCKIING_DET#: D5102.3 R5105.1 U5101.6
DRAM_RCOMP_0: R2406.2 U2400.AH50
DRAM_RCOMP_1: R2405.2 U2400.AK51
DRAM_RCOMP_2: R2404.1 U2400.AH48
EC_A_GND: C3002.2 C3003.2 L3002.2 R3056.2 U3001.46
EC_CH_GA_SCL: R3036.1 R8875.1 R8973.1 U3001.52
EC_CH_GA_SDA: R3037.1 R8876.1 R8971.1 U3001.53
EC_PWRBTN_R: Q3006.5 R3062.1 U3001.10
EC_VIBRATOR_PWM: R7007.2 U3001.9
EDP_CSCL: Q7199.6 R7113.2 U7107.21 U7112.6
EDP_CSDA: Q7199.3 R7114.2 U7107.20 U7112.5
EDP_GPIO: U7107.17 U7112.7
EDP_I2C_CFG: R7106.1 R7108.2 U7107.10
EDP_LVDS_0+_R: CON7305.9 LX7324.3 RN7309.4
EDP_LVDS_0-_R: CON7305.8 LX7324.2 RN7309.2
EDP_LVDS_1+_R: CON7305.12 LX7326.2 RN7337.2
EDP_LVDS_1-_R: CON7305.11 LX7326.3 RN7337.4
EDP_LVDS_2+_R: CON7305.15 LX7327.3 RN7338.4
EDP_LVDS_2-_R: CON7305.14 LX7327.2 RN7338.2
EDP_LVDS_3+_R: CON7305.21 LX7328.2 RN7340.2
EDP_LVDS_3-_R: CON7305.20 LX7328.3 RN7340.4
EDP_LVDS_C+_R: C7341.1 CON7305.18 LX7325.2 RN7341.2
EDP_LVDS_C-_R: C7342.1 CON7305.17 LX7325.3 RN7341.4
EDP_PD#: Q7198.4 R7127.2 U2400.BP12
EDP_PD#_N: C7105.1 Q7198.3 R7129.1 U7107.8
EDP_RLV_CFG: R7109.2 R7110.2 U7107.18
EDP_RLV_SSC: R7107.2 R7119.2 U7107.19
EDP_RST#: R7136.1 U2400.F38
EDP_RST#_N: C7104.1 Q7198.6 U7107.7
EDP_RST#_R: Q7198.1 R7135.2 R7136.2
EMMC_CLK: R1908.1 U2400.BP20
EMMC_CLK_R: C1911.1 R1908.2 U1915.W6
EMMC_CMD: T1903.1 U1915.W5 U2400.BU21
EMMC_DATA_0: T1901.1 U1915.H3 U2400.BJ21
EMMC_DATA_1: U1915.H4 U2400.BM20
EMMC_DATA_2: U1915.H5 U2400.BR21
EMMC_DATA_3: U1915.J2 U2400.BR19
EMMC_DATA_4: U1915.J3 U2400.BK22
EMMC_DATA_5: U1915.J4 U2400.BU19
EMMC_DATA_6: U1915.J5 U2400.BJ19
EMMC_DATA_7: U1915.J6 U2400.BL21
EMMC_RCOMP: R2507.1 U2400.BH24
EMMC_RESET: T1902.1 U1915.U5 U2400.BH22
GA_SCL_R: R8972.2 R8973.2 T8907.1 U8901.A3
GA_SDA_R: R8923.2 R8971.2 T8906.1 U8901.B3
GASG_BAT_GD#: Q8900.1 U8901.B2
GASG_BAT_LOW: Q2650.3 Q3007.3 T8903.1 U8901.C3
GASG_BAT_LOW_EC: Q3007.2 R3077.1 U3001.4
GASG_GND_SIGNAL: C8907.2 C8911.2 C8912.2 C8913.2 C8916.2 C8918.2 C8919.1 Q8900.2 SR8900.1 U8901.C1 U8901.C2
GASG_SOC_INT: R3066.1 T8902.1 U3001.3 U8901.A2
GASG_SRN: C8917.2 C8919.2 R8906.1 U8901.B1
GASG_SRP: C8917.1 C8918.1 R8905.1 U8901.A1
GPI_HOMESCREEN#: R2017.1 U2400.BL11
GPIO_RCOMP18: R2614.1 U2400.E13
GPIO_SOC_V1P0SX_S: T2623.1 U2400.BN15
GYRO_IRQ: R5849.2 U2400.D14
GYRO_IRQ_R: R5849.1 U5801.12
GYRO_REGOUT: C5811.1 U5801.10
HDA_RCOMP: R2506.1 U2400.BH28
HDMI_CLK_DN_CON: CON0901.14 L0903.3 R0900.1 RN0903.4
HDMI_CLK_DP_CON: CON0901.12 L0903.2 R0901.1 RN0903.2
HDMI_DATA0_DN_CON: CON0901.11 L0902.3 R0902.1 RN0902.4
HDMI_DATA0_DP_CON: CON0901.9 L0902.2 R0903.1 RN0902.2
HDMI_DATA1_DN_CON: CON0901.8 L0901.3 R0904.1 RN0901.4
HDMI_DATA1_DP_CON: CON0901.6 L0901.2 R0905.1 RN0901.2
HDMI_DATA2_DN_CON: CON0901.5 L0900.3 R0906.1 RN0900.4
HDMI_DATA2_DP_CON: CON0901.3 L0900.2 R0907.1 RN0900.2
HDMI_DDC_SCL_CONN: C0952.1 CON0901.17 Q0902.3 R0910.2
HDMI_DDC_SDA_CONN: C0951.1 CON0901.18 Q0903.3 R0913.2
HDMI_HPD_CONN: CON0901.1 R0914.2
HOME_BUTTON#_CON: C2036.1 Q2025.2 R2017.2 R2040.2 R2064.1 R2096.2
HOME_BUTTON_CON: CON2003.1 Q2025.3 R2018.2 R2064.2 R2088.1 R2097.2
HOME_BUTTON_CON_R: Q2001.5 R2097.1
HOME_KEY#_3V3: R2018.1 U8201.E7
HOME_KEY#_EC: Q2001.6 R2099.1 U3001.26
HOMEKEY_VIB_INT#: R2040.1 U2400.BT10
I2C_0_SCL: R3078.1 R8878.1 R8972.1 T3005.1 U2400.BK32 U3001.27
I2C_0_SDA: R3079.1 R8874.1 R8923.1 T3006.1 U2400.BJ30 U3001.28
I2C_1_SCL: CON3800.24 R1027.1 U1001.38 U2400.BL33
I2C_1_SDA: CON3800.22 R1026.1 U1001.39 U2400.BR30
I2C_2_SCL: CON2003.4 Q7199.1 U2400.BJ33
I2C_2_SDA: CON2003.5 Q7199.4 U2400.BM32
I2C_3_SCL: R2137.1 U2400.BH34
I2C_3_SDA: R2138.1 U2400.BN33
I2C_4_SCL: C5867.1 R5820.1 R5867.1 U2400.BU33 U5801.23 U5803.5
I2C_4_SDA: C5866.1 R5821.1 R5866.1 U2400.BU30 U5801.24 U5803.2
I2C_5_SCL: SP7302.2 U2400.BP34
I2C_5_SDA: SP7304.1 U2400.BT32
I2C_CAM2_SCL: CON2101.10 R2137.2
I2C_CAM2_SDA: CON2101.9 R2138.2
I2C_NFC_SCL: CON3800.56 U2400.BR39
I2C_NFC_SDA: CON3800.58 U2400.BK40
I2C_PMIC_SCL: R2668.1 U2400.BK34 U8201.M5
I2C_PMIC_SDA: R2667.1 U2400.BR33 U8201.M6
I2C_VIO: R8531.2 U8201.M4
I2CM_SZ_A1: R8511.2 U8201.P9
I2S_0_CLK: R1020.2 U2400.BR27
I2S_0_FS: R1036.2 U2400.BP28
I2S_0_FS_R: C1047.1 R1036.1 U1001.29
I2S_0_RXD: R1034.2 U2400.BL27
I2S_0_RXD_R: C1044.1 R1034.1 U1001.32
I2S_0_TXD: R1035.2 U2400.BU27
I2S_0_TXD_R: C1045.1 C1063.1 R1035.1 U1001.31
I2S_2_CLK: R1052.2 U2400.BL37
I2S_2_FS: R1053.2 U2400.BT36
I2S_2_RXD: R1050.2 U2400.BP36
I2S_2_TXD: R1051.2 R2550.1 U2400.BK36
I2S_IRQ: R2658.2 U1001.40 U2400.D18
ICLK_ICOMP: R2631.2 U2400.AK14
ICLK_RCOMP: R2632.1 U2400.AH12
ICLK_USB_TERMN: R2613.1 U2400.G7
ICLK_USB_TERMP: R2612.1 U2400.H6
ILIM: R8810.1 U8800.10
IME_SCL: R5818.1 U5801.7
IME_SDA: R5819.1 U5801.21
IN2N: R1118.2 U1001.8
IN2P: C1105.1 U1001.7
INT_EC#: R2688.2 R2691.1 U3001.41
INT_EC#_SOC: R2691.2 U2400.C17
JACK_DET#: R1125.1 U2400.H14
KBC_EN: CON5101.5 D5104.3 Q5401.6 R5110.1
KBC_EN_SOC: Q5401.1 U2400.J39
KSI0: J3101.9 U3001.36
KSI1: J3101.10 U3001.37
KSI2: J3101.11 U3001.49
KSI3: J3101.12 U3001.50
KSI4: J3101.13 U3001.59
KSI5: J3101.14 U3001.60
KSI6: T3002.1 U3001.61
KSI7: T3003.1 U3001.62
KSO0: J3101.1 U3001.18
KSO1: J3101.2 U3001.19
KSO2: J3101.3 U3001.20
KSO3: J3101.4 U3001.58
KSO4: J3101.5 U3001.1
KSO5: J3101.6 U3001.2
KSO6: J3101.7 U3001.11
KSO7: J3101.8 U3001.12
KSO9: J3101.15 U3001.14
LCD_DDC_SCL: C7323.1 CON7305.6 R7115.2 U7107.25
LCD_DDC_SDA: C7324.1 CON7305.7 R7116.2 U7107.26
LCD_ENBLT: R7152.2 U7107.28
LCD_ENPVCC: R7137.1 U7107.30
LCDVDD_EN_R: R7137.2 R7138.2 R7139.2 R7147.2 U7141.3
LDO1_EN: C1020.2 R1014.2 R1015.2 R1045.2 U1001.44
LDO_FB: R2129.2 R2130.1 U2101.4
LED_AN: C7312.1 CON7305.37 CON7305.38 CON7305.39 JP9000.2
LED_CH1: CON7305.35 SR9001.2
LED_CH2: CON7305.34 SR9000.2
LED_CH3: CON7305.33 SR9002.2
LED_CH4: CON7305.32 SR9003.2
LID_SW#: D5104.2 Q2650.6 R5833.2
LID_SW_SOC#: Q2650.1 R2677.1 U2400.K14
LIGHT_SENSOR_INT#: R2649.2 U2400.E19 U5803.3
LPC_AD0: J3101.33 U2400.BK18
LPC_AD1: J3101.31 U2400.BL19
LPC_AD2: J3101.29 U2400.BR15
LPC_AD3: J3101.27 U2400.BP16
LPC_CLKRUN#: T2646.1 U2400.BU17
LPC_FRAME#: J3101.25 U2400.BT18
LPC_RCOMP: R2623.1 U2400.BH18
LPC_SERIRQ: Q3101.1 R3101.1 U2400.BR11
LPC_SERIRQ_R: J3101.28 Q3101.6
LRCK2: C1061.1 R1053.1 U1001.35
LVDS_A_GND: C7108.2 C7109.1 C7110.2 C7111.2 C7112.2 C7166.2 C7187.2 R7102.2 R7104.2 R7105.2 R7144.2 R7145.2 U7107.3 U7107.24
M0_A_ZQ0: R1603.1 U1601.B11
M0_A_ZQ1: R1602.1 U1601.C11
M0_B_ZQ0: R1605.1 U1601.E2
M0_B_ZQ1: R1604.1 U1601.E3
M1_A_ZQ0: R1710.1 U1701.B11
M1_A_ZQ1: R1709.1 U1701.C11
M1_B_ZQ0: R1712.1 U1701.E2
M1_B_ZQ1: R1711.1 U1701.E3
MCLK: C1010.1 R1010.1 U1001.37
MCSI_2_CLK_DN: L2104.1 RN2104.1 U2400.W11
MCSI_2_CLK_DN_CON: CON2101.16 L2104.2 RN2104.2 T2103.1
MCSI_2_CLK_DP: L2104.4 RN2104.3 U2400.V12
MCSI_2_CLK_DP_CON: CON2101.15 L2104.3 RN2104.4 T2101.1
MCSI_2_DATA_DN: L2102.1 RN2105.1 U2400.AB8
MCSI_2_DATA_DN_CON: CON2101.19 L2102.2 RN2105.2 T2102.1
MCSI_2_DATA_DP: L2102.4 RN2105.3 U2400.AA9
MCSI_2_DATA_DP_CON: CON2101.18 L2102.3 RN2105.4 T2104.1
MCSI_COMP: R2510.2 U2400.AF14
MDSI_COMP: R2511.2 U2400.AD12
MICBIAS1: R1117.1 U1001.4
MIPI_BKLT_CTRL: T2657.1 U2400.BN37
OTG: R8806.1 R8834.2 U8800.8
PCIE_RCOMP_DN: R2411.2 U2400.BN3
PCIE_RCOMP_DP: R2411.1 U2400.BM4
PG#: T8800.1 U8800.3
PLT_CLK0_2MP: R2101.1 U2400.BP8
PLT_CLK0_2MP_R: C2122.1 CON2101.6 R2101.2
PLTRST#: CON3800.46 Q3009.2 R1045.1 R7135.1 U2400.H20 U8201.K5
PLTRST#_R: Q3009.3 R3084.1 U3001.44
PMC_ACPRESENT: T2608.1 U2400.E21
PMIC_5V_EN: D8101.2 R7356.1 U8201.K10
PMIC_AC_OK: D8101.1 R8335.1 U8201.E8
PMIC_BACKLIGHT_EN: R7151.1 R8515.1 R8517.2
PMIC_BODYSAR_N: T8464.1 U8201.F7
PMIC_CHGDET#: T8430.1 U8201.P4
PMIC_CHGRINT#: R8456.1 R8457.2 R8458.1 U8201.M2
PMIC_ILIM0: T8410.1 U8201.D7
PMIC_ILIM1: T8411.1 U8201.D8
PMIC_INT: R2601.2 U2400.E17 U8201.J6
PMIC_MEMCFG0: R0507.1 R0515.2 U8201.G9
PMIC_MEMCFG1: R0506.1 R0514.2 U8201.E10
PMIC_MODEM_OFF#: T8428.1 U8201.K2
PMIC_PANEL_EN: R7147.1 U8201.H6
PMIC_PWRBTN#: CON3800.49 Q3006.6 R3046.2 U8201.J8
PMIC_ROTATION_LOCK: T8416.1 U8201.H9
PMIC_RTC_POR: R8337.1 U8201.H7
PMIC_SHUTDOWN#: T8403.1 U8201.G6
PMIC_THERMTRIP_B: Q8102.6 R8131.2 T2301.1 U2301.3 U8201.J7
PMIC_TOUCH_EN: R7355.1 U8201.F9
PMIC_VBUS_EN: R5201.1 U8201.H10
PMIC_VIBRATOR_PWM: R7001.2 U8201.E6
PMIC_VOLUMEDOWN#: R2010.1 R8435.2 U8201.K11
PMIC_VOLUMEUP#: R2011.1 R8431.2 U8201.L11
PMID: C8801.2 U8800.23
PMU_BATTLOW#: R2643.2 U8201.H4
PMU_BATTLOW#_R: R2643.1 R2685.1 U2400.E23
PROCHOT#: R2508.2 U2400.E33 U8201.K6
PROG_SPI_CS#: CON3800.37 U3301.D5
PROG_SPI_IO3: CON3800.41 Q3301.1 R3342.2 R3350.1 U3301.B4 U3301.D3 U3304.3
PROG_SPI_MISO: CON3800.35 U3301.E4
PROG_SPI_MOSI: CON3800.33 U3301.E3
PSEL: R8803.2 R8805.1 U8800.2
PWR_3P3_SX_EN: Q8406.2 R8406.1 U2400.J27
PWR_AMBER_LED#: CON2002.6 U3001.57
PWR_BLUE_LED#: CON2002.7 U3001.25
PWRBTN#: CON2002.4 R3046.1 R3047.1 T2012.1
PWRBTN#_EC: R3045.1 R3047.2 U3001.48
R_BT_PCM_IN: R5414.2 U5401.59
R_BT_PCM_OUT: R5411.2 U5401.60
R_BT_UART_CTS_N: R5409.2 U5401.54
R_BT_UART_RTS_N: R5407.2 U5401.57
R_BT_UART_RXD: R5408.2 U5401.56
R_BT_UART_TXD: R5410.2 U5401.55
R_I2S_1_RXD: R5411.1 U2400.BK16
R_I2S_1_TXD: R2540.1 R5414.1 U2400.BR25
R_LPC_CLKOUT_1: SP2603.2 U2400.BL17
R_UART_BT_CTS: R5407.1 U2400.BK38
R_UART_BT_RTS: R5409.1 U2400.BU39
R_UART_BT_RXD: R5410.1 U2400.BV38
R_UART_BT_TXD: R5408.1 U2400.BL39
R_XDP_H_TCK: CON3800.9 R2634.2 U2400.C11
REGN: C8800.2 R8814.1 R8822.1 U8800.22
RESET_BUTTON#: C2011.1 R2020.1 R8119.2 T2005.1
REXT: R7105.1 U7107.22
RLV_AMP: R7104.1 U7107.23
RSMRST#: C2610.1 CON3800.47 R2638.1 T2624.1 U2400.C9 U8201.J4
SATA_RCOMP_DN: R2409.1 U2400.BT4
SATA_RCOMP_DP: R2409.2 U2400.BR3
SD3_WP: R2512.1 U2400.BN9
SD_CD#_R: CON0700.19 D0706.1 R0737.2
SD_CLK_R: C0714.1 CON0700.5 D0705.1 R0734.2
SDIO3_1P8V_R_EN: U2400.BN11 U8201.H8
SDIO3_CD#: C0715.1 R0704.1 R0737.1 R2512.2 U2400.BN19
SDIO3_CLK: R0734.1 U2400.BL25
SDIO3_CMD: CON0700.3 D0704.1 R0724.2 U2400.BN25
SDIO3_DATA_0: CON0700.7 D0703.1 U2400.BP24
SDIO3_DATA_1: CON0700.8 D0702.1 U2400.BK26
SDIO3_DATA_2: CON0700.1 D0701.1 U2400.BJ25
SDIO3_DATA_3: CON0700.2 D0700.1 U2400.BU25
SDIO3_PWR_EN_R#: R0706.1 U2400.BK12 U8201.D2
SDIO3_RCOMP: R2509.1 U2400.BH26
SDIORESET: C5417.1 R5426.2 R5428.2 U5401.45
SDIOWAKE: R5421.2 R5423.2 U5401.46
SDMMC3_PWR_EN: Q0704.2 Q0704.3 R0700.2
SIM_DET: T2541.1 U2400.J37
SLP_S0IX#: CON3800.31 Q0901.5 Q3008.2 R2615.1 U2400.J21 U8201.L3
SLP_S0IX#_R: Q3008.3 R3082.1 U3001.7
SLP_S3#: CON3800.27 R2642.1 R8224.1 U2400.D22 U8201.L5
SLP_S4#: CON3800.29 Q3004.2 R2641.1 U2400.K20 U8201.K7
SLP_S4#_R: Q3004.3 R3060.1 U3001.43
SOC_MIPI_BLEN: T2509.1 U2400.G33
SOC_MIPI_VDDEN: T2508.1 U2400.J33
SOC_PWRBTN#: C2608.1 U2400.C23 U8201.D4
SOC_RTEST#: C2602.1 CON3800.53 R2626.2 R8337.2 U2400.D10
SOC_SPI_CS#: R3347.1 U2400.C27 U3301.B5
SOC_SPI_MISO: R3346.1 U2400.K28 U3301.A4
SOC_SPI_MOSI: R3345.1 U2400.E27 U3301.A2
SOC_TOUCH_EN: R2542.1 R7360.1
SOC_TOUCH_EN_R: R2542.2 U2400.BH14
SOC_USB_OC#: R5205.2 U2400.F24
SOC_VIBRATOR_PWM: R7002.2 U2400.BJ37
SOC_VOLUMEDOWN#: R2008.2 U2400.BU9
SOC_VOLUMEUP#: R2009.2 U2400.BR9
SPEAKER_OUT_LN: R1120.1 T1106.1 U1001.48
SPEAKER_OUT_LN_CON: CON1102.4 D1104.1 R1120.2
SPEAKER_OUT_LP: R1121.1 T1105.1 U1001.1
SPEAKER_OUT_LP_CON: CON1102.3 D1103.1 R1121.2
SPEAKER_OUT_RN: R1112.1 T1104.1 U1001.47
SPEAKER_OUT_RN_CON: CON1102.2 D1102.1 R1112.2
SPEAKER_OUT_RP: R1113.1 T1103.1 U1001.45
SPEAKER_OUT_RP_CON: CON1102.1 D1101.1 R1113.2
SPI_CS#: R3315.1 R3339.2 R3347.2 U3301.D1 U3302.1
SPI_CS#_CON: CON3301.5 R3315.2
SPI_HOLD#: CON3301.10 R3338.2 U3302.7
SPI_MISO: CON3301.6 R3346.2 U3301.C1 U3302.2
SPI_MOSI: CON3301.8 R3345.2 U3301.B1 U3302.5
SRT_CRST#: C2603.1 CON3800.45 R2627.2 U2400.G11
STAT: R3080.2 R8811.1 U8800.4
SUS_PWRDOWNACK: R2640.2 U2400.H24 U8201.L4
SVID_ALERT_PMIC: R8502.2 U8201.F5
SVID_CLK_PMIC: R8504.2 U8201.E4
SVID_DIO_PMIC: R8503.2 U8201.F4
SYSTHERM_0: C8344.2 R8323.2 R8326.1 U8201.K8
SYSTHERM_1: C8345.2 R8324.2 R8325.1 U8201.L7
SYSTHERM_2: C8346.2 R8327.2 R8328.1 U8201.L8
T2_PMIC: R8509.1 R8510.2 U8201.P14
T4_PMIC: R8507.2 R8508.1 U8201.A14
TA0N: LX7324.1 RN7309.1 U7107.46
TA0P: LX7324.4 RN7309.3 U7107.45
TB0N: LX7326.4 RN7337.3 U7107.44
TB0P: LX7326.1 RN7337.1 U7107.43
TC0N: LX7327.1 RN7338.1 U7107.41
TC0P: LX7327.4 RN7338.3 U7107.40
TCK0N: LX7325.4 RN7341.3 U7107.39
TCK0P: LX7325.1 RN7341.1 U7107.38
TD0N: LX7328.4 RN7340.3 U7107.36
TD0P: LX7328.1 RN7340.1 U7107.35
THERM_SET: R2301.1 U2301.1
TOUCH_INT#: C2611.1 R2645.2 R7373.2 SP7301.1 U2400.F22
TOUCH_RESET#_CN_3V3: CON7305.29 SP7307.2
TOUCH_RST#: SP7308.1 U2400.BU15
TOUCH_SCL_3V3: C7321.1 CON7305.26 SP7303.2
TOUCH_SDA_3V3: C7322.1 CON7305.27 SP7305.1
TP_BCU_DIS_A: T8405.1 U8201.B4
TP_BCU_DIS_B: T8407.1 U8201.E5
TP_BCU_DIS_CRIT: T8406.1 U8201.D5
TP_DDRXXXSI3_1P5_OBS: T2700.1 U2400.AA44
TP_DIG_RAM_OBS: T2703.1 U2400.AA17
TP_DIGDI3SIO_1P03_OBS: T2701.1 U2400.BB44
TP_RAM_CPU0_OBS: T2702.1 U2400.AH38
TP_ULPI_VBUS_EN: T8431.1 U8201.L6
TP_ULPMC_TEST: CON3800.12 T3802.1
TP_VCC_CORE1_VID_OBS: T2704.1 U2400.AF39
TP_VCC_CORE2_VID_OBS: T2705.1 U2400.M34
TS_CHG: R8812.1 R8813.1 R8814.2 U8800.12
UART3_DEBUG_RXD: CON3800.57 T3803.1 U2400.BT14
UART3_DEBUG_TXD: CON3800.55 T3804.1 U2400.BU13
ULPMC_RST#: CON3800.10 T3801.1
USB2_DEBUG_DN: CON3800.54 U2400.C3
USB2_DEBUG_DP: CON3800.52 U2400.D2
USB2_DN: L5201.3 RNX5227.1 U2400.E3
USB2_DOCK_DN: U2400.C5 U5101.7
USB2_DOCK_DP: U2400.D6 U5101.8
USB2_DP: L5201.2 RNX5227.3 U2400.D4
USB3_REXT0: R2603.1 U2400.N9
USB3_REXT1: R2608.1 U2400.M10
USB_DOCK_DM: CON5101.6 U5101.2 U5101.3
USB_DOCK_DP: CON5101.4 U5101.1 U5101.4
USB_HSIC_RCOMP: R2622.1 U2400.T14
USB_OC#: R5204.1 R5205.1 U5203.5
USB_PHY0_RST#: T2685.1 U2400.C21
USB_RCOMP: R2617.2 U2400.H8 U2400.J7
VBCLK: C1046.1 R1020.1 U1001.30
VOLUMEDOWN#: CON2002.1 R2008.1 R2010.2
VOLUMEUP#: CON2002.2 R2009.1 R2011.2
W_DISABLE#1: T5401.1 U5401.28
W_DISABLE#2: C5410.1 R5418.2 R5420.2 U5401.63
WL_DEV_EN: R5428.1 T5407.1 U2400.B24
WL_DEV_WAKE: R5425.2 U5401.22
WLAN_DEV_WAKE: R5425.1 T5406.1 U2400.K16
WLAN_HOST_WAKE#: R5423.1 T5405.1 U2400.K22
WLBT_1V8: C5415.1 C5416.1 R5421.1 R5426.1 R5427.2 R5429.1 R5430.1 R5431.1 R5432.1 R5433.1
WRST#: C3001.1 R3001.2 T3007.1 U3001.23
XDP_H_PRDY#: CON3800.13 U2400.B12
XDP_H_PREQ#: CON3800.11 R2676.2 R3803.2 U2400.F12
XDP_H_TDI: CON3800.1 R2636.1 U2400.E11
XDP_H_TDO: CON3800.3 R2630.2 U2400.J11
XDP_H_TMS: CON3800.5 R2635.1 U2400.K12
XDP_H_TRST#: CON3800.7 R2629.1 U2400.H12
N43112359: C8101.1 JP8101.2 L8100.1 R8101.1 R8113.1 R8114.1 U8100.8
N43112585: C8100.1 JP8100.2 R8103.1
N43112762: L8100.2 U8100.3 U8100.4
N45929927: C8106.1 R8101.2 R8111.1 U8100.9
N45935989: T8100.1 U8100.12
N46908093: C1102.1 R1118.1 R1119.1 R1125.2
N50246848: D0905.1 R0910.1
N50248755: C0910.1 Q0901.2 R0911.1 R0914.1
N54799847: C8304.1 C8305.1 R8320.2 U8201.H3 U8201.K13
N54800277: C8310.1 R8366.2 U8201.G2
N54802100: C8309.1 R8365.2 U8201.M13
N54837978: C8405.1 JP8402.1 Q8402.3 R8404.1
N55037572: T8507.1 U8201.N4
N55037573: T8506.1 U8201.N5
N55396009: R8450.2 U8201.R2
N55582751: C1003.1 U1001.19
N55583031: C1003.2 U1001.18
N55583175: C1004.2 U1001.20
N55583183: C1004.1 U1001.21
N55584679: C1001.1 C1002.2 R1047.2 U1001.15
N55851405: T2601.1 U2400.BV4
N55851407: T2602.1 U2400.BU5
N55851409: T2600.1 U2400.BU7
N55956187: CON3800.32 R3810.2
N56361708: Q0704.5 R0703.2 R0704.2 R0706.2
N56361884: C0722.2 Q0703.1 R0755.2 R0757.2
N56362286: Q0704.6 R0757.1
N56674697: R3340.2 U3302.3
N56674876: R3343.2 R3351.1 U3304.7
N56674880: Q3301.3 R3352.2 U3304.2
N57330511: R8515.2 U8201.G5
N57534678: C1106.1 R1116.2 R1117.2
N57840224: C7103.1 L7102.1 L7111.2
N57908913: Q0901.3 R0900.2 R0901.2 R0902.2 R0903.2 R0904.2 R0905.2 R0906.2 R0907.2
N58054896: C8802.2 L8801.1 U8800.19 U8800.20
N58054898: C8802.1 R8800.2
N58054900: R8800.1 U8800.21
N58054914: R8833.2 U8800.7
N58054916: C8811.1 C8812.1 JP8800.1 U8800.13 U8800.14
N58056974: C9005.1 C9006.1 C9010.1 D9001.2 JP9000.1 JP9001.2
N58056982: JP9001.1 R9001.1
N58056996: SR9001.1 U9000.11
N58057009: C9008.1 U9000.4
N58057015: R9003.1 U9000.3
N58057035: SR9000.1 U9000.10
N58057050: C9007.1 U9000.2
