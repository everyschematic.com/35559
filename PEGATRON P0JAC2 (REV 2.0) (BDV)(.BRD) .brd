# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
R_I2S_1_TXD: length 45.5
  L5-SIG w0.06: 43.33,69.08 43.48,69.08 43.65,69.26 44.22,69.26 v5(44.77,69.8)
  L5-SIG w0.109: 43.33,69.08 40.13,69.08 39.21,70 38.62,70 28.94,79.67 28.94,79.96 28.94,83.37 28.66,83.65 28.66,86.7 v3(29.03,87.07)
  L6-GND w0.102: v4(28.63,86.94) 28.76,87.07 v3(29.03,87.07)
  L7-SIG w0.06: v6(46.63,69.86) 46.6,69.83 46.23,69.83 46.09,69.96 45.9,69.96 45.59,69.66 45.02,69.66 44.88,69.8 44.77,69.8 v5(44.77,69.8)
  L7-SIG w0.084: v1(17.56,84.31) 18.97,82.91 22.14,82.91 22.72,82.33 24.32,82.33 28.27,86.28 28.27,86.57 v4(28.63,86.94)
  BOTTOM w0.31: v1(17.56,84.31) 17.56,84.68 17.58,84.69 R5414.1
R_LPC_CLKOUT_1: length 59.4
  L4-SIG w0.109: v3(49.1,66.81) 49.1,67.47 48.92,67.65 48.92,67.99 47.53,69.38 44.77,69.38 43.88,70.27 41.2,70.27 40.08,71.39 38.64,71.39 35.21,74.82 35.21,76.26 32.04,79.43 32.04,79.96 31.24,80.76 31.24,83.53 31.77,84.05 32.5,84.05 33.04,84.59 33.79,84.59 35.82,86.62 37.24,88.03 37.24,88.11 37.07,88.28 36.71,88.28 36.65,88.35 36.65,88.7 36.75,88.8 37.36,88.8 37.5,88.93 37.5,89.16 37.39,89.26 36.8,89.26 36.69,89.37 36.69,89.59 36.8,89.7 37.39,89.7 37.5,89.81 37.5,90.03 37.39,90.14 36.8,90.14 36.69,90.25 36.69,90.47 36.8,90.58 37.39,90.58 37.5,90.68 37.5,90.9 37.39,91.01 36.8,91.01 36.69,91.12 36.69,91.34 36.8,91.45 37.39,91.45 37.5,91.56 37.5,91.77 37.41,91.86 36.84,91.86 36.71,91.98 36.71,92.12 36.9,92.31 37.33,92.31 37.5,92.49 37.5,92.91 37.5,92.91 37.5,93.21 37.5,93.21 37.5,99.34 37.36,99.48 37.36,100.81 37.59,101.04 37.86,101.04 38.02,100.87 v3(38.02,100.65)
  L5-SIG w0.06: v6(47.77,67.66) 47.93,67.66 48.38,67.21 48.38,67.16 48.58,66.96 48.96,66.96 v3(49.1,66.81)
  L6-GND w0.102: v1(38.38,100.56) 38.37,100.54 38.13,100.54 v3(38.02,100.65)
  BOTTOM w0.31: v1(38.38,100.56) v9(38.38,99.62)
R_UART_BT_CTS: length 37.1
  L5-SIG w0.06: v6(48.09,73) 47.67,72.58 47.29,72.58 47,72.87 46.13,72.87 45.9,72.65 43.72,72.65 43.16,73.21 41.88,73.21 41.18,73.92 41.03,73.92
  L5-SIG w0.109: 41.03,73.92 40.62,73.92 35.47,79.07 34.15,79.07 32.28,80.94 32.28,82.22 v3(32.56,82.51)
  L6-GND w0.102: v4(32.21,82.32) 32.37,82.32 v3(32.56,82.51)
  L7-SIG w0.084: v1(17.58,82.81) 18.06,82.34 21.06,82.34 21.66,81.74 31.69,81.74 32.21,82.27 v4(32.21,82.32)
R_UART_BT_RTS: length 32.5
  L5-SIG w0.06: v6(46.03,73.27) 46,73.24 45.12,73.24
  L5-SIG w0.076: 45.12,73.24 44.75,73.62 42.18,73.62 42.16,73.63
  L5-SIG w0.109: 42.16,73.63 41.22,74.57 40.94,74.57 35.72,79.8 34.48,79.8 33.21,81.07 v3(33.3,81.07)
  L6-GND w0.102: v3(33.3,81.07) v4(32.92,81.07)
  L7-SIG w0.084: v1(17.58,80.53) 17.99,80.53 18.35,80.17 22.53,80.17 23.51,81.15 32.85,81.15 v4(32.92,81.07)
R_UART_BT_RXD: length 32.7
  L5-SIG w0.076: v6(45.69,73) 45.58,73.11 45.06,73.11 44.69,73.48 42.02,73.48 41.14,74.35
  L5-SIG w0.109: 41.14,74.35 40.86,74.35 35.67,79.54 34.27,79.54 32.85,80.97 32.85,81.48 32.96,81.59 v3(32.96,81.57)
  L6-GND w0.102: v3(32.96,81.57) 32.92,81.53 v4(32.52,81.53)
  L7-SIG w0.084: v4(32.52,81.53) 32.37,81.37 21.26,81.37 20.87,81.76 18.05,81.76 v1(17.58,81.29)
R_UART_BT_TXD: length 37.2
  L5-SIG w0.06: 40.1,74.79 40.75,74.14 41.12,74.14 41.91,73.35 43.19,73.35 43.77,72.77 45.85,72.77 46.37,73.28 v6(47.77,73.28)
  L5-SIG w0.109: 40.1,74.79 35.59,79.31 34.2,79.31 32.49,81.03 32.49,81.82 32.95,82.28 v3(33.14,82.28)
  L6-GND w0.102: v4(33.32,81.88) 33.14,82.07 v3(33.14,82.28)
  L7-SIG w0.084: v1(17.58,82.05) 20.92,82.05 21.41,81.56 31.9,81.56 32.29,81.94 33.26,81.94 v4(33.32,81.88)
R_XDP_H_TCK: length 59.8
  L4-SIG w0.102: v3(88.01,97.19) 88.29,96.91 88.29,96.27 84.43,92.41 84.43,92 84.16,91.73 83.64,91.73 82.35,90.45 82.35,90.15 80.24,88.03 80.24,87.84 75.92,83.52 75.92,78.67 75.15,77.91 74.87,77.91 74.3,77.35 71.95,77.35 70.59,75.99 69.93,75.33 69.93,73.12 70.74,72.31 70.74,72.04 71.6,71.18 71.6,70.62 71.35,70.37 71.35,70.06 71.2,69.91 71.2,69.72 71.17,69.7 71.17,69.38 71.2,69.36 71.2,68.48 71.19,68.48 71.19,67.53 70.21,66.54 v3(70.21,66.51)
  L6-GND w0.102: v4(70.57,66.46) 70.25,66.46 v3(70.21,66.51) ; v3(88.01,97.19) 87.89,97.07 v1(87.65,97.07)
  L7-SIG w0.06: v6(60.82,66.04) 61.02,66.04 61.23,65.83 62.28,65.83
  L7-SIG w0.102: 62.28,65.83 63.51,64.6 64.13,64.6 64.61,64.12 66.13,64.12 v1(66.42,64.41) 66.66,64.17 66.91,64.17 67.06,64.32 67.46,64.32 67.74,64.04 68.61,64.04 68.83,64.27 69.23,64.27 70.57,65.6 v4(70.57,66.46)
  BOTTOM w0.102: v1(87.65,97.07) 88.16,97.07 88.77,96.46 89.33,96.46 89.54,96.25 91.56,96.25 v9(92.13,95.68)
REGN: length 18.4
  L7-SIG w0.254: v1(38.42,23) 39.31,23.89 v1(39.31,24.55) 39.31,24.89 39.59,25.17 39.59,25.57 39.22,25.94 39.22,27.05 37.58,28.69 33.43,28.69 32.36,27.62 29.92,27.62 29.67,27.37 29.67,26.96 29.36,26.65 29.36,24.78 v1(29.2,24.62)
  vias: v9(37.45,23.08)
RESET_BUTTON#: length 94.4
  L2-SIG w0.254: v8(82.93,49.92) 83.66,49.92 88.55,54.81 v8(88.55,55.05)
  L3-GND w0.254: v8(88.55,55.05) 88.82,54.77 v3(88.82,54.65) ; v3(82.55,49.92) v8(82.93,49.92)
  L5-SIG w0.254: v3(95.4,93.15) 95.83,92.72 95.83,66.15 93,63.32 93,56.83 90.81,54.65 v3(88.82,54.65) ; v3(43.99,50.33) 44.48,50.81 46.06,50.81 46.95,49.92 54.13,49.92 54.66,50.45 57.31,50.45 58.96,48.8 81.43,48.8 v3(82.55,49.92)
  L6-GND w0.102: v1(95.4,92.77) v3(95.4,93.15) v1(95.4,93.53)
  L6-GND w0.254: v3(43.99,50.33) v1(43.31,50.33)
  BOTTOM w0.102: T2005.1 v1(95.4,93.53)
REXT: length 2.3
  BOTTOM w0.102: U7107.22 73.61,15.86 v9(74.09,16.34) R7105.1
RLV_AMP: length 2.2
  BOTTOM w0.102: R7104.1 73.71,15.58 73.49,15.36 U7107.23
RSMRST#: length 112.1
  L4-SIG w0.109: v2(86.87,89.67) 87.31,89.67 87.66,89.32 87.66,89 87.49,88.84 87.49,84.27 80.63,77.41 78.1,77.41 77.85,77.16 77.85,76.41 77.85,76.24 77.29,75.68 77.29,75.38 76.89,74.97 76.89,72.42 77.26,72.05 v3(77.26,71.13) 77.66,70.73 77.66,69.23 79.32,67.56 79.32,60.58 80.74,59.16 80.74,57.55 82.43,55.86 82.43,54.59 v3(82.43,54.58) ; v3(63.54,62.86) 62.83,62.15 62.06,62.15 61.4,61.5 61.4,60.7 61.58,60.52 61.58,59.48 v3(61.79,59.27)
  L6-GND w0.06: v6(59.12,36.54) 59.32,36.74 59.32,37.02 59.37,37.07 59.37,37.67 59.42,37.72
  L6-GND w0.102: v3(63.54,62.86) 63.54,63.09 v5(63.4,63.23) ; v1(62.06,58.83) 62.06,58.99 v3(61.79,59.27) ; v4(76.81,71.36) 77.03,71.36 v3(77.26,71.13) ; v3(82.43,54.58) 82.43,54.46 v4(82.2,54.23) ; v4(60.48,45.48) 60.48,42.35 60.07,41.94 60.07,40.17 59.74,39.84 59.74,38.59 59.42,38.27 59.42,37.72
  L7-SIG w0.06: 62.19,64.53 61.37,65.35 61.01,65.35 60.98,65.32 v6(60.79,65.32)
  L7-SIG w0.084: v4(60.48,45.48) 60.68,45.68 66.8,45.68 67.31,46.19 71.53,46.19 72.72,47.38 75.55,47.38 78.54,50.37 78.54,50.47 82.2,54.13 v4(82.2,54.23) ; 62.19,64.53 63.4,63.32 v5(63.4,63.23) 63.96,62.67 64.19,62.67 64.62,62.24 64.62,61.99 64.75,61.86 66.59,61.86 66.77,62.04 67.62,62.04 67.81,62.24 68.52,62.24 69.49,63.21 69.49,63.97 71.96,66.44 74.25,66.44 75.6,67.79 75.6,67.96 75.6,68.04 76.81,69.25 v4(76.81,71.36) ; v2(86.87,89.67) 87.44,89.67 v1(87.65,89.47)
  BOTTOM w0.31: v1(87.65,89.47) 88.06,89.47 88.77,90.18 T2624.1
SATA_RCOMP_DN: length 6
  L7-SIG w0.06: 44.08,62.98 45.68,62.98 46.03,63.33 46.03,63.57 v6(46.41,63.95)
  L7-SIG w0.127: 44.08,62.98 42.46,62.98 42.13,62.65 41.89,62.65 41.52,62.28 v1(41.23,62.28)
SATA_RCOMP_DP: length 5.4
  L7-SIG w0.06: v6(46.63,63.66) 46.63,63.33 46.42,63.11 46.42,62.96 46.22,62.76 44.29,62.76 44.12,62.6 43.7,62.6
  L7-SIG w0.127: v1(42.09,62.27) 42.29,62.27 42.62,62.6 43.7,62.6
SD3_WP: length 5.7
  L7-SIG w0.06: 45.44,65.46 45.51,65.53 46.12,65.53 46.2,65.44 46.46,65.44 46.58,65.57 47,65.57 v6(47.2,65.36)
  L7-SIG w0.102: v1(41.95,65.52) 42.25,65.52 42.6,65.16 45.14,65.16 45.44,65.46
SD_CD#_R: length 19.4
  L7-SIG w0.084: v1(90.96,90.09) 91.25,90.38 v1(91.25,90.81) 91.72,91.29 92.28,91.29 92.56,91.01 92.56,89.95 91.82,89.2 90.93,89.2 90.79,89.06 90.79,88.26 91.16,87.89 91.85,87.89 92.01,87.89 92.28,87.61 92.28,87.22 91.87,86.81 91.73,86.81 90.78,85.86 90.78,84.3 87.62,81.14 v1(86.21,81.14)
  BOTTOM w0.31: v9(91.71,91.92) 91.24,91.45 R0737.2
SD_CLK_R: length 17.9
  L7-SIG w0.084: v1(91.81,87.42) 91.81,87.42 91.81,87.41 91.13,87.41 v1(91.07,87.36) 90.95,87.24 v1(90.95,86.87) 90.9,86.87 89.7,85.67 89.7,84.03 87.72,82.04 86.28,82.04 85.21,80.98 85.21,77.69 86.04,76.86 v1(86.21,76.86)
  BOTTOM w0.31: v9(93.88,89.28) 93.6,89 93.18,89 91.9,87.72 R0734.2
SDIO3_1P8V_R_EN: length 77.3
  L5-SIG w0.06: v6(58.72,34.94) 58.12,35.54 58.12,35.86 57.97,36 57.97,36.21 57.7,36.49 57.01,36.49 56.63,36.87 56.63,37.68 56.01,38.29 56.01,38.59
  L5-SIG w0.109: v3(37.92,52.21) 37.44,51.72 33.71,51.72 32.84,50.86 31.85,50.86 31.2,50.22 28.34,50.22 27.58,49.46 27.58,45.86 29.16,44.28 32.07,44.28 34.06,42.29 45.58,42.29 48.45,45.16 50.62,45.16 50.62,45.16 50.99,45.16 56.01,40.14 56.01,38.59 ; v3(38.91,62.09) 44,62.09 44.45,62.54 45.04,62.54 47.21,64.72 v6(47.21,65.93)
  L6-GND w0.102: v4(37.95,52.94) 37.92,52.92 v3(37.92,52.21) ; v3(38.91,62.09) v4(39.29,62.09)
  L7-SIG w0.084: v4(39.29,62.09) 38.61,61.4 38.61,58.61 39.65,57.57 39.65,56.14 38.82,55.31 38.82,54.09 37.95,53.22 v4(37.95,52.94)
SDIO3_CD#: length 105.2
  L4-SIG w0.109: v3(37.39,60) 39.17,60 42.91,56.26 60.16,56.26 v3(61.95,58.06)
  L6-GND w0.102: v3(61.95,58.06) 62.26,57.76 v4(62.26,57.57) ; v3(37.39,60) 37.14,60.26 v4(37.14,60.39)
  L7-SIG w0.06: v6(47.2,68.19) 46.61,67.6 46.32,67.6 46.11,67.39 44.71,67.39 43.92,66.6 43.4,66.6
  L7-SIG w0.084: v4(62.26,57.57) 62.26,57.03 62.47,56.82 70.57,56.82 71,56.39 79.64,56.39 80.2,56.95 80.2,57.96 79.84,58.32 79.59,58.32 79.35,58.55 79.35,59.19 82.07,61.91 82.54,61.91 84.43,63.8 84.48,63.8 v1(84.87,64.2) 84.87,65.33 84.59,65.61 84.59,82.48 85.13,83.02 86.3,83.02 89.87,86.58 89.87,89.11 90.24,89.48 90.66,89.48 90.77,89.59 91.54,89.59 v1(91.9,89.95) 91.98,90.03 91.98,90.08 92.09,90.18 v1(92.09,90.81) ; v4(37.14,60.39) 37.24,60.49 37.24,63.69 37.36,63.81 37.61,64.06 39.15,64.06 40.41,65.33 41,65.33 41.11,65.44 v1(41.11,65.47) 41.11,65.72 41.41,66.02 41.41,66.27 41.82,66.68 43.31,66.68 43.38,66.6 43.4,66.6
  BOTTOM w0.31: R0737.1 93.05,90.81 v9(93.19,90.96)
SDIO3_CLK: length 124.1
  L5-SIG w0.06: 43.33,68.3 43.94,68.3 45.19,69.55 45.53,69.55 45.72,69.74 47.17,69.74 47.36,69.93 47.75,69.93 v6(47.76,69.92)
  L5-SIG w0.109: 43.33,68.3 39.8,68.3 38.89,69.21 38.29,69.21 26.99,80.51 26.99,92.53 32.85,98.39 39.24,98.39 39.41,98.56 41.32,98.56 41.81,99.05 41.81,100.98 44.18,103.35 84.38,103.35 87.29,100.44 89.85,100.44 92.16,98.13 92.16,92.53 93.09,91.6 v3(93.36,91.6)
  L6-GND w0.102: v4(93.45,91.23) 93.45,91.51 v3(93.36,91.6)
  L7-SIG w0.084: v4(93.45,91.23) 93.45,89.59 93.09,89.23 v1(93.09,88.02)
  BOTTOM w0.31: v1(93.09,88.02) 93.09,87.82 R0734.1 93.66,87.49 v9(93.7,87.53)
SDIO3_CMD: length 146.4
  L5-SIG w0.109: v3(91.63,85.89) 91.63,86.31 93.4,88.07 v3(93.4,88.81) ; v3(28.82,77.6) 26.54,79.88 26.54,92.68 32.62,98.76 39.09,98.76 39.26,98.92 40.35,98.92 41.42,100 41.42,101.11 44.03,103.71 84.53,103.71 87.45,100.8 90,100.8 92.52,98.28 92.52,92.68 93.05,92.16 v3(93.38,92.16)
  L6-GND w0.102: v1(91.28,85.89) v3(91.63,85.89) ; v3(93.38,92.16) 93.4,92.14 v4(93.74,92.14) ; v3(28.82,77.6) 28.82,77.23 v4(28.79,77.2) ; v3(93.4,88.81) 93.64,89.05 v4(93.64,89.24)
  L7-SIG w0.06: v6(47.2,69.89) 46.91,69.89 46.73,70.07 46.55,70.07 46.46,69.98 46.25,69.98 46.14,70.08 45.71,70.08 45.69,70.11 44.76,70.11 44.52,69.86 43.49,69.86 43.33,69.7
  L7-SIG w0.084: v4(93.74,92.14) 93.56,92.14 93.44,92.03 93.44,91.72 93.79,91.37 93.79,89.39 v4(93.64,89.24) 93.64,84.79 87.17,78.32 87.17,75.84 86.66,75.33 86.47,75.33 v1(86.21,75.06) ; v4(28.79,77.2) 29.92,76.07 33.17,76.07 38.82,70.42 38.82,70.34 39.73,69.43 41.7,69.43 41.97,69.7 43.33,69.7 ; v1(91.28,85.89) 91.56,85.89 91.9,86.23 v1(91.9,86.54)
  BOTTOM w0.31: v9(92.1,85.77) 91.99,85.89 v1(91.28,85.89) D0704.1
SDIO3_DATA_0: length 145.4
  L5-SIG w0.109: v3(92.91,93.08) 92.74,93.25 92.74,98.37 90.09,101.01 87.53,101.01 84.62,103.93 43.94,103.93 41.21,101.2 41.21,100.09 40.26,99.14 39.17,99.14 39,98.97 32.5,98.97 25.67,92.13 25.67,78.03 25.93,77.76 v3(25.93,76.99)
  L6-GND w0.102: v4(26.2,77.29) 25.93,77.03 v3(25.93,76.99) ; v3(92.91,93.08) 92.92,93.07 v4(92.92,92.72)
  L7-SIG w0.06: v6(46.95,69.61) 46.95,69.37 47.17,69.15 47.17,68.96 47.05,68.84 46.88,68.84 46.79,68.93 46.54,68.93 46.21,68.59 45.86,68.59 45.79,68.66 45.09,68.66 44.04,67.61 43.33,67.61
  L7-SIG w0.084: v1(86.21,78.66) 87.25,78.66 92.53,83.94 92.53,86.94 92.66,87.07 92.66,87.97 92.18,88.45 v1(91.24,88.45) 91.77,88.97 92.36,88.97 93.11,89.73 93.11,90.96 92.73,91.35 92.73,92.54 v4(92.92,92.72) ; 43.33,67.61 43.11,67.61 42.91,67.42 41.35,67.42 40.97,67.04 39.53,67.04 37.8,68.77 37.8,70.13 34.16,73.77 28.92,73.77 26.2,76.49 v4(26.2,77.29)
  BOTTOM w0.31: v9(85.06,78.66) v1(86.21,78.66)
SDIO3_DATA_1: length 134
  L5-SIG w0.06: 43.33,68.87 43.44,68.87 43.7,69.14 44.41,69.14 45.07,69.8 45.42,69.8 45.59,69.98 47.07,69.98 47.34,70.25 48.02,70.25 v6(48.06,70.21)
  L5-SIG w0.109: v3(91.6,89.11) 92.13,89.64 92.13,91.63 91.59,92.17 91.59,97.89 89.62,99.86 87.06,99.86 84.14,102.78 44.41,102.78 42.38,100.75 42.38,98.68 41.57,97.87 39.53,97.87 39.48,97.82 33.17,97.82 27.56,92.22 27.56,80.75 38.53,69.79 39.13,69.79 40.04,68.87 43.33,68.87
  L6-GND w0.102: v1(91.22,88.92) v3(91.6,89.11)
  L7-SIG w0.084: v1(91.22,88.92) 90.97,88.68 90.97,88.34 91.13,88.18 92.12,88.18 92.47,87.83 92.47,87.14 92.35,87.02 92.35,84.02 87.84,79.51 86.26,79.51 v1(86.21,79.56)
  BOTTOM w0.31: v9(92.07,88.99) 91.95,89.11 D0702.1
SDIO3_DATA_2: length 148.2
  L5-SIG w0.06: 43.33,68.66 43.4,68.66 43.75,69.02 44.47,69.02 45.12,69.67 45.48,69.67 45.67,69.86 47.12,69.86 47.39,70.13 47.84,70.13 48,69.97 48.2,69.97 v6(48.27,69.9)
  L5-SIG w0.109: v3(91.68,84.21) 91.8,84.21 92.43,84.84 92.43,86.3 94.51,88.38 v3(94.51,88.79) ; v3(94.51,90.58) 93.53,90.58 91.8,92.32 91.8,97.98 89.7,100.08 87.14,100.08 84.23,102.99 44.33,102.99 42.17,100.83 42.17,98.9 41.47,98.2 39.56,98.2 39.39,98.03 33,98.03 27.35,92.38 27.35,80.67 38.44,69.58 39.04,69.58 39.95,68.66 43.33,68.66
  L6-GND w0.102: v1(91.28,84.21) v3(91.68,84.21) ; v3(94.51,88.79) v4(94.51,89.21) ; v4(94.51,90.23) v3(94.51,90.58)
  L7-SIG w0.084: v1(86.21,73.26) 87.54,74.6 87.54,78.05 94.51,85.03 v4(94.51,89.21) 94.22,89.5 94.22,90.07 94.38,90.23 v4(94.51,90.23)
  BOTTOM w0.31: v9(92.13,84.04) 91.96,84.21 v1(91.28,84.21) D0701.1
SDIO3_DATA_3: length 152
  L5-SIG w0.109: v3(91.68,85.05) 92.22,85.59 92.22,86.49 93.96,88.22 v3(93.96,88.8) ; v3(94.44,91.35) 94.44,92.25 92.95,93.74 92.95,98.46 90.18,101.22 87.64,101.22 84.72,104.14 43.86,104.14 41,101.29 41,100.17 40.17,99.35 39.08,99.35 38.91,99.18 32.41,99.18 25.46,92.22 v3(25.46,77.53)
  L6-GND w0.102: v4(94.29,91.02) 94.29,91.19 v3(94.44,91.35) ; v4(94.04,89.21) 94.04,88.89 v3(93.96,88.8) ; v1(91.28,85.05) v3(91.68,85.05) ; v4(25.82,77.44) 25.55,77.44 25.46,77.53 v3(25.46,77.53)
  L7-SIG w0.06: v6(46.01,69.76) 45.75,69.5 44.75,69.5 44.52,69.72 43.61,69.72 43.4,69.52
  L7-SIG w0.084: v4(94.29,91.02) 94.08,91.02 94.04,90.98 v4(94.04,89.21) 94.04,84.82 87.35,78.13 87.35,74.97 86.55,74.16 v1(86.21,74.16) ; 43.4,69.52 43.4,69.52 42.05,69.52 41.78,69.24 39.65,69.24 38.63,70.27 38.63,70.35 33.09,75.88 31.4,75.88 28.01,75.88 26.33,77.56 25.94,77.56 v4(25.82,77.44)
  BOTTOM w0.31: v9(93.9,84.05) 93.22,84.73 91.6,84.73 v1(91.28,85.05) D0700.1
SDIO3_PWR_EN_R#: length 90.1
  L4-SIG w0.109: v3(45.89,57.98) 46.38,57.49 59.04,57.49 59.64,58.09 59.64,58.6 60.06,59.02 v3(60.06,59.03)
  L5-SIG w0.109: v3(45.89,57.98) 45.89,59.11 46.88,60.1 46.88,62.82 48.16,64.1 48.16,66.13 v6(48.04,66.26)
  L6-GND w0.102: v4(45.86,57.62) 45.89,57.65 v3(45.89,57.98) ; v4(60.25,58.73) 60.07,58.92 60.07,59.03 v3(60.06,59.03) ; v6(57.06,37.34) 57.06,37.77 56.24,38.59 56.24,38.92 55.32,39.84 55.32,40.56 54.85,41.03 54.85,44.33 54.25,44.94 v4(54.25,45.42)
  L7-SIG w0.084: v4(45.86,57.62) 45.84,57.6 45.49,57.6 43.9,56 43.9,54.76 44.82,53.84 44.82,52.96 44.41,52.55 44.41,52.37 44.16,52.13 44.16,50.46 44.91,49.71 46.74,49.71 46.89,49.86 48.74,49.86 49.17,49.44 51.84,49.44 54.25,47.04 v4(54.25,45.42) ; v4(60.25,58.73) 60.65,58.34 60.93,58.34 61.55,57.72 61.55,56.88 61.8,56.64 70.49,56.64 70.92,56.21 79.72,56.21 80.38,56.87 80.38,58.04 80.19,58.23 80.19,59.67 82.17,61.66 82.55,61.66 84.47,63.58 84.85,63.58 85.15,63.87 85.15,65.49 v1(84.91,65.72)
SDIO3_RCOMP: length 9.3
  L5-SIG w0.06: v6(48.59,70.19) 48.59,69.93 48.35,69.69 48.18,69.69 48.09,69.79 47.92,69.79 47.84,69.72 47.67,69.72 47.58,69.81 47.41,69.81 47.22,69.62 45.77,69.62 45.58,69.43 45.24,69.43 43.73,67.91 43.49,67.91 43.48,67.91 43.33,67.91
  L5-SIG w0.127: v3(41.48,67.91) 41.49,67.9 43.31,67.9 43.32,67.91 43.33,67.91
  L6-GND w0.127: v3(41.48,67.91) 41.46,67.93 40.56,67.93 v1(40.54,67.91)
SDIORESET: length 4.5
  BOTTOM w0.31: R5426.2 R5428.2 C5417.1 5.78,75.29 5.79,75.31 5.94,75.47 6.35,75.88 v9(6.35,76.11) U5401.45
SDIOWAKE: length 5.4
  BOTTOM w0.102: R5421.2 4.62,73.54 4.62,74.28 R5423.2 4.58,75.13 v9(4.58,75.8) 4.58,75.88 5.85,77.15 U5401.46
SDMMC3_PWR_EN: length 5
  BOTTOM w0.102: R0700.2 84.64,60.04 84.64,58.68 84.97,58.35 Q0704.3 84.97,56.67 85.19,56.45 85.42,56.45 85.62,56.65 Q0704.2
SIM_DET: length 1
  L3-GND w0.06: v3(58.5,72.7) 58.12,72.7 v8(58.07,72.76)
  L6-GND w0.06: v3(58.5,72.7) 58.51,72.72 v6(59.05,72.72)
SLP_S0IX#: length 152.2
  L4-SIG w0.109: v3(59.51,47.94) 67.66,47.94 71.61,51.89 71.61,58.87 72.55,59.81 72.55,61.94 73.8,63.19 73.8,63.52 73.56,63.76 73.13,63.76 v3(72.88,63.51) 72.64,63.75 v3(72.64,66.51) 71.81,67.34 71.81,68.23 72.34,68.76 72.34,72.52 71.62,73.24 71.16,73.24 71.16,73.24 70.7,73.71 70.7,75.23 72.2,76.73 75.35,76.73 76.53,77.91 76.53,81.26 80.9,85.63 80.9,87.83 82.97,89.89 82.97,90.19 83.89,91.12 84.41,91.12 85.85,92.56 86.35,92.56 86.47,92.67 v2(86.89,92.67) ; v3(75.31,48.17) 75.31,46.87 74.7,46.26 74.7,42.99 75.31,42.38 75.31,35.39 76.18,34.53 78.11,34.53 v3(79.2,33.44)
  L5-SIG w0.06: 62.85,66.97 62.62,66.97 62.29,67.3 61.94,67.3 61.29,67.95 60.67,67.95 60.41,68.21 60.02,68.21 59.44,68.78 v6(59.07,68.78)
  L5-SIG w0.107: 62.85,66.97 63.35,66.97 64.05,66.28 64.93,66.28
  L5-SIG w0.109: v3(75.31,48.17) 74.98,48.5 60.06,48.5 v3(59.51,47.94) ; 64.93,66.28 67.35,66.28 67.64,66.57 68.32,66.57 68.32,66.57 68.49,66.57 69.28,65.78 70.72,65.78 71.05,66.11 72.25,66.11 v3(72.64,66.51)
  L6-GND w0.06: 60.91,38.59 60.91,38.41 60.02,37.52 60.02,37.02 v6(59.93,36.94)
  L6-GND w0.102: v4(59.03,47.89) 59.45,47.89 v3(59.51,47.94) ; 60.91,38.59 60.91,38.59 60.91,38.65 61.55,39.29 61.55,42.51 62.18,43.14 62.18,44.64 62.46,44.92 v4(62.46,44.97) ; v3(72.88,63.51) 72.85,63.48 v4(72.85,63.16) ; v4(79.58,33.44) v3(79.2,33.44)
  L7-SIG w0.084: v4(79.58,33.44) 82.22,33.44 82.91,32.75 82.91,29.65 83.39,29.17 84.84,29.17 85.12,28.89 85.12,28.38 85.42,28.08 v1(85.42,27.9) ; v4(62.46,44.97) 62.39,44.9 59.83,44.9 59.03,45.7 v4(59.03,47.89) ; v1(73.33,60.49) 73.65,60.49 73.92,60.75 73.92,62.85 73.61,63.16 v4(72.85,63.16) 72.35,63.16 72.25,63.05 72.25,62.32 71.26,61.34 70.49,61.34 v1(70.36,61.48)
  BOTTOM w0.31: CON3800.31 v2(86.89,92.67)
SLP_S0IX#_R: length 30.4
  L4-SIG w0.102: v3(73.28,59.34) 73.89,59.96 73.89,62.7 74.21,63.02 74.21,63.78 73.78,64.21 73.78,64.41 73.13,65.06 73.13,67.5 73.13,67.51 73.13,68.91 72.82,69.22 72.82,72.63 71.79,73.66 71.34,73.66 71.11,73.88 71.11,74.2 71.73,74.82 74.35,74.82 75.01,75.47 v3(75.14,75.47)
  L6-GND w0.102: v3(73.28,59.34) 72.92,59.34 v4(72.87,59.29) ; v1(75.06,75.11) 75.14,75.2 v3(75.14,75.47)
  L7-SIG w0.102: v1(72.87,61.99) 73.54,61.32 v1(73.54,61.14) 72.72,60.32 72.72,59.45 v4(72.87,59.29)
  BOTTOM w0.102: U3001.7 72.16,73.8 72.31,73.95 73.44,73.95 73.53,74.03 74.93,74.03 75.02,74.12 75.02,75.07 v1(75.06,75.11)
SLP_S3#: length 181.4
  L4-SIG w0.109: v3(74.4,35.14) 74.4,34.33 73,32.92 73,31.12 73.82,30.3 73.82,27.43 73.19,26.8 71.66,26.8 68.92,24.06 68.59,24.06 68.01,23.48 63.5,23.48 61.89,21.88 59.44,21.88 58.16,20.6 55.47,20.6 55.25,20.82 v3(54.39,20.82) ; v3(80.78,73.14) 80.78,71.9 79.41,70.52 79.41,69.57 80.21,68.77 81.63,68.77 85.55,64.85 85.55,59.66 86.28,58.92 86.28,58.24 86.95,57.57 86.95,40.81 85.45,39.3 v3(85.45,39.25) ; v3(76.56,95.17) 76.56,97.22 v3(76.83,97.48)
  L5-SIG w0.109: v3(85.45,39.25) 85.07,38.87 81.32,38.87 77.05,34.6 74.94,34.6 v3(74.4,35.14) 74.09,35.44 73.13,35.44 72.6,35.97 70.56,35.97 70.23,36.3 61.59,36.3 61.43,36.14 59.93,36.14 v6(59.92,36.15) ; v3(76.83,97.48) 77.22,97.09 78.05,97.09 78.28,96.86 78.28,81.78 79.71,80.35 79.71,74.91 80.78,73.84 v3(80.78,73.14) ; v3(73.97,73.15) 73.97,73.87 74.02,73.92 74.19,74.1 74.19,74.66 74.62,75.09 75.97,75.09 76.28,75.4 76.28,77.52 76.36,77.6 76.36,79.21 76.17,79.4 76.17,87.31 75.43,88.05 75.43,90.06 76.56,91.18 v3(76.56,95.17)
  L6-GND w0.102: v4(77.07,97.74) 77.07,97.73 v3(76.83,97.48) ; v4(73.67,73.44) 73.68,73.44 v3(73.97,73.15) ; v1(54.91,20.82) v3(54.39,20.82)
  L7-SIG w0.06: 64.95,69.36 61.04,69.36 60.83,69.14 60.58,69.14 v6(60.48,69.05)
  L7-SIG w0.084: v1(87.65,93.47) 87.25,93.86 84.44,93.86 80.73,97.57 77.24,97.57 v4(77.07,97.74) ; v4(73.67,73.44) 73.62,73.39 72.67,73.39 72.29,73.01 72.29,72.68 70.24,70.62 69.58,70.62 69.12,70.16 68.14,70.16 68.05,70.07 66.69,70.07 v1(66.19,70.57) 66.02,70.4 66.02,69.74 65.64,69.36 64.95,69.36
SLP_S4#: length 145.1
  L4-SIG w0.109: v3(78.55,76.8) 78.26,76.51 78.26,76.06 77.71,75.51 77.71,75 78.75,73.95 78.75,73.35 79.82,72.27 79.82,71.83 78.77,70.78 78.77,69.31 80.13,67.95 81.36,67.95 84.91,64.4 84.91,58.65 86.32,57.24 86.32,47.67 84.37,45.72 84.37,38.41 84.88,37.91 v3(84.89,37.91)
  L5-SIG w0.06: 62.33,35.06 62.23,35.16 60.43,35.16 60.06,35.53 59.72,35.53 v6(59.52,35.34)
  L5-SIG w0.109: v3(77.7,96.56) 78.07,96.19 78.07,80.67 78.93,79.81 78.93,77.18 v3(78.55,76.8) 78.55,76.02 78.9,75.67 78.9,73.23 77.66,71.99 77.66,66.55 76.83,65.73 73.04,65.73 72.64,65.32 69.12,65.32 68.3,66.14 67.81,66.14 67.52,65.85 63.88,65.85 63.18,66.55 62.64,66.55 62.18,67.01 61.19,67.01 60.3,67.9 59.56,67.9 58.99,68.47 v6(58.8,68.47) ; v3(84.89,37.91) 80.96,37.91 77.23,34.18 74.06,34.18 73.31,34.93 66.19,34.93 65.25,35.88 64.13,35.88 63.31,35.06 62.33,35.06
  L6-GND w0.102: v4(78.39,77.12) 78.55,76.96 v3(78.55,76.8) ; v4(77.98,96.83) v3(77.7,96.56)
  L7-SIG w0.084: v4(78.39,77.12) 78.39,76.67 78.21,76.49 77.52,76.49 76.66,77.35 76.66,78.78 v1(76.91,79.03) 75.97,79.03 75.49,78.55 v1(75.49,77.81) ; v4(77.98,96.83) 78.49,97.34 80.62,97.34 84.3,93.66 87.05,93.66 v1(87.65,93.07)
SLP_S4#_R: length 28.1
  L5-SIG w0.109: v3(76.92,66.37) 76.49,65.94 72.95,65.94 72.72,65.71 v3(71.94,65.71)
  L6-GND w0.102: v4(71.96,65.35) 71.94,65.37 v3(71.94,65.71) ; v3(76.92,66.37) 77.11,66.18 v4(77.25,66.18)
  L7-SIG w0.084: v1(78.74,72.5) 78.74,70.59 79.68,69.66 79.68,68.14 77.72,66.18 v4(77.25,66.18) ; v1(75.01,79.38) 75.01,77.87 75.23,77.64 75.23,75.37 75.41,75.19 76.07,75.19 76.56,74.71 76.56,74.3 76.94,73.92 77.52,73.92 v1(77.83,74.23) ; v4(71.96,65.35) 71.76,65.16 v1(71.76,64.18) v1(71.76,62.85)
  BOTTOM w0.31: v1(75.01,79.38) 74.84,79.22 Q3004.3 ; v1(78.74,72.5) 78.64,72.5 77.83,73.32 v1(77.83,74.23)
SOC_MIPI_BLEN: length 3.6
  L2-SIG w0.06: v7(62.38,71.05) 62.41,71.05 v8(62.66,71.31)
  L3-GND w0.06: v3(62.23,71.24) 62.29,71.31 v8(62.66,71.31)
  L6-GND w0.102: v3(62.23,71.24) 61.9,71.24 v5(61.85,71.29)
  L7-SIG w0.06: v5(61.85,71.29) 61.6,71.54 60.44,71.54 60.3,71.4 60.11,71.4 59.97,71.54 v6(59.67,71.54)
SOC_MIPI_VDDEN: length 1
  L3-GND w0.06: v8(59.06,71.59) 59.16,71.69 v3(59.56,71.69)
  L6-GND w0.102: v6(59.13,71.55) 59.27,71.69 v3(59.56,71.69)
SOC_PWRBTN#: length 53.6
  L4-SIG w0.109: v3(65.91,67.13) 65.91,66.49 66.53,65.88 66.53,65.62 67.52,64.63 67.52,63.76 68.76,62.52 68.76,57.24 65,53.48 65,51.79 63.77,50.56 57.19,50.56 57.14,50.51 56.15,49.52 54.6,49.52 54.04,48.96 v3(51.95,48.96)
  L5-SIG w0.06: 62.46,68.31 62.09,68.68 60.93,68.68 60.74,68.87 v6(60.74,69.35)
  L5-SIG w0.107: 64.95,67.59 63.74,67.59 63.02,68.31 62.46,68.31
  L5-SIG w0.109: v3(65.91,67.13) 65.46,67.59 64.95,67.59
  L6-GND w0.06: v6(57.12,36.54) 57.12,36.64 56.59,37.17 56.59,37.76 55.81,38.53 55.81,38.59
  L6-GND w0.102: v3(51.95,48.96) 51.95,48.95 v4(51.95,48.56) ; v1(65.68,66.83) 65.68,66.9 v3(65.91,67.13) ; 55.81,38.59 55.81,38.75 54.91,39.65 54.91,39.71 54.91,40.4 54.45,40.86 54.45,44.04 53.47,45.02 v4(53.47,45.42)
  L7-SIG w0.084: v4(53.47,45.42) 53.47,47.05 v4(51.95,48.56)
SOC_RTEST#: length 79.1
  L4-SIG w0.109: v3(45.8,52.96) 54.05,52.96 54.36,52.65 61.65,52.65 62.59,53.59 62.59,53.68 66.36,57.45 66.36,59.22 63.93,61.65 63.93,63.72 v3(63.43,64.22)
  L5-SIG w0.109: v3(80.22,66.62) 81,67.4 81.37,67.4 87.2,73.22 87.2,86.17 88.21,87.18 v3(88.21,88.3) ; v3(76.98,64.48) 73.83,64.48 73.54,64.77 73.1,64.77 72.9,64.58 70.12,64.58 69.38,63.83 66.39,63.83 66.38,63.84 66.13,64.07 64.75,64.07 64.6,64.22 v3(63.43,64.22)
  L6-GND w0.102: v1(45.43,53.12) 45.63,53.12 v3(45.8,52.96) ; v4(77.26,64.77) 76.98,64.49 v3(76.98,64.48) ; v1(87.77,88.27) 88.18,88.27 v3(88.21,88.3) ; v3(63.43,64.22) 63.21,64.22 v5(63.09,64.33) ; v4(79.87,66.62) v3(80.22,66.62)
  L7-SIG w0.06: v6(60.5,65.65) 60.5,65.65 61.07,65.65 61.13,65.59 61.87,65.59 62.01,65.45
  L7-SIG w0.084: v4(79.87,66.62) 79.42,66.18 79.15,66.18 78.77,65.8 v1(78.45,65.8) v1(78.45,65.06) 78.16,64.77 v4(77.26,64.77) ; v5(63.09,64.33) 63.09,64.37 62.01,65.45
SOC_SPI_CS#: length 38.6
  L5-SIG w0.109: v3(62.48,70.46) 62.69,70.25 62.91,70.25 64.24,68.92 68.25,68.92 68.41,68.76 70.34,68.76 70.71,69.12 71.68,69.12 72.67,70.11 72.67,71.35 73.44,72.12 74.33,72.12 77.22,75.01 77.22,77.13 77.99,77.91 77.99,79.11 77.11,79.99 77.11,88.18 v3(76.58,88.71)
  L6-GND w0.102: v1(76.04,88.24) 76.12,88.24 v3(76.58,88.71) ; v5(62.12,70.49) 62.16,70.46 v3(62.48,70.46)
  L7-SIG w0.06: v6(60.82,70.48) 61.29,70.48 61.38,70.39 62.02,70.39 v5(62.12,70.49)
  L7-SIG w0.084: v1(76.04,88.24) 74.46,89.82 v1(73.91,89.82)
SOC_SPI_MISO: length 43.3
  L7-SIG w0.06: v6(58.8,70.74) 59.04,70.74 59.24,70.53 60.07,70.53 60.13,70.59 60.3,70.59 60.62,70.27 62.21,70.27 62.41,70.47
  L7-SIG w0.084: 62.41,70.47 62.99,71.06 62.99,71.06 65.65,71.06 65.83,71.24 66.63,71.24 66.99,70.88 67.27,70.88 67.38,70.99 70.08,70.99 71.92,72.83 71.92,73.23 72.47,73.78 73.2,73.78 74.17,74.74 74.17,75.42 74.74,76 74.74,77.44 74.47,77.71 74.47,78.52 74.26,78.73 74.26,80.53 73.76,81.04 73.76,83.78 74.2,84.22 74.2,86.44 73.99,86.65 73.99,87.22 74.56,87.79 74.77,87.79 74.86,87.71 75.19,87.71 75.42,87.94 75.42,88.27 74.21,89.48 73.36,89.48 73.13,89.72 73.13,90.05 72.5,90.68 72.5,91.1 v1(72.77,91.37) 73.05,91.09 73.95,91.09 75.96,89.09 76.19,89.09 v1(76.54,88.74)
SOC_SPI_MOSI: length 49.7
  L4-SIG w0.109: v3(76.45,89.82) 77.9,91.27 79.89,91.27 80.27,91.65 80.27,92.9 80.95,93.58 v3(80.95,94.19)
  L5-SIG w0.109: v3(76.45,89.82) 75.71,89.08 75.71,88.19 76.38,87.52 76.38,79.48 76.57,79.3 76.57,77.51 76.49,77.44 76.49,75.31 74.96,73.78 v3(74.5,73.78)
  L6-GND w0.102: v3(74.5,73.78) v4(74.15,73.78) ; v1(80.65,94.42) 80.87,94.19 v3(80.95,94.19)
  L7-SIG w0.06: 62.5,70.29 62.4,70.29 62.26,70.15 60.45,70.15 v6(60.22,70.39)
  L7-SIG w0.084: 62.5,70.29 63.08,70.87 65.73,70.87 65.89,71.04 66.52,71.04 66.85,70.7 68.66,70.7 68.9,70.45 69.15,70.45 69.51,70.81 70.16,70.81 72.11,72.75 72.11,73.09 72.61,73.59 73.43,73.59 73.62,73.78 v4(74.15,73.78) ; v1(77.54,88.74) 77.7,88.9 77.7,90.06 78.42,90.78 78.42,92.1 78.8,92.49 78.8,93.54 79.48,94.22 80.44,94.22 v1(80.65,94.42)
SOC_TOUCH_EN: length 65.1
  L4-SIG w0.109: v3(48.01,12.99) 46.56,12.99 43.46,16.09 43.46,17.66 40.87,20.25 40.82,20.25 40.81,20.26 39.39,20.26 37.23,22.42 37.23,32.71 36.73,33.22 36.73,38.25 33.94,41.04 33.94,42.15 33.86,42.23 33.86,50.25 33.48,50.63 33.48,51.5 33.83,51.85 v3(33.83,52.33)
  L6-GND w0.102: v3(33.83,52.33) v4(33.83,52.71) ; v3(48.01,12.99) 48.26,12.74 v1(48.39,12.74)
  L7-SIG w0.084: v1(39.96,62.95) 39.06,62.95 38.41,62.29 38.41,58.37 39.4,57.38 39.4,56.73 38.43,55.76 38.43,54.57 37.47,53.6 35.08,53.6 34.19,52.71 v4(33.83,52.71)
  BOTTOM w0.31: R2542.1 40.82,62.95 v1(39.96,62.95)
SOC_TOUCH_EN_R: length 8.3
  L7-SIG w0.06: v6(48.63,66.75) 48.63,66.52 48.26,66.15 48.24,66.15 48.12,66.03 48.12,65.99 47.69,65.56 47.13,65 47.08,65 46.84,64.76 46.84,64.71 46.72,64.59 46.71,64.59 46.41,64.29 46.41,64.27 45.77,63.64 45.75,63.64 45.45,63.34 44.25,63.34
  L7-SIG w0.084: v1(42.06,63.1) 42.3,63.34 44.25,63.34
SOC_USB_OC#: length 37.8
  L4-SIG w0.107: v3(60.07,69.19) 60.07,68.84 62.41,66.49 62.65,66.49 64.95,64.19
  L4-SIG w0.109: 64.95,64.19 65.39,63.75 65.39,62.52 66.93,60.98 66.93,57.31 63.79,54.17 63.79,53.28 v3(63.17,52.66)
  L5-SIG w0.109: v3(63.17,52.66) 64.34,51.5 69.86,51.5 70.11,51.75 70.11,52.4 70.76,53.05 76.3,53.05 76.56,52.79 v3(77.41,52.79)
  L6-GND w0.102: v1(77.41,53.25) v3(77.41,52.79) ; v6(59.98,69.61) 60.07,69.52 v3(60.07,69.19)
SOC_VIBRATOR_PWM: length 31.3
  L5-SIG w0.06: v6(48.32,72.72) 48.32,72.15 48.54,71.92 48.54,71.36
  L5-SIG w0.107: 48.54,71.36 49.12,70.77 49.12,67.98 49.44,67.66 49.44,66.67 48.78,66.01 48.78,63.88 47.75,62.85 47.75,62.49 47.63,62.37
  L5-SIG w0.109: v3(43.4,57.93) 43.74,57.59 46.05,57.59 46.74,58.27 46.74,58.8 47.63,59.69 47.63,62.37
  L6-GND w0.102: v3(43.4,57.93) 43.04,57.93 v4(43.02,57.96)
  L7-SIG w0.084: v1(38.14,49.59) 38.14,49.69 39.11,50.65 39.11,52.65 40.27,53.82 41.48,53.82 41.82,54.16 41.82,55.82 42.76,56.76 42.76,57.7 v4(43.02,57.96)
SOC_VOLUMEDOWN#: length 52.1
  L5-SIG w0.109: v3(37.14,53.88) 36.84,54.18 35.4,54.18 35.13,53.9 34.99,53.77 34.27,53.77 33.92,54.12 33.92,54.12 33.67,54.37 23.17,54.37 23.16,54.37 v3(22.91,54.37)
  L6-GND w0.102: v3(22.91,54.37) 22.69,54.59 v4(22.59,54.59) ; v4(37.43,54.21) 37.14,53.92 v3(37.14,53.88)
  L7-SIG w0.06: 44.25,64.97 45.2,64.97 45.55,65.32 v6(46.03,65.32)
  L7-SIG w0.084: 44.25,64.97 41.57,64.97 41.34,64.74 41.12,64.74 40.49,64.1 40,64.1 39.39,63.49 37.96,63.49 37.82,63.34 37.82,59.19 37.75,59.12 37.69,59.06 37.69,54.65 37.43,54.38 v4(37.43,54.21) ; v1(8.59,59.98) 10.2,61.6 16.58,61.6 21.06,57.11 21.06,56.58 22.25,55.38 22.25,54.93 v4(22.59,54.59)
SOC_VOLUMEUP#: length 52.8
  L5-SIG w0.109: v3(37.75,53.86) 37.21,54.39 35.32,54.39 34.91,53.98 34.36,53.98 34.13,54.21 34.13,54.21 33.76,54.58 23.62,54.58 v3(23.31,54.89)
  L6-GND w0.102: v3(37.75,53.86) 37.75,53.98 37.77,54.01 v4(37.77,54.31) ; v4(23.29,55.25) 23.29,55.24 23.29,54.91 v3(23.31,54.89)
  L7-SIG w0.06: v6(46.67,65.36) 46.58,65.28 46.28,65.28 46.08,65.08 46.02,65.08 45.72,64.78 45.17,64.78
  L7-SIG w0.084: v4(37.77,54.31) 37.89,54.43 37.89,59 37.94,59.05 38,59.11 38,63.21 38.1,63.3 39.46,63.3 40.07,63.92 40.56,63.92 41.2,64.55 41.42,64.55 41.65,64.78 45.17,64.78 ; v1(8.59,62.37) 8.86,62.64 9.45,62.64 9.75,62.34 16.59,62.34 21.62,57.32 21.62,56.7 23.07,55.25 v4(23.29,55.25)
SPEAKER_OUT_LN: length 72.7
  L4-SIG w0.508: v3(36.73,8.04) 36.73,8.1 33.29,11.54 31.4,11.54 30.94,12 27.87,12 27.74,11.87 27.29,11.87 27.18,11.85 26.77,11.85 26.08,12.55 26.08,13.81 22.25,17.63 22.25,44.84 25.96,48.55 25.96,52.13 28.09,54.26 31.12,54.26 33.1,56.25 33.1,62.53 32.26,63.36 v2(32.03,63.36)
  L6-GND w0.508: v1(36.73,7.25) v3(36.73,8.04)
SPEAKER_OUT_LN_CON: length 2.6
  L7-SIG w0.508: v1(35.57,4.31) 35.57,4.31 36.65,5.39 v1(36.65,5.67) 36.73,5.75 v1(36.73,6.39)
SPEAKER_OUT_LP: length 71.2
  L4-SIG w0.508: v3(35.87,7.88) 32.97,10.78 31.08,10.78 30.63,11.24 28.19,11.24 28.06,11.11 27.36,11.11 27.26,11.09 26.45,11.09 25.31,12.23 25.31,13.49 21.49,17.32 21.49,45.16 25.18,48.85 25.18,52.43 27.79,55.04 30.8,55.04 32.33,56.58 32.33,62.06 v2(32.03,62.36)
  L6-GND w0.508: v1(35.89,7.25) 35.87,7.27 v3(35.87,7.88)
SPEAKER_OUT_LP_CON: length 2.6
  L7-SIG w0.508: v1(35.99,6.39) v1(35.99,5.67) 34.77,4.45 v1(34.77,4.31)
SPEAKER_OUT_RN: length 73.4
  L4-SIG w0.508: v3(33.62,8.07) 33.62,8.34 33.16,8.8 32.67,8.8 31.45,10.02 30.77,10.02 30.31,10.47 28.5,10.47 28.37,10.35 27.44,10.35 27.33,10.33 27.29,10.33 26.9,9.94 25.9,9.94 24.55,11.28 24.55,13.18 20.73,17 20.73,45.47 24.42,49.16 24.42,52.75 27.47,55.8 30.48,55.8 31.57,56.89 31.57,61.72 31.08,62.22 v2(31.08,63.83)
  L6-GND w0.508: v1(33.62,7.26) v3(33.62,8.07)
  BOTTOM w0.508: v1(33.62,7.26) 34.34,7.26 T1104.1
SPEAKER_OUT_RN_CON: length 2.2
  L7-SIG w0.508: v1(33.62,6.39) 33.6,6.38 v1(33.6,5.68) 33.97,5.32 v1(33.97,4.31)
SPEAKER_OUT_RP: length 74.8
  L4-SIG w0.508: v2(31.99,64.62) 31.99,64.62 30.8,64.62 30.76,64.59 30.32,64.15 30.32,61.9 30.81,61.41 30.81,57.21 30.17,56.57 27.16,56.57 23.66,53.07 23.66,49.48 19.73,45.55 19.73,16.9 23.79,12.84 23.79,10.97 25.58,9.18 27.22,9.18 27.62,9.59 28.69,9.59 28.82,9.71 30,9.71 30.45,9.26 31.09,9.26 32.32,8.02 v3(32.86,8.02)
  L6-GND w0.508: v1(32.86,7.26) v3(32.86,8.02)
SPEAKER_OUT_RP_CON: length 2.2
  L7-SIG w0.508: v1(32.86,6.39) 32.87,6.38 v1(32.87,5.68) 32.87,4.99 33.17,4.69 v1(33.17,4.31)
SPI_CS#: length 117.1
  L4-SIG w0.109: v2(79.34,104.86) 79.63,104.57 79.63,93.74 79.88,93.49 v3(79.88,91.81) 79.75,91.68 77.57,91.68 76.68,90.79 v3(74.27,90.79)
  L6-GND w0.102: v3(79.88,91.81) 79.93,91.76 79.93,91.3 v4(79.96,91.27) ; v1(73.88,90.79) v3(74.27,90.79)
  L7-SIG w0.084: v2(79.34,104.86) 79.12,105.07 78.94,105.07 78.66,105.36 33.4,105.36 33.24,105.21 30.92,105.21 28.51,102.8 27.7,102.8 26.24,101.34 21.12,101.34 18.21,98.43 18.21,89.09 14.85,85.73 14.85,80.41 14.21,79.78 14.21,75.29 14.12,75.19 v1(14.12,74.62) ; v1(73.41,89.82) 73.41,90.15 v1(72.77,90.79) v1(73.88,90.79) ; v4(79.96,91.27) 79.96,90.16 79.17,89.38 79.17,88.38 78.36,87.57 78.36,87.57 v1(78.05,87.26)
  vias: v9(13.19,75.31)
SPI_CS#_CON:
  vias: v9(14.92,75.44)
SPI_HOLD#: length 115.6
  L4-SIG w0.102: v3(81.71,93.02) 82.17,93.48 82.17,93.96 80.93,95.21 80.93,105.24 79.96,106.21 79.15,106.21 v3(77.88,104.94)
  L6-GND w0.102: v3(81.71,93.02) 81.71,92.9 v1(81.51,92.69) ; v4(77.47,104.94) v3(77.88,104.94)
  L7-SIG w0.102: v4(77.47,104.94) 73.38,104.94 72.67,104.23 62.08,104.23 61.57,104.73 30.76,104.73 28.6,102.57 27.84,102.57 26.37,101.1 21.16,101.1 18.42,98.36 18.42,88.99 15.05,85.62 15.05,80.33 14.45,79.74 14.45,74.25 14.61,74.1 14.61,73.47 14.22,73.09 13.08,73.09 11.33,74.84 v1(10.87,74.84)
  BOTTOM w0.102: CON3301.10 12.12,74.47 11.75,74.85 v9(11.51,74.85) 10.88,74.85 v1(10.87,74.84) ; U3302.7 80.39,92.06 R3338.2 81.13,92.31 v1(81.51,92.69)
SPI_MISO: length 122.4
  L4-SIG w0.109: v3(73.03,92.14) 77.32,92.14 79.42,94.23 79.42,104.16 78.93,104.65 78.93,105.34 v2(79.28,105.7)
  L6-GND w0.102: v1(72.77,91.88) v3(73.03,92.14)
  L7-SIG w0.084: v1(73.88,92.06) 73.53,92.06 73.36,91.88 v1(72.77,91.88) 73.25,91.4 74.24,91.4 76.05,89.6 v1(77.14,89.6) ; v2(79.28,105.7) 79.13,105.85 30.88,105.85 28.22,103.19 27.57,103.19 26.09,101.71 20.73,101.71 17.12,98.1 17.12,88.63 14.47,85.98 14.47,84.76 13.84,84.13 13.84,75.44 13.66,75.26 13.66,74.36 14.12,73.9 v1(14.12,73.64)
  BOTTOM w0.31: v9(77.59,106.17) 78.06,105.7 v2(79.28,105.7) ; v1(77.14,89.6) 77.76,89.6 78.45,88.91 78.45,87.93 78.26,87.74 U3301.C1
SPI_MOSI: length 113.9
  L4-SIG w0.109: v3(80.11,95.44) 80.11,104.69 v2(79.94,104.86)
  L6-GND w0.102: v3(80.11,95.44) 80.62,94.93 v1(80.65,94.93)
  L7-SIG w0.084: v1(13.12,73.64) 13.4,73.36 14.23,73.36 14.39,73.53 14.39,73.95 13.85,74.5 13.85,75.18 14.03,75.37 14.03,83.96 14.66,84.59 14.66,85.91 17.37,88.62 17.37,97.95 20.95,101.53 26.16,101.53 27.65,103.01 28.3,103.01 30.84,105.55 v1(31.74,105.55) 78.73,105.55 79.02,105.26 79.55,105.26 v2(79.94,104.86) ; v1(79.54,94.6) 79.87,94.93 v1(80.65,94.93) 80.98,94.59 80.98,93.7 79.09,91.8 79.09,90.5 78.39,89.79 78.39,88.58 v1(78.05,88.25)
  BOTTOM w0.31: v1(31.74,105.55) v9(31.74,106.34)
SRT_CRST#: length 54.4
  L5-SIG w0.107: v6(59.61,65.93) 59.84,65.93 61.41,64.36 62.4,64.36 62.88,63.88 64.64,63.88 64.95,63.57
  L5-SIG w0.109: 64.95,63.57 65.94,63.57 66.17,63.35 66.18,63.35 66.18,63.34 69.58,63.34 70.23,63.99 77.28,63.99 v3(77.47,64.18) 78.72,65.43 78.72,66.78 80.49,68.56 80.89,68.56 85.98,73.64 85.98,87.23 85.39,87.82 85.39,89.07 85.78,89.45 85.78,89.73 86.71,90.67 87.26,90.67 v3(88.06,89.87)
  L6-GND w0.102: v3(77.47,64.18) 77.65,64.01 77.65,63.97 v4(77.71,63.92) ; v1(87.65,89.87) v3(88.06,89.87)
  L7-SIG w0.084: v1(78.45,64.32) v1(78.45,63.59) 78.05,63.98 77.77,63.98 v4(77.71,63.92)
STAT: length 85.6
  L4-SIG w0.102: v3(73.84,58.58) 72.95,57.7 72.95,51.41 68.97,47.43 48.13,47.43 47.07,48.5 v3(43.87,48.5) ; v3(33.43,21.98) 33.43,28.38 33.73,28.69 33.73,37.32 34.42,38.01 34.42,38.57 29.72,43.27 29.72,47.56 v3(29.03,48.24)
  L5-SIG w0.102: v3(29.03,48.24) 29.69,48.9 35.51,48.9 37.18,47.23 42.6,47.23 v3(43.87,48.5)
  L6-GND w0.102: v3(33.43,21.98) 33.43,21.87 v1(33.72,21.58) ; v3(73.84,58.58) 74.03,58.78 v1(74.19,58.78)
  BOTTOM w0.102: v1(33.72,21.58) 33.72,21.15 33.73,21.14 R8811.1
SUS_PWRDOWNACK: length 77.9
  L4-SIG w0.109: v3(83.52,54.75) 83.52,55.37 81.43,57.45 81.43,59.07 79.74,60.76 79.74,62.86 80.25,63.37 80.25,64.84 79.62,65.47 79.62,67.56 77.87,69.31 77.87,72.24 v3(77.28,72.83)
  L5-SIG w0.06: v3(61.9,68.35) 61.72,68.53 60.91,68.53 60.4,69.04 60.4,69.31 60.14,69.57 v6(59.41,69.57)
  L6-GND w0.06: v3(61.9,68.35) 62.18,68.63 v5(62.19,68.63) ; v6(59.92,36.54) 60.14,36.76 60.14,37.47 61.14,38.47 61.14,38.59
  L6-GND w0.102: v4(76.99,73.03) 77.19,72.83 v3(77.28,72.83) ; v4(83.51,54.19) 83.51,54.74 v3(83.52,54.75) ; 61.14,38.59 61.76,39.21 61.76,42.42 62.56,43.23 62.56,44.54 62.84,44.82 v4(62.84,44.94)
  L7-SIG w0.084: v4(76.99,73.03) 76.23,73.03 75.16,71.96 75.16,71.78 74.3,70.92 73.22,70.92 72.9,70.6 72.26,70.6 71.71,70.04 71.21,70.04 70.82,69.65 70.82,69.28 70.6,69.05 69.84,69.05 69.53,69.37 68.41,69.37 67.35,68.31 67.12,68.31 66.98,68.45 65.76,68.45 64.88,67.57 v6(64.77,67.57) 64.57,67.78 64.08,67.78 63.24,68.63 v5(62.19,68.63) ; v4(62.84,44.94) 67.23,44.94 67.55,45.26 70.6,45.26 70.69,45.35 71.7,45.35 73.16,46.8 75.96,46.8 83.34,54.19 v4(83.51,54.19)
SVID_ALERT_PMIC: length 22.7
  L6-GND w0.06: 57.66,37.24 57.73,37.17 57.73,36.33 v6(57.92,36.14)
  L6-GND w0.102: 57.66,37.24 57.66,37.93 57.01,38.57 57.01,44.22 55.52,45.71 v4(55.09,45.71)
  L7-SIG w0.084: v4(55.09,45.71) 55.11,45.71 55.35,45.96 55.35,47.31 51.44,51.23 47.62,51.23 47.38,50.99 v1(47.11,50.99)
SVID_CLK_PMIC: length 22.7
  L6-GND w0.06: 57.32,37.35 57.32,36.74 v6(57.52,36.54)
  L6-GND w0.102: 57.32,37.35 57.32,37.88 56.66,38.54 56.66,44.07 55.37,45.35 v4(55.09,45.35)
  L7-SIG w0.084: v4(55.09,45.35) 55.23,45.35 55.72,45.84 55.72,47.49 51.64,51.57 v1(47.23,51.57)
SVID_DIO_PMIC: length 21.9
  L6-GND w0.06: v6(57.93,36.54) 58.14,36.74 58.14,37.02 58.13,37.03 58.13,37.43
  L6-GND w0.102: 58.13,37.43 58.13,37.76 57.33,38.57 57.33,44.3 55.5,46.12 v4(55.08,46.12)
  L7-SIG w0.084: v1(47.11,50.43) 47.28,50.43 47.75,50.9 51.26,50.9 55.08,47.08 v4(55.08,46.12)
SYSTHERM_0: length 113
  L2-SIG w0.102: v8(83.69,64.61) 83.69,55 81.23,52.54 81.23,48.93 84.89,45.27 84.89,37.32 v8(84.81,37.24)
  L3-GND w0.102: v8(84.81,37.24) 85.06,37.24 v3(85.31,37.49) ; v3(83.69,65.05) 83.69,64.61 v8(83.69,64.61)
  L5-SIG w0.06: 62.33,33.1 61.07,34.36 60.35,34.36 60.12,34.58 60,34.7 59.73,34.7 v6(59.52,34.91)
  L5-SIG w0.102: v3(77.17,32.27) 78.88,33.98 81.61,33.98 82.82,35.19 83.01,35.19 v3(85.31,37.49) ; 62.33,33.1 62.78,32.65 67.89,32.65 68.45,33.21 73.67,33.21 74.09,32.78 74.09,31.94 74.55,31.48 75.62,31.48 v3(75.72,31.58)
  L6-GND w0.102: v3(77.17,32.27) 76.96,32.06 v1(76.78,32.06) ; v4(83.69,65.61) v3(83.69,65.05) ; v4(76.05,31.79) 75.85,31.58 v3(75.72,31.58)
  L7-SIG w0.102: v4(76.05,31.79) 76.43,31.79 v1(76.84,31.38) ; v1(87.81,108.01) 87.81,105.98 90.18,103.62 90.18,102.38 90.85,101.71 90.85,93.68 89.28,92.11 89.28,86.78 86.12,83.62 84.78,83.62 84.04,82.89 84.04,65.96 v4(83.69,65.61)
  BOTTOM w0.102: v1(76.84,31.38) 76.84,31.71 76.78,31.76 v1(76.78,32.06) ; R8323.2 87.46,107.73 v9(87.46,105.7)
SYSTHERM_1: length 94.5
  L2-SIG w0.102: v8(40.26,3.34) 71.44,3.34 84.62,16.53 v8(84.62,25)
  L3-GND w0.102: v3(40,3.07) 40.26,3.33 v8(40.26,3.34) ; v8(84.62,25) v3(84.62,25.36)
  L5-SIG w0.06: 62.33,34.5 61.75,34.5 61.51,34.74 60.55,34.74 59.97,35.32 v6(59.94,35.32)
  L5-SIG w0.102: 62.33,34.5 62.6,34.5 63.85,33.26 66.89,33.26 67.55,33.92 73.82,33.92 74.7,33.04 74.7,32.45 v3(74.88,32.27)
  L6-GND w0.102: v3(40,3.07) v1(39.73,2.8) ; v3(74.88,32.27) 74.7,32.09 v1(74.47,32.09) ; v3(84.62,25.36) v4(84.62,25.71)
  L7-SIG w0.102: v4(84.62,25.71) 84.62,26.5 77.96,33.16 76.09,33.16 75.65,32.72 75.65,32.03 75.31,31.69 74.07,31.69 v1(73.74,31.35)
  BOTTOM w0.102: v1(74.47,32.09) 74.45,32.12 C8345.2 73.71,31.76 73.74,31.73 v1(73.74,31.35)
SYSTHERM_2: length 81.7
  L5-SIG w0.06: 62.33,34.1 61.58,34.1 61.19,34.48 60.4,34.48 59.97,34.91 v6(59.92,34.91)
  L5-SIG w0.102: v3(75.74,32.27) 75.16,31.68 74.64,31.68 74.3,32.03 74.3,32.87 73.75,33.41 67.62,33.41 67.06,32.85 63.68,32.85 62.43,34.1 62.33,34.1
  L6-GND w0.102: v1(75.31,32.09) 75.49,32.27 v3(75.74,32.27)
  L7-SIG w0.102: v1(52.12,59) 51.62,58.5 47.85,58.5 45.91,56.56 45.23,56.56 44.52,55.84 44.52,55.3 45.71,54.1 45.71,53 45.33,52.62 45.29,52.62 44.66,51.99 44.66,50.46 45.06,50.06 49.24,50.06 49.41,49.89 51.67,49.89 54.53,47.03 54.53,45.25 54.77,45.01 59.08,45.01 59.43,44.66 66.51,44.66 68.68,42.49 68.68,33.04 69.1,32.62 69.94,32.62 70.93,31.63 71.75,31.63 73.16,30.21 73.85,30.21 74.22,30.58 74.22,30.97 v1(74.65,31.4)
  BOTTOM w0.102: v1(74.65,31.4) 74.93,31.4 74.96,31.38 R8328.1 v1(75.31,32.09) ; v1(52.12,59) R8327.2
T2_PMIC: length 16.9
  L6-GND w0.06: 62.29,31.23 61.12,32.39 v6(61.12,32.54)
  L6-GND w0.102: 62.29,31.23 63.15,30.37 63.15,26.78 v4(64.03,25.89)
  L7-SIG w0.102: v1(70.63,27.09) 69.93,27.8 68.3,27.8 66.55,26.04 64.69,26.04 64.54,25.89 v4(64.03,25.89)
  BOTTOM w0.102: v1(70.63,27.09) 70.33,27.39 R8509.1 R8510.2
T4_PMIC: length 12.1
  L6-GND w0.06: 55.09,31.89 55.68,32.47 v6(55.92,32.47)
  L6-GND w0.102: 55.09,31.89 53.75,30.54 53.75,30.22 53.32,29.78 v4(53.32,29.47)
  L7-SIG w0.102: v1(49.78,24.49) 49.78,25.25 50.19,25.66 51.13,25.66 52.76,27.29 53.01,27.29 53.32,27.59 v4(53.32,29.47)
  BOTTOM w0.102: v1(49.78,24.49) R8507.2
TA0N: length 17.3
  L5-SIG w0.081: v3(64.64,6.84) 64.78,6.71 64.97,6.71 65.08,6.81 65.08,7.04 64.15,7.96 64.15,10.29 62.3,12.15 62.3,16.6 65.06,19.36 65.69,19.36 v3(65.81,19.49)
  L6-GND w0.102: v3(64.64,6.84) v1(65.19,6.84) ; v1(66.37,19.36) 65.94,19.36 v3(65.81,19.49)
TA0P: length 17.3
  L5-SIG w0.081: v3(64.67,6.23) 64.86,6.42 65.09,6.42 65.36,6.69 65.36,7.19 64.46,8.09 64.46,10.39 62.58,12.26 62.58,16.48 65.18,19.07 65.6,19.07 v3(65.81,18.86)
  L6-GND w0.102: v1(66.37,18.86) v3(65.81,18.86) ; v1(65.19,6.29) 64.77,6.29 64.72,6.23 v3(64.67,6.23)
TB0N: length 14.4
  L5-SIG w0.081: v3(65.81,18.3) 65.12,18.3 63.1,16.29 63.1,12.43 64.95,10.58 64.95,8.47 v3(65.73,7.68)
  L6-GND w0.102: v1(66.37,18.36) 65.88,18.36 v3(65.81,18.3) ; v1(65.19,7.68) v3(65.73,7.68)
TB0P: length 14.4
  L5-SIG w0.081: v3(65.73,8.37) 65.45,8.37 65.23,8.59 65.23,10.7 63.39,12.54 63.39,16.17 65.23,18.01 65.39,18.01 65.44,17.97 65.44,17.65 65.32,17.54 65.32,17.42 65.38,17.37 65.71,17.37 65.81,17.47 v3(65.81,17.69)
  L6-GND w0.102: v3(65.73,8.37) 65.6,8.23 v1(65.19,8.23) ; v3(65.81,17.69) 65.99,17.86 v1(66.37,17.86)
TC0N: length 16.2
  L5-SIG w0.081: v3(66.93,17.1) 66.73,16.91 65.12,16.91 64.19,15.98 64.19,12.75 66.21,10.73 66.21,5.82 65.96,5.57 65.84,5.57 v3(65.69,5.72)
  L6-GND w0.102: v1(66.37,16.86) 66.69,16.86 v3(66.93,17.1) ; v3(65.69,5.72) 65.42,5.72 v1(65.19,5.49)
TC0P: length 16.2
  L5-SIG w0.081: v3(66.98,16.47) 66.83,16.62 65.23,16.62 64.47,15.86 64.47,12.87 66.49,10.85 66.49,5.7 66.08,5.29 65.79,5.29 v3(65.67,5.17)
  L6-GND w0.102: v1(65.19,4.94) 65.44,4.94 v3(65.66,5.17) ; v3(66.98,16.47) 66.47,16.47 v1(66.37,16.36)
TCK0N: length 16.5
  L5-SIG w0.081: v3(65.53,3.79) 65.25,3.79 65.17,3.87 65.17,4.04 65.44,4.3 66.85,4.3 68.55,6.01 68.55,10.97 66.36,13.17 66.36,15.32 v3(65.91,15.76)
  L6-GND w0.102: v3(65.91,15.76) 66.26,15.76 v1(66.37,15.86) ; v1(65.19,3.54) 65.3,3.65 65.4,3.65 v3(65.53,3.79)
TCK0P: length 16.7
  L5-SIG w0.081: v3(65.91,15.12) 65.45,15.12 65.29,14.96 65.29,14.81 65.44,14.66 66,14.66 66.07,14.58 66.07,13.05 68.27,10.85 68.27,6.12 66.73,4.59 65.32,4.59 64.88,4.16 64.88,3.93 v3(64.79,3.83)
  L6-GND w0.102: v3(65.91,15.12) 65.95,15.12 66.18,15.36 v1(66.37,15.36) ; v3(64.79,3.83) 64.92,3.83 v1(65.19,4.09)
TD0N: length 16.1
  L5-SIG w0.081: v3(66.88,13.75) 67.05,13.58 67.05,13.13 69.06,11.12 69.06,5.15 66.83,2.92 65.71,2.92 64.92,2.14 v3(64.74,2.14)
  L6-GND w0.102: v1(66.97,14.26) 66.97,13.84 v3(66.88,13.75) ; v3(64.74,2.14) 64.77,2.17 v1(65.21,2.17)
TD0P: length 16.1
  L5-SIG w0.081: v3(65.67,2.13) 65.67,2.48 65.83,2.64 66.95,2.64 69.34,5.03 69.34,11.24 67.33,13.25 67.33,13.54 v3(67.56,13.77)
  L6-GND w0.102: v1(65.21,2.72) 65.48,2.45 65.48,2.32 v3(65.67,2.13) ; v3(67.56,13.77) 67.47,13.87 v1(67.47,14.26)
THERM_SET: length 6.9
  BOTTOM w0.102: v9(86.03,5.95) 85.5,5.42 84.38,5.42 R2301.1 84.58,4.3 86.28,4.3 86.83,3.75 U2301.1
TOUCH_INT#: length 98.5
  L4-SIG w0.109: v3(77.56,73.31) 78.11,72.77 78.11,69.37 78.6,68.88 79.83,67.65 79.83,66.1 81.56,64.38 81.56,62.54 83.51,60.59 83.51,57.97 83.76,57.72 85.32,56.15 85.32,52.85 83.86,51.38 83.74,51.26 83.74,37.92 85.93,35.72 85.93,31.95 85.01,31.03 85.01,16.16 81.63,12.79 81.63,9.91 v3(81.15,9.43) 81.15,7.19 v3(82.12,6.23)
  L6-GND w0.102: v3(77.56,73.31) 77.32,73.31 v4(77.22,73.42) ; v1(81.83,8.98) 81.61,8.98 v3(81.15,9.43) ; v1(82.12,5.83) v3(82.12,6.23)
  L7-SIG w0.06: v6(59.92,69.02) 59.98,68.96 60.28,68.96 60.39,68.84 60.58,68.84 60.74,69 61.06,69
  L7-SIG w0.084: v4(77.22,73.42) 76.36,73.42 74.97,72.03 74.97,71.89 74.18,71.1 73.13,71.1 72.82,70.8 72.2,70.8 71.63,70.23 71.14,70.23 70.64,69.73 70.64,69.55 70.47,69.39 69.77,69.39 69.6,69.55 68.33,69.55 67.97,69.2 66.94,69.2 66.78,69.04 66.78,68.92 66.5,68.64 65.63,68.64 65.25,68.26 v6(64.82,68.26) v6(64.82,69.02) 64.6,69.02 64.43,68.85 63.88,68.85 63.73,69 61.06,69
  BOTTOM w0.31: v9(81.22,7.23) 81.22,6.73 v1(82.12,5.83)
TOUCH_RESET#_CN_3V3: length 37.9
  L7-SIG w0.084: v1(52.66,3.05) 52.77,2.93 52.77,2.57 53.75,1.59 77.34,1.59 79.33,3.58 81.09,3.58 83.61,6.1 84.48,6.1 85.35,6.96 85.35,8.71 v1(85.61,8.98)
TOUCH_RST#: length 210.5
  L4-SIG w0.109: v2(23.29,78.37) 23.9,77.76 23.9,77.53 26.37,75.07 26.9,75.07 31.09,70.88 31.3,70.88 33.19,68.99 35.77,68.99 38.6,66.16 43.48,66.16 44.03,66.71 v3(44.43,66.71)
  L5-SIG w0.06: v3(44.43,66.71) 44.43,66.79 v5(44.65,67.01)
  L5-SIG w0.109: v3(86.16,5.55) 86.16,6.82 84.95,8.02 76.34,8.02 74.98,6.66 74.98,5.45 70.84,1.31 22.56,1.31 18.02,5.84 18.02,57.94 15.68,60.28 6.4,60.28 2.34,64.34 2.34,68.88 v2(2.9,69.43)
  L6-GND w0.102: v1(86.3,5.04) 86.3,5.41 v3(86.16,5.55)
  L7-SIG w0.084: v1(22.89,72.96) 23.44,72.4 23.44,71.82 23.19,71.56 20.48,71.56 19.77,70.85 16.49,70.85 15.07,69.43 v1(11.79,69.43) v2(2.9,69.43)
  L7-SIG w0.102: v6(46.06,67.09) 45.85,67.09 45.57,66.81 44.86,66.81 v5(44.65,67.01)
  BOTTOM w0.31: v2(23.29,78.37) 22.96,78.37 21.85,77.25 21.85,73.68 21.88,73.64 22.54,72.98 22.86,72.98 v1(22.89,72.96) ; v1(11.79,69.43) v9(12.41,69.43)
TOUCH_SCL_3V3: length 29.4
  L7-SIG w0.084: v1(53.56,5.72) 53.56,4.77 53.59,4.73 53.59,2.75 53.84,2.5 59.31,2.5 61.23,4.42 66.61,4.42 v1(66.75,4.28) 67.11,4.64 78.3,4.64 v1(78.7,5.04)
TOUCH_SDA_3V3: length 27.2
  L7-SIG w0.084: v1(53.26,3.05) 53.26,2.61 53.7,2.16 62.18,2.16 63.3,3.27 66.54,3.27 v1(66.75,3.49) 67.02,3.22 68.16,3.22 69.23,4.28 78.65,4.28 v1(78.73,4.2)
TP_BCU_DIS_A: length 4.5
  L3-GND w0.102: v8(53.47,38.44) v3(53.47,38.82)
  L6-GND w0.06: 55.09,37.63 55.21,37.52 55.21,37.15 55.67,36.69 56,36.69 56.15,36.54 v6(56.32,36.54)
  L6-GND w0.102: 55.09,37.63 54.92,37.8 54.22,37.8 53.47,38.56 v3(53.47,38.82)
TP_BCU_DIS_B: length 7.7
  L3-GND w0.102: v8(54.36,40.55) 54.36,40.78 v3(53.98,41.16)
  L5-SIG w0.06: 55.6,38.59 55.6,38.04 56.25,37.4 56.33,37.32 56.33,36.79 56.96,36.16 v6(57.52,36.16)
  L5-SIG w0.102: v3(53.98,41.16) 54.19,40.95 54.42,40.95 55.6,39.77 55.6,38.59
TP_BCU_DIS_CRIT: length 7.1
  L3-GND w0.102: v3(52.78,39.71) 52.63,39.56 v8(51.99,39.56)
  L6-GND w0.06: 55.09,37.92 55.63,37.39 56.15,37.39 56.92,36.62 56.92,36.34 v6(57.12,36.14)
  L6-GND w0.102: v3(52.78,39.71) 53.12,39.71 53.85,38.98 53.85,38.47 54.31,38.01 55.01,38.01 55.09,37.92
TP_DDRXXXSI3_1P5_OBS: length 0.9
  L3-GND w0.06: v3(56.29,74.81) 56.26,74.78 v8(56.26,74.38)
  L6-GND w0.06: v6(55.84,74.74) 56.23,74.74 v3(56.29,74.81)
TP_DIG_RAM_OBS: length 2.3
  L3-GND w0.06: v8(55.63,66.25) 55.61,66.24 v3(55.61,65.81)
  L6-GND w0.06: v5(55.84,66.2) 55.84,66.04 v3(55.61,65.81)
  L7-SIG w0.06: v5(55.84,66.2) 55.81,66.23 v6(55.81,67.58)
TP_DIGDI3SIO_1P03_OBS: length 0.8
  L3-GND w0.06: v3(50.42,74.58) 50.62,74.58 v8(50.8,74.41)
  L6-GND w0.06: v3(50.42,74.58) 50.27,74.74 v6(50.09,74.74)
TP_RAM_CPU0_OBS: length 0.8
  L3-GND w0.06: v8(53.16,73.42) 53.42,73.42 v3(53.55,73.29)
  L6-GND w0.06: v6(53.85,73.08) 53.65,73.29 v3(53.55,73.29)
TP_ULPI_VBUS_EN: length 3.7
  L3-GND w0.102: v3(62.97,35.49) 62.74,35.72 v8(62.64,35.72)
  L5-SIG w0.06: v6(59.92,35.74) 60.11,35.74 60.55,35.29 62,35.29 62.13,35.42 62.33,35.42
  L5-SIG w0.102: v3(62.97,35.49) 62.89,35.42 62.33,35.42
TP_ULPMC_TEST: length 6
  BOTTOM w0.102: T3802.1 87.17,101.18 87.17,100.49 86.7,100.02 86.7,97.09 86.28,96.67 CON3800.12
TP_VCC_CORE1_VID_OBS: length 0.8
  L3-GND w0.06: v8(54.64,73.34) 54.53,73.24 54.53,73.23 v3(54.31,73.01)
  L6-GND w0.06: v6(54.38,73.36) 54.31,73.3 v3(54.31,73.01)
TP_VCC_CORE2_VID_OBS: length 3.9
  L3-GND w0.06: v8(61.42,72.48) 61.43,72.46 v3(61.43,72.09)
  L6-GND w0.102: v3(61.43,72.09) 61.33,72.2 v5(61.09,72.2)
  L7-SIG w0.06: v5(61.09,72.2) 61,72.29 60.59,72.29 60.25,71.95 58.98,71.95 58.89,72.04 58.4,72.04 v6(58.24,71.87)
TS_CHG: length 10.2
  L7-SIG w0.102: v1(38.81,26.96) v1(38.81,26.22) 38.81,25.77 v1(39.17,25.41) 38.76,25.41 37.87,26.3 36.97,26.3 36.68,26.01 36.68,25.28 36.35,24.95 32.4,24.95 v1(32.12,24.68)
UART3_DEBUG_RXD: length 79.5
  L4-SIG w0.076: 46.73,65.18 46.43,65.49 46.43,66.21 45.88,66.75 v3(45.88,66.97)
  L4-SIG w0.107: v3(54.23,63.13) 53.84,63.13 51.22,65.74 48.13,65.74 47.52,65.14 46.78,65.14 46.73,65.18
  L4-SIG w0.109: v3(78.92,60.91) 79.11,61.1 79.11,67.48 77.45,69.14 77.45,70.34 76.63,71.16 76.63,75.02 77.08,75.47 77.08,75.77 77.64,76.32 77.64,77.25 77.76,77.37 84.43,84.04 84.43,86.9 84.84,87.31 v3(87.11,87.31)
  L5-SIG w0.109: v3(87.11,87.31) 87.51,87.31 87.65,87.45 87.65,88.72 87.92,89 88.66,89 88.95,88.7 88.95,85.46 v3(88.76,85.27) ; v3(54.23,63.13) 54.25,63.13 54.67,62.7 54.67,62.19 55.4,61.46 59.71,61.46 60.59,60.57 62.97,60.57 63.39,60.15 69.72,60.15 70.65,61.08 71.47,61.08 71.56,61.17 77.22,61.17 77.48,60.91 v3(78.92,60.91)
  L6-GND w0.06: v6(46.37,66.7) 46.1,66.97 v3(45.88,66.97)
  L6-GND w0.102: v3(87.11,87.31) 87.49,87.31 v1(87.65,87.47) ; v1(89.19,85.45) 89.01,85.27 v3(88.76,85.27)
