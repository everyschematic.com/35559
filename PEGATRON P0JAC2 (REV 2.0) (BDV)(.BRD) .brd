# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Nets (continued)
N58057057: R9001.2 R9002.1 U9000.12
N58057069: D9001.1 L9000.2 R9006.1 U9000.14
N58057081: C9004.1 D9000.2 L9000.1 Q9000.3
N58057101: C9003.2 Q9000.1 R9000.1 R9005.2 U9000.16
N58057127: C9002.1 R9004.2 U9000.15
N58057155: SR9002.1 U9000.9
N58057163: SR9003.1 U9000.7
N58057187: C9009.1 R9006.2
N58626283: R8312.2 T8304.1
N58759745: C8913.1 R8904.2 U8901.D3
N58759758: C8912.1 R8903.1 R8944.2 U8901.E3
N58983506: R8907.2 U8901.D2
N58989919: JP8900.1 R8906.2
N59743838: C5215.1 R5201.2 U5203.4
N59790830: R5822.2 R5870.1 U5804.A2
N59826746: R5847.1 U5801.20
N59826750: R5842.2 U5801.22
N59826752: T5807.1 U5801.11
N59826757: R5848.2 U5801.9
N59827709: C7001.1 C7003.1 Q7001.3 R7005.2
N59885010: C3007.1 L3003.1 U3001.5
N60244404: L5202.1 U5203.6 U5203.7 U5203.8
N60285321: R1124.1 U1101.2
N60474543: D0905.2 R0913.1
N60485144: C2126.2 R2131.1 R2134.2 U2101.3
N60517541: Q8203.2 R8224.2
N60556074: C1040.1 C1053.2 R1046.2 U1001.10
N60826251: C1008.1 U1001.12
N60826256: C1007.1 U1001.11
N60946431: C8818.1 Q8804.3 R8820.2 R8821.1
N60977672: CON8902.1 CON8902.2 JP8901.2 R8908.1
N60977700: JP8901.1 R8905.2
N61001811: C7002.1 Q7001.1 Q7003.6 R7004.2
N61001912: Q7003.2 R7001.1 R7002.1 R7006.1 R7007.1
N61018294: R5831.2 R5899.2 U5803.4
N61045998: Q7142.6 Q7187.2 R7186.2
N61046001: Q7142.1 Q7142.3 R7132.1
N61046551: Q7142.5 R7151.2 R7152.1 R7177.2
N61060018: Q8100.5 Q8100.6 R8113.2
N61060048: D8101.3 Q8100.2 R8112.1
N61183239: T3010.1 U3001.56
N61655404: Q3004.5 Q3004.6 R3042.1
N61684486: C8116.1 R8126.2 R8128.1 U8102.5
N61684746: R8117.2 R8123.1 U8101.B3
N61684748: R8132.1 R8133.1 U8101.B2
N61684936: C8115.1 R8124.1 R8127.1 U8102.1
N61684944: R8127.2 U8102.3
N61684969: R8125.2 R8126.1 U8102.4
N61766419: C5878.1 R5825.1 R5826.1 R5871.1 U5806.1
N61766442: R5833.1 R5871.2 U5806.2
N61773390: C7359.2 R7359.2 U7311.5
N61773392: R7358.1 U7311.4
N61773489: R7355.2 R7356.2 R7357.1 R7360.2 U7311.3
N61801494: D2003.1 R2020.2 R2021.2 SW2004.2
N61858088: Q8101.5 Q8101.6 Q8102.2 R8130.2
N61858102: Q8101.2 R8118.1 R8119.1
N61932976: Q2650.4 R2685.2 R2692.2
N61933366: R2678.1 U2400.B28
N61933368: R2687.1 U2400.E30
N61961093: D2701.2 R2702.2
N62009177: JP8207.1 R8214.2
N62053578: C2600.1 SP2602.1 X2600.1
N62053849: C2605.1 SP2601.1 X2601.1
N62125634: R2637.1 U2400.BU11
N62127208: J3101.30 T3101.1
N62213582: CON2002.17 R2030.1 R2031.1
N62285848: C7313.1 C7318.1 CON7305.23 CON7305.24 L7304.2 L7305.2
N62321407: R1127.1 U1101.6
N62376398: C8348.1 R8335.2 R8367.2 R8368.1 R8377.2
N62471773: R7374.2 U7321.C2
N62471816: R7370.2 SP7305.2 U7321.A1
N62471852: R7371.2 SP7303.1 U7321.A2
N62573604: SP7302.1 U7321.D2
N62573733: SP7304.2 U7321.D1
N62573833: SP7308.2 U7322.C1
N62573859: SP7301.2 U7320.C1
N62573915: SP7306.1 U7320.C2
N62573966: SP7307.1 U7322.C2
N62692739: C8814.1 R8801.1
N62708375: Q3006.2 Q3006.3 R3061.1
N62774305: Q8805.6 R8821.2
N62839220: C8412.1 Q8405.1 R8437.2 R8438.1
N62839234: Q8406.6 R8438.2
N62839244: C8408.1 Q8405.3 R8430.1
N62900780: Q7187.5 R7184.1 R7185.2 R7190.2
N62901123: Q7187.3 R7181.2 R7182.2
N62901166: C7125.1 Q7111.2 R7182.1 R7183.2
N62901168: C7125.2 Q7111.1 R7181.1
N62928799: Q2001.2 Q2001.3 R2098.1
N62933876: T2686.1 U2400.BR7
N63021289: R3080.1 U3001.40
N63039426: Q3008.5 Q3008.6 R3081.1
N63040609: Q3009.5 Q3009.6 R3083.1
N63106901: C8349.1 R8369.1 R8370.2 R8379.2

Pads without a net: CON0901 2 15; CON2101 3 12 13 21; CON3301 2 4 12; CON3800 2 4 6 8 14 15 16 18 19 20 21 23 25 26 28 34 36 38 40 42; CON5201 4; CON7305 1 5 30 31 36; J3101 16 17 18 19 20 21 22; NOREF#6 1; NOREF#9 1; NOREF#10 1; NOREF#12 1; NOREF#14 1; NOREF#16 1; NOREF#17 1; NOREF#20 1; NOREF#21 1; NOREF#24 1; NOREF#25 1; NOREF#26 1; NOREF#27 1; NOREF#28 1; Q3101 3 4 5; Q5401 3 4 5; Q7003 3 4 5; Q8102 3 4 5; Q8203 3 4 5; Q8406 3 4 5; Q8805 3 4 5; U1001 6 13 14 16 17; U1601 A1 A17 D8 D11 E4 H4 J12 M9 U1 U17; U1701 A1 A17 D8 D11 E4 H4 J12 M9 U1 U17; U1915 AA1 AA2 AA7 AA8 AA9 AA10 AA11 AA12 AA13 AA14 H1 H2 H6 H7 H8 H9 H10 H11 H12 H13 H14 J1 J7 J8 J9 J10 J11 J12 J13 J14 K1 K3 K5 K7 K8 K9 K10 K11 K12 K13 K14 L1 L2 L3 L4 L12 L13 L14 M1 M2 M3 M5 M8 M9 M10 M12 M13 M14 N1 N2 N3 N10 N12 N13 N14 P1 P2 P3 P10 P12 P13 P14 R1 R2 R3 R5 R12 R13 R14 T1 T2 T3 T5 T12 T13 T14 U1 U2 U3 U6 U7 U10 U12 U13 U14 V1 V2 V3 V12 V13 V14 W1 W2 W3 W7 W8 W9 W10 W11 W12 W13 W14 Y1 Y3 Y6 Y7 Y8 Y9 Y10 Y11 Y12 Y13 Y14; U2400 AA3 AA5 AB4 AB10 AC3 AC5 AC9 AC11 AC16 AD4 AD10 AE3 AE5 AE9 AF4 AF8 AF10 AG3 AG5 AG9 AG11 AH4 AH10 AK3 AK7 AK9 AM2 AM4 AM8 AM10 AN3 AN5 AN7 AN9 AN11 AP4 AP10 AP18 AP43 AP45 AR3 AT2 AT17 AT44 AT46 AU5 AU11 AV4 AV6 AV10 AW3 AY2 AY4 B16 B34 B38 BA3 BC3 BC11 BD2 BD10 BE53 BF10 BG3 BG9 BG11 BH2 BH4 BH10 BH16 BH36 BH48 BH54 BJ3 BJ5 BJ9 BJ49 BJ53 BK4 BK8 BK10 BL9 BL35 BL55 BM38 BM54 BN5 BN55 BN57 BP4 BP14 BP38 BP54 BP56 BR17 BR35 BR37 BR55 BR57 BT40 BU35 BU37 C13 C15 C19 C33 C37 C39 D36 D40 E5 E7 E15 E37 E55 E57 F4 F16 F34 F54 F56 G3 G15 G19 G55 G57 H2 H4 H54 J3 J5 J9 J17 J19 J55 K4 K8 K18 L3 L9 L49 L53 M2 M4 M8 M48 M54 N3 N5 N11 P4 P10 R3 R53 T2 T4 T6 T8 T10 T12 T39 U3 U5 U9 V4 V8 V10 V40 W3 W5 W7 W9 Y4; U3001 13 15 17 31 32 33 34 35 63; U3301 A3 A5 C5 D2 D4 E1 E5; U5401 1 2 3 7 8 9 10 11 12 13 14 15 16 18 19 21 25 29 30 31 33 34 36 37 39 40 42 43 44 64 65 66 67 69 70; U5801 1 2 3 4 5 6 14 15 16 17 19; U5804 A3; U7107 16 31 33 34 47 48; U7112 1 2; U8100 2; U8201 D6 H5

## Via types
v1: diameter 0.254, hole 0.102, L7-SIG to BOTTOM, 5148 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 868 vias
v3: diameter 0.457, hole 0.203, L3-GND to L6-GND, 1406 vias
v4: diameter 0.254, hole 0.102, L6-GND to L7-SIG, 4398 vias
v5: diameter 0.229, hole 0.102, L6-GND to L7-SIG, 868 vias
v6: diameter 0.229, hole 0.102, L7-SIG to BOTTOM, 1128 vias
v7: diameter 0.254, hole 0.102, TOP to L2-SIG, 5799 vias
v8: diameter 0.254, hole 0.102, L2-SIG to L3-GND, 6133 vias
v9: diameter 0.559, hole 0.279, TOP to BOTTOM, 161 vias
v10: diameter 0.229, hole 0.102, L5-SIG to L6-GND, 325 vias
v11: diameter 0.762, hole 0.457, TOP to BOTTOM, 60 vias
v12: diameter 0.254, hole 0.102, L5-SIG to L6-GND, 110 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3VO: length 0.8
  L2-SIG w0.102: v2(33.45,43.95) 32.86,43.95 v7(32.75,44.06)
3VO_EN: length 15
  L7-SIG w0.102: v1(41.13,47.74) 41.01,47.86 v1(40.34,47.86) 39.68,47.2 38.4,47.2 37.76,46.57 37.76,46.38 37.47,46.09 37.31,46.09 37.03,45.8 37.03,45.21 36.73,44.91 36.73,42.82 35.98,42.07 35.13,42.07 35.08,42.12 32.45,42.12 v1(31.96,42.61) 31.29,41.95 v1(30.73,41.95)
  vias: v9(40.11,47.07)
3VO_FB: length 3.1
  L7-SIG w0.203: v1(34.92,45.21) 34.92,44.55 33.38,43.01 v1(33.16,43.01)
3VO_PWRGD: length 4.2
  L2-SIG w0.102: v7(34.2,44.14) 34.43,43.91 v2(34.43,43.38)
  L7-SIG w0.102: v1(32.76,42.61) 34.45,42.61 35,43.16 v1(35,43.42)
  BOTTOM w0.102: v2(34.43,43.38) 34.96,43.38 v1(35,43.42)
3VO_SS: length 1.3
  BOTTOM w0.102: C8110.1 33.88,42.68 33.81,42.61 U8101.D3
3VO_VIN:
  vias: v1(30.53,40.83) v1(30.53,40.52) v1(30.81,40.98) v1(30.81,40.67) v1(34.78,40.29) v1(34.78,39.99) v1(35.06,40.45) v1(35.06,40.14) v4(30.53,40.83) v4(30.53,40.52) v4(30.81,40.98) v4(30.81,40.67) v4(34.78,40.29) v4(34.78,39.99) v4(35.06,40.45) v4(35.06,40.14)
5V_EN: length 6.3
  L7-SIG w0.102: v1(72.25,44.86) 72.25,42.91 v1(73.2,41.97) 74.28,41.97 v1(75.67,43.36)
5V_FB: length 5.1
  BOTTOM w0.203: U8100.14 77.2,45.29 77.08,45.4 74.98,45.4 C8100.2 74.38,44.8 74.08,44.8 R8103.2 74.12,45.33 74.12,45.48 R8100.1
5V_USB_PAD:
  vias: v2(94.29,55.84) v2(94.29,55.23) v9(85.39,52.5)
+5VO:
  vias: v9(78.28,45.87)
+V1P0A: length 103.8
  L2-SIG w1.27: 46.3,51.92 46.3,45.15 47.26,44.19 47.26,41.27 48.08,40.45 48.08,35.65 50.06,33.66 52.89,33.66 60.49,26.06 71.26,26.06 72.77,27.57 74.68,27.57 74.85,27.75
  L4-SIG w0.508: v3(49.02,32.83) 49.02,31.81 48.39,31.17 48.39,28.64 51.61,25.41 55.12,25.41 56.04,26.33 67.25,26.33 68.07,27.16 70.03,27.16 v3(70.74,27.87)
  L5-SIG w0.508: v2(75.13,28) 74.98,28 74.07,27.09 71.53,27.09 v3(70.74,27.87)
  L6-GND w0.152: v6(56.72,33.74) 56.23,33.24 54.7,33.24
  L6-GND w0.508: 50.55,33.11 53.85,33.11
  L7-SIG w0.254: v6(57.71,67.52) 57.59,67.39 57.59,66.62 57.2,66.23 57.2,65.74 56.83,65.38 56.83,64.21 56.64,64.02 56.1,64.02 55.67,63.59 55.67,63.23 56.15,62.75 v6(56.54,62.75)
  L7-SIG w1.27: 47.22,55.84 53.17,55.84 53.76,56.43 55.34,56.43 55.35,56.45 55.47,56.45 55.81,56.79
  vias: v1(49.56,33.08) v1(49.94,33.08) v1(56.51,60.29) v1(56.51,59.57) v1(56.85,59.22) v2(44.92,55.49) v2(45.55,55.49) v2(46.16,55.48) v2(46.78,55.51) v2(77.83,27.87) v2(78.33,28.51) v4(49.56,33.08) v4(49.94,33.08) v8(48.16,32.83) v8(48.52,32.82) v11(77.09,27.9)
+V1P0A_FB: length 13.9
  L6-GND w0.06: 62.33,32.6 62.26,32.53 61.87,32.53 61.3,33.1 61.3,33.36 60.77,33.89 60.58,33.89 v6(60.32,34.15)
  L6-GND w0.102: v4(68.93,30.93) 68.58,30.93 67.34,32.16 63.55,32.16 63.31,32.41 62.73,32.41 62.54,32.6 62.33,32.6
  L7-SIG w0.102: v1(72.16,29.6) 70.84,30.93 v4(68.93,30.93)
+V1P0A_LX: length 4.5
  BOTTOM w0.508: 62.26,32.9 62.51,32.65 65.56,32.65 66.11,32.1 L8211.2
+V1P0S: length 158.1
  L2-SIG w1.27: 37.78,73.55 37.36,73.14 37.36,55.89 39.02,54.24 39.02,51.47 39.57,50.91 40.36,50.12 40.36,48.02 40.62,47.71 40.62,44.22 40.42,44.03 40.42,32.42 43.53,29.32 48.19,29.32 53.9,23.61 71.88,23.61
  L4-SIG w0.254: 62.23,62.95 62.91,62.95 63.2,63.23 63.2,63.66 62.46,64.4 58.75,64.4
  L4-SIG w0.305: 47.78,72.25 47.2,72.25 46.86,72.59 43.75,72.59 43.39,72.95 43.39,72.97 42.03,74.33 v3(39.46,74.33)
  L4-SIG w0.381: v3(48.9,71.66) 48.36,71.66 47.78,72.25 48.31,72.78 49.23,72.78 49.89,72.12 51.62,72.12 52.28,72.78 52.78,72.78 53.48,72.08 55.67,72.08 56.49,71.26 57.61,71.26 57.68,71.18 ; 62.23,62.95 62.13,63.05 59.15,63.05 58.73,62.63 58.73,60.76 v3(58.9,60.59) ; 57.68,71.18 v3(57.68,71.26) ; 57.68,71.18 59.05,69.81 59.05,67.4 58.48,66.82 58.48,64.67 58.75,64.4
  L4-SIG w0.508: v3(55.83,60.74) 55.68,60.59 53.07,60.59 52.18,59.7 v2(50.65,59.7)
  L5-SIG w0.254: v3(55.83,60.74) 56.34,60.23 58.55,60.23 v3(58.9,60.59)
  L6-GND w0.254: v6(49.14,71.41) 49.12,71.41 48.9,71.64 v3(48.9,71.66) ; v3(55.83,60.74) 55.79,60.79 v1(55.79,61.15) ; v1(58.89,60.23) 58.89,60.57 v3(58.9,60.59) ; v5(57.74,70.88) 57.68,70.94 v3(57.68,71.26)
  L7-SIG w0.06: v6(58.24,72.44) 58.24,72.44 58.24,72.73 58.71,73.2 58.88,73.2 59,73.08 59.17,73.08 59.29,73.21 59.49,73.21 59.91,72.79 60.35,72.79 60.37,72.78 61.98,72.78 62.33,72.43 64.53,72.43 v6(64.8,72.15)
  L7-SIG w0.152: v6(58.24,72.44) 58.24,72.26 57.74,71.77 v5(57.74,70.88) 57.74,70.76 57.45,70.47 57.45,70.22 57.49,70.19 57.49,69.38 57.45,69.34 57.45,69.12 57.49,69.09 57.49,68.84 57.07,68.42 57.07,68.2 57.45,67.82 57.78,67.82 57.98,67.62 57.98,67.08 v6(58.22,66.85)
  L7-SIG w0.254: v1(46.76,59.39) v1(46.18,59.39) 46.18,58.66 43.63,56.12 43.63,54.65 44.55,53.73 v1(44.55,53.13)
  BOTTOM w0.06: R2508.1 64.77,72.12 v6(64.8,72.15)
  BOTTOM w0.254: v1(50.6,60.28) 50.6,59.75 v2(50.65,59.7) 50.65,59.38 50.27,59.01 47.15,59.01 v1(46.76,59.39)
  vias: v1(38.68,73.4) v1(38.89,73.2) v1(39.23,72.86) v1(39.54,72.86) v1(39.52,72.58) v2(72.42,24.39) v3(39.08,74.79) v4(38.68,73.4) v4(38.89,73.2) v4(39.23,72.86) v4(39.54,72.86) v4(39.52,72.58) v8(37.69,74.74) v8(37.69,74.46) v8(38,74.74) v8(38,74.46) v8(38.28,74.74) v8(38.3,74.46) v9(38.56,72.48) v11(73.15,24.39)
+V1P0S_EN: length 24.8
  L6-GND w0.06: 62.33,32.17 61.78,32.17 60.81,33.13 60.64,33.13 60.48,33.29 60.48,33.46 60.32,33.62 v6(60.32,33.74)
  L6-GND w0.102: v4(68.61,30.21) 67.49,31.33 63.23,31.33 62.4,32.17 62.33,32.17
  L7-SIG w0.102: v1(75.46,24.55) 75.46,26.33 75.21,26.59 73.54,28.25 69.55,28.25 69.34,28.46 68.49,28.46 68.3,28.65 68.3,29.9 v4(68.61,30.21)
  BOTTOM w0.102: v9(77.27,24.2) 76.97,23.9 75.65,23.9 75.46,24.09 R8314.1 v1(75.46,24.55) 75.57,24.65 Q8301.3
+V1P0S_LC_GPIO_SI0: length 8.1
  L7-SIG w0.254: v6(49.56,66.76) 49.38,66.58 49.38,66.52 48.08,65.23 48.08,63.5 47.14,62.55 47.14,62.13 47.17,62.1 47.17,61.29 v1(46.85,60.97) 46.13,60.25 v1(46.03,60.25)
+V1P0S_PCIE_SATA: length 5.7
  L7-SIG w0.127: v6(50.09,67.03) 50.14,66.98 50.14,66.75 50.03,66.64 50.03,66.31 50.06,66.28
  L7-SIG w0.152: 50.06,66.28 50.06,66.08 49.81,65.82
  L7-SIG w0.254: 49.81,65.82 49.5,65.82 48.82,65.15 48.82,63.74 v6(49.18,63.38) 49.22,63.34 49.69,63.34 49.73,63.38 v6(50.31,63.38)
+V1P0S_PMIC:
  vias: v9(74.58,26.19)
+V1P0S_SENSE: length 28.6
  L6-GND w0.06: v6(59.92,33.34) 59.92,33.31 60.1,33.13 60.1,32.85 61.42,31.53 61.42,31.23
  L6-GND w0.102: 61.42,31.23 61.42,31.12
  L6-GND w0.254: v4(62.56,25.77) 62.56,26.01 62.31,26.26 62.31,30.23 61.42,31.12
  L7-SIG w0.254: v1(73.29,25.41) 73.19,25.51 70.95,25.51 70.18,26.27 67.53,26.27 66.82,25.56 64.89,25.56 64.74,25.41 64.38,25.41 62.97,24 62.97,23.19 63.57,22.59 63.57,22.16 63.19,21.78 62.28,21.78 61.52,22.54 61.52,24.32 62.56,25.36 v4(62.56,25.77)
+V1P0SX: length 70.2
  L2-SIG w1.27: 66.43,63.28 73.99,55.72 73.99,53.96
  L2-SIG w1.524: 74.27,52.13 74.27,50.31 79.88,44.69 79.88,29.68
  L4-SIG w0.508: v2(62.28,63.89) 62.1,63.71 57.86,63.71 57.63,63.94 57.63,65.74 56.97,66.4 v3(50.94,66.4) 50.79,66.4 49.33,67.87 49.33,68.16 47.55,69.94 45.36,69.94 v3(44.97,70.32) 44.42,70.87 41.51,70.87 v3(40.4,71.98)
  L6-GND w0.254: v6(44.47,70.34) 44.95,70.34 v3(44.97,70.32)
  L7-SIG w0.254: 51.77,62.47 51.84,62.54 52.45,62.54 52.76,62.85 52.76,64.7 52.89,64.84 52.89,65.19 52.15,65.94 51.91,65.94 51.72,66.13 51.72,66.56 v6(51.52,66.76)
  vias: v1(40.42,71.37) v1(40.68,71.38) v2(62.71,63.43) v2(81.39,27.43) v4(40.42,71.37) v4(40.68,71.38) v5(51.16,66.68) v6(51.04,67.03) v6(51.16,66.68) v6(51.27,62.43) v6(51.49,62.72) v6(52,68.13) v9(40.71,72.1) v10(51.16,66.68) v11(80.9,26.88)
+V1P0SX_EN: length 25
  L6-GND w0.06: 62.33,32.37 61.86,32.37 61.04,33.19 61.04,33.33 v6(60.69,33.68)
  L6-GND w0.102: v4(68.96,30.21) 68.96,30.25 67.68,31.53 63.32,31.53 62.48,32.37 62.33,32.37
  L7-SIG w0.102: v4(68.96,30.21) 69.22,29.96 69.22,28.87 69.63,28.46 73.89,28.46 75.23,27.12 78.95,27.12 v1(79.16,26.92) 79.34,26.73 v1(80.04,26.73)
  BOTTOM w0.102: v9(79.4,28.52) 79.64,28.28 79.64,27.09 79.46,26.92 v1(79.16,26.92)
+V1P0SX_PMIC: length 1
  BOTTOM w0.102: Q8302.4 79.16,24.28 v9(79.04,24.16)
+V1P0SX_S: length 22.9
  L4-SIG w0.254: v3(50.37,73.72) 50.27,73.82 45.67,73.82 v3(45.37,74.12)
  L4-SIG w0.381: v3(62.97,72.79) 61.7,74.06 58.1,74.06 v3(57.33,73.29)
  L5-SIG w0.254: v3(57.33,73.29) 57.33,73.62 56.92,74.02 53.94,74.02 v5(53.91,74.05) 51.82,74.05 v6(51.09,74.78) 51.09,74.34 50.47,73.72 v3(50.37,73.72)
  L6-GND w0.254: v6(45.03,74.41) 45.32,74.12 v3(45.37,74.12)
  L7-SIG w0.254: v5(53.91,74.05) 53.8,74.16 53.8,74.63 v6(53.9,74.74) 53.93,74.76 54.5,74.76 54.53,74.74 54.53,74.74 54.78,74.49 55.3,74.49 v6(55.33,74.46)
  vias: v5(62.56,72.93) v5(63.35,72.86) v6(62.56,72.93) v6(63.35,72.86) v9(40.91,74.94)
+V1P0SX_SENSE: length 35.1
  L6-GND w0.06: 60.78,31.23 60.78,31.56 59.69,32.66 59.69,33.16 59.52,33.33 v6(59.52,33.34)
  L6-GND w0.102: 60.78,31.23 60.78,31 61.72,30.06 v4(61.72,25.79)
  L7-SIG w0.102: v1(80.08,24.72) 78.01,24.72 77.25,23.96 75.22,23.96 75.2,23.99 74.2,23.99 74.08,23.86 72.85,23.86 72.73,23.99 71.97,23.99 71.46,24.5 70.28,24.5 70.14,24.64 65.49,24.64 64.47,23.62 64.47,22.15 63.45,21.14 62.02,21.14 60.81,22.35 60.81,24.7 61.72,25.61 v4(61.72,25.79)
+V1P2A: length 39.1
  L4-SIG w0.254: v3(57.81,60.69) 57.02,59.9 53.18,59.9 52.43,59.16 50.64,59.16 50.55,59.06 49.53,59.06 48.77,59.83 45.43,59.83 v3(45.34,59.92)
  L6-GND w0.254: v4(44.96,59.85) 45.28,59.85 v3(45.34,59.92)
  L7-SIG w0.254: v4(44.96,59.85) 45.16,59.85 45.64,59.36 45.64,59.07 44.27,57.69 43.76,57.69 43.49,57.42 43.49,56.47 42.55,55.53 42.55,54.74 43.02,54.26 43.48,54.26 44.14,53.6 44.14,52.67 44.14,52.66 44.14,52.48 42.84,51.19 42.84,50.12 45.29,47.68 45.72,47.68 46.2,47.2 46.2,46.49 45.9,46.19 45.9,44.88 45.68,44.66 45.34,44.66 44.5,43.82 v1(44.5,43.44)
  BOTTOM w0.508: T8306.1 42.52,44.15 43.78,44.15 R8305.2
  vias: v1(58.04,61.15) v1(58.29,60.87) v4(58.04,61.15) v4(58.29,60.87)
+V1P2A_PMIC: length 14.7
  L6-GND w0.06: v6(56.72,35.34) 56.54,35.52 56.03,35.52
  L6-GND w0.152: 56.03,35.52 55.69,35.87 55.14,35.87 54.65,36.36 54.39,36.36 53.42,37.33 50.87,37.33
  L6-GND w0.254: v4(48.77,39.43) 50.87,37.33
  L7-SIG w0.508: v4(48.77,39.43) 48.67,39.43 48.03,40.08 48.03,40.63 47.62,41.04 46.33,41.04 46.04,41.33 44.83,41.33
  vias: v1(44.35,42.69) v1(44.43,41.88) v1(44.58,42.53) v1(44.76,41.88)
+V1P2S: length 36.8
  L4-SIG w0.508: v3(44.92,60.61) v3(52.22,60.61)
  L6-GND w0.254: v5(44.37,60.56) 44.43,60.61 v3(44.92,60.61) ; v3(52.22,60.61) 52.22,60.25 v1(52.25,60.21) ; v1(43,46.47) 43.27,46.47 44.35,47.55 44.35,47.96 v4(44.3,48.02)
  L7-SIG w0.254: v4(44.3,48.02) 42.29,50.03 42.29,51.97 43.21,52.89 43.48,52.89 43.76,53.18 43.76,53.47 43.38,53.86 42.92,53.86 42.19,54.59 42.19,55.72 43.11,56.64 43.11,57.55 43.62,58.05 43.91,58.05 44.93,59.07 44.93,59.37 44.37,59.93 v5(44.37,60.56) ; v6(52.95,67.03) 52.95,66.58 v6(52.58,66.21) 52.58,65.95 53.73,64.8 53.73,63.93 53.12,63.33 53.12,61.93 53.4,61.65 53.4,61.15 52.46,60.21 v1(52.25,60.21)
  BOTTOM w0.508: T8309.1 42.15,46.42 R8308.2
+V1P2S_EDP_8622: length 23.8
  L7-SIG w0.254: 75.64,19.64 75.77,19.78 75.77,20.83 74.59,22.02 v1(69.81,22.02) ; v1(70.91,12.26) 75.6,12.26 76.63,13.29 76.63,18.11 75.77,18.96 75.79,18.98
  BOTTOM w0.254: v1(70.91,12.26) C7166.1
  BOTTOM w0.279: C7166.1 C7108.1 71.57,13.62 71.47,13.73 U7107.27 ; U7107.6 69.47,21.67 v1(69.81,22.02)
  vias: v1(75.77,19.42) v1(75.77,19.14)
+V1P2S_PMIC: length 23.1
  L4-SIG w0.254: v3(43.21,44.41) 43.21,39.18 47.42,34.96 47.42,34.55 v3(47.47,34.5)
  L6-GND w0.152: 48.44,33.54 53.76,33.54 54.01,33.79 54.46,33.79 54.64,33.61 55.07,33.61 55.2,33.49 56.03,33.49 56.67,34.14 v6(56.72,34.14)
  L6-GND w0.203: v3(47.47,34.5) 48.44,33.54
  L6-GND w0.254: v3(43.21,44.41) 43.2,44.42 v1(43.2,44.82)
  BOTTOM w0.254: v1(43.2,44.82) 43.2,45.23 R8308.1
+V1P2SX: length 78.3
  L2-SIG w0.762: v8(43.59,73.31) 42.84,72.56 42.84,67.2 41.86,66.23 41.86,57.15 43.74,55.27 43.74,50.96 44.2,50.5 44.2,49.08
  L3-GND w0.254: v8(43.59,73.31) 43.75,73.15 v3(43.96,73.15)
  L4-SIG w0.584: v3(49.2,74.38) 48.72,74.86 45.09,74.86 43.96,73.74 v3(43.96,73.15)
  L5-SIG w0.254: v6(52.47,67.31) 52.47,65.81 53.73,64.56 53.73,62.17 54.69,61.21 v3(54.69,59.39)
  L5-SIG w0.508: v6(52.47,67.31) 52.47,67.62 52.25,67.84 52.25,69.75 52.83,70.33 v6(53.9,70.33)
  L6-GND w0.254: v5(50.03,74.37) 50.02,74.38 v3(49.2,74.38) ; v3(54.69,59.39) 54.64,59.45 v1(54.19,59.45) ; v3(43.96,73.15) 43.77,72.96 v6(43.56,72.96)
  L7-SIG w0.203: v6(53.9,70.33) 52.63,71.61 52.63,72.73 52.94,73.05 52.94,73.65 53.42,74.13 v6(53.42,75.01) ; v6(53.42,75.01) 53.21,75.23 52.15,75.23 51.3,74.37 v5(50.03,74.37) ; v6(53.42,75.01) 53.77,75.01 53.81,75.05 54.7,75.05 54.98,74.77 55.42,74.77 55.62,74.58 55.62,74.58 55.73,74.47 56.1,74.47 56.65,75.01 57.44,75.01
  L7-SIG w0.254: 38.77,44.27 38.4,43.9 38.4,43.34 38.47,43.26 38.91,42.82 38.91,42.51 39.72,41.7 39.72,40.79 41.02,39.5 43.39,39.5 v1(43.46,39.43) ; 57.44,75.01 v6(57.71,74.74) 57.85,74.6 58.19,74.26 58.19,73.61 v6(58.24,73.57)
  L7-SIG w0.508: 42.92,46.98 42.77,46.98 40.1,44.31 38.81,44.31 38.77,44.27
  BOTTOM w0.254: R8309.2 43.12,39.51 43.07,39.46 T8310.1
  vias: v3(43.89,47.74) v4(42.94,47.4) v4(43.23,47.48) v4(43.26,47.13) v8(44.2,47.99) v8(44.37,47.7) v8(44.52,47.99)
+V1P2SX_PMIC: length 17.3
  L6-GND w0.152: v4(48.29,34.48) 48.95,33.82 53.68,33.82 53.9,34.05 54.62,34.05 54.8,33.87 55.18,33.87 55.3,33.75 55.94,33.75 v6(56.32,34.14)
  L7-SIG w0.254: v4(48.29,34.48) 46.69,34.48 46.47,34.26 45.51,34.26 45.24,34.54 45.24,34.89 44.35,35.77 44.09,35.77 43.15,36.72 43.15,37.5 v1(43.63,37.98) v1(43.63,38.64)
+V1P05S: length 58.5
  L2-SIG w1.524: 65.1,68.97 69.37,64.7 69.37,62.47 75.95,55.89 75.95,50.93 81.71,45.16 81.71,34.36
  L4-SIG w0.254: 49.99,73.29 48.84,73.29 48.76,73.36 44.88,73.36 v3(44.61,73.09)
  L5-SIG w1.524: 72.8,30.78 73.51,30.07 78.74,30.07 79.94,31.27
  L6-GND w0.254: v6(64.74,70.46) 64.77,70.46 v3(65.19,70.04) 65.5,70.35 v1(65.5,70.43) ; v6(44.4,73.4) 44.64,73.17 44.64,73.13 44.6,73.1 44.6,73.09 v3(44.61,73.09) ; v6(64.11,70.57) 64.42,70.27 v3(64.42,70.04) 63.9,70.04 v6(63.36,70.58)
  vias: v1(71.43,32.22) v1(71.6,31.99) v1(72.04,31.99) v1(72.26,32.19) v2(81.2,32.75) v2(81.18,32.14) v2(81.15,31.53) v3(54.94,72.98) v3(70.92,32.04) v3(70.92,31.51) v3(71.55,31.51) v4(71.43,32.22) v4(71.6,31.99) v4(72.04,31.99) v4(72.26,32.19) v5(54.85,72.53) v5(55.33,72.81) v5(56.28,73.36) v6(53.42,73.36) v6(54.85,72.53) v6(55.33,72.81) v6(56.28,73.36) v8(64.21,70.47) v8(64.36,69.5) v8(64.57,70.47) v8(64.72,69.5) v8(65.1,70.44) v8(65.1,69.5) v8(65.46,70.44) v8(65.43,69.5) v8(71.63,32.47) v8(71.63,32.09) v8(71.98,32.47) v8(71.98,32.12) v10(54.85,72.53) v10(55.33,72.81) v10(56.28,73.36)
+V1P05S_FB: length 11.8
  L6-GND w0.152: v6(61.16,35) 61.95,35 62.04,35.09 63.14,35.09 63.22,35.17 64.32,35.17 64.45,35.04 67.31,35.04 69.01,33.33 v4(69.16,33.33)
  L7-SIG w0.152: v4(69.16,33.33) 69.55,33.72 71.16,33.72 v1(71.35,33.91)
  BOTTOM w0.102: JP8202.2 71.29,33.96 v1(71.35,33.91)
+V1P05S_LX: length 2.9
  BOTTOM w0.508: 65.85,34.05 62.99,34.05
  vias: v1(62.41,33.97) v1(62.63,33.78) v4(62.41,33.97) v4(62.63,33.78) v5(61.13,34.11) v6(61.13,34.11)
+V1P8_EC: length 161.6
  L2-SIG w0.254: v8(82.09,71.37) 84.77,68.69 84.77,55.08 81.86,52.18 81.86,49.8 v8(82.24,49.43)
  L3-GND w0.254: v3(82.36,49.08) 82.36,49.31 v8(82.24,49.43) ; v3(81.9,71.67) 81.9,71.56 v8(82.09,71.37)
  L4-SIG w0.254: v3(40.43,49.18) 42.42,47.19 47.38,47.19 47.62,46.95 69.39,46.95 70.91,48.47 72.19,48.47 73.16,47.49 v3(73.83,47.49)
  L5-SIG w0.254: v3(73.99,65.12) 76.92,65.12 78.16,66.36 78.16,67.01 80.26,69.12 80.66,69.12 81.05,69.51 81.05,70.82 v3(81.9,71.67) ; v3(73.83,47.49) 80.75,47.49 82.34,49.08 v3(82.36,49.08)
  L6-GND w0.254: v3(40.43,49.18) 40.26,49.35 40.26,49.44 v1(40.15,49.55) ; v3(73.99,65.12) 73.79,65.12 73.66,65.24 v4(73.63,65.24) ; v1(81.66,71.41) 81.82,71.58 81.82,71.6 v3(81.9,71.67)
  L7-SIG w0.254: v1(73.73,85.1) 73.13,85.7 73.13,88.17 71.6,89.7 71.6,93.94 73.23,95.56 73.23,98.05 75.11,99.93 v1(75.34,99.93) ; v1(66.78,68.18) 66.92,68.04 67.51,68.04 68.57,69.1 69.41,69.1 69.73,68.78 70.85,68.78 v1(72.07,69.99) ; v1(72.75,65.96) 73.47,65.24 v4(73.63,65.24)
  BOTTOM w0.229: U3001.51 67.62,66.34 67.21,65.93
  BOTTOM w0.254: R3037.2 67.21,65.52 67.21,65.93 ; R3037.2 67.48,65.2 69.41,65.2 69.88,65.67 72.46,65.67 v1(72.75,65.96) 73.01,66.22 73.01,67.79 74.35,69.12 74.35,69.7 74.05,69.99 v1(72.07,69.99) 71.3,69.99 69.42,71.88 69.42,73.92 L3003.2 ; R3037.2 66.72,65.96 R3036.2 ; R3079.2 v1(75.34,99.93) ; U3001.30 78.17,66.34 C3011.1 78.24,67 C3009.1 78.5,67 78.63,67.13 78.63,67.6 R3001.1 79.46,68 79.46,67.88 79.6,67.74 81.07,67.74 81.66,68.33 v1(81.66,71.41) 81.66,83.8 80.56,84.89 79.96,85.49 77.43,85.49 76.68,86.25 74.25,86.25 T8105.1 74.02,85.39 v1(73.73,85.1)
+V1P8A: length 400.6
  L2-SIG w0.203: v8(79.76,86.47) 79.04,85.75 v2(74.7,85.75) ; v8(34.57,60.28) 34.54,60.26 34.54,58.84 34.7,58.68 34.7,54.86 36.73,52.82 36.73,47.64 37.77,46.6 37.77,44.43 v8(37.9,44.31)
  L3-GND w0.203: v3(38.41,44.1) 38.1,44.1 v8(37.9,44.31) ; v3(34.57,60.64) v8(34.57,60.28) ; v8(79.76,86.47) v3(80.11,86.47)
  L4-SIG w0.203: v3(68.71,69.17) 68.15,69.17 67.79,68.81 67.79,67.61 68.72,66.67 v3(68.72,64.73) 68.72,63.62 70.49,61.86 v3(70.49,59.99) 70.49,57.65 70.92,57.22 70.92,52.67 v3(70.64,52.38) ; v3(46.56,18.17) 47.47,19.09 57.99,19.09 58.41,19.51 58.41,20.22 59.34,21.14 v3(59.34,21.17) 59.34,21.41 59.55,21.62 62,21.62 63.3,22.92 69.62,22.92 70.15,23.45 v3(70.15,24.63) ; v3(59.26,23.66) 58.98,23.66 57.81,24.83 51.55,24.83 47.35,29.03 47.35,33.41 47.91,33.97 47.91,35.44 46.76,36.59 v2(46.76,38.64) 46.76,39.52 51.35,44.1 v3(53.39,44.1)
  L4-SIG w0.254: v3(84.63,67.39) 86.74,65.28 86.74,62.01 88.16,60.59 88.16,56 87.81,55.65 87.81,34.92 87.48,34.59 87.48,31.68 86.82,31.02 86.82,30.33 86.17,29.68 v3(86.17,25.11)
  L5-SIG w0.203: v3(62.31,59.95) 62.93,59.95 63.2,59.68 70.18,59.68 v3(70.49,59.99) ; v3(70.64,52.38) 70.69,52.38 71.1,52.79 75.97,52.79 76.46,52.31 77.54,52.31 77.98,52.75 v3(77.98,52.79) ; v2(81.42,66.81) 82.05,66.81 82.64,67.39 v3(84.63,67.39) ; v3(31.48,17.23) 31.61,17.1 31.61,13.24 32.01,12.84 33.91,12.84 34.87,11.87 40.84,11.87 46.56,17.59 v3(46.56,18.17) ; v3(80.16,81.59) 81.48,82.92 81.48,85.1 v3(80.11,86.47) 80.11,87.73 80.21,87.83 80.21,88.21 79.78,88.64 79.78,90.36 84.02,94.6 v3(84.02,98.28) ; v3(59.26,23.66) 59.26,23.61 59.31,23.56 59.31,21.19 v3(59.34,21.17) ; v6(58.29,38.35) 58.43,38.35 58.75,38.67 58.75,39.01 58.49,39.28 58.47,39.28 58.12,39.63 58.12,40.28 59.13,41.29 59.13,45.06 57.4,46.79 54.68,46.79 53.39,45.5 v3(53.39,44.1)
  L6-GND w0.203: v1(48.84,36.59) 49.42,36.01 53.17,36.01 54.03,35.15 54.6,35.15 54.82,35.38 55.54,35.38 55.92,35 56.29,35 v6(56.32,34.97) ; v1(68.24,64.41) 68.56,64.73 v3(68.72,64.73) ; v1(59.21,20.69) 59.21,21.04 v3(59.34,21.17) ; v1(31.8,17.43) 31.69,17.43 v3(31.48,17.23) ; v3(77.98,52.79) 78.15,52.95 v1(78.15,53.25) ; v1(34.29,60.23) 34.29,60.36 v3(34.57,60.64) ; v4(68.76,69.86) 68.71,69.8 v3(68.71,69.17) ; v4(38.75,43.75) 38.75,43.76 v3(38.41,44.1) ; v1(62.2,59.57) 62.31,59.68 v3(62.31,59.95) ; v4(85.81,25.12) 86.12,25.12 86.12,25.11 v3(86.17,25.11) ; v4(84.86,67.12) 84.74,67.24 84.74,67.29 v3(84.63,67.39) ; v1(70.15,25.13) v3(70.15,24.63) ; v1(84.4,98.28) v3(84.02,98.28) ; v3(80.16,81.59) v1(80.16,81.21)
  L7-SIG w0.203: v2(74.7,85.75) 74.47,85.52 74.47,84 74.01,83.53 74.01,81.86 74.51,81.36 74.51,78.83 74.72,78.62 74.72,77.81 74.99,77.54 74.99,75.76 74.63,75.4 74.63,75.07 75.29,74.41 75.29,74.04 73.98,72.73 72.93,72.73 72.34,72.15 72.11,72.15 70.34,70.38 69.68,70.38 69.16,69.86 v4(68.76,69.86) 68.25,69.86 67.85,69.46 66.94,69.46 66.86,69.46 66.59,69.46 66.4,69.26 v1(66.4,68.92) ; v1(9.14,73.09) v1(9.14,72.3) 13.97,72.3 14.8,73.13 21.59,73.13 v1(22.27,73.8) ; v1(69.06,63.79) 69.06,63.26 68.29,62.48 67.25,62.48 v1(67.13,62.37) ; v1(70.15,25.13) 70.5,24.77 71.05,24.77 71.25,24.98 74.69,24.98 75.01,24.66 75.01,24.54 75.33,24.22 77.12,24.22 77.95,25.05 80.24,25.05 80.39,24.9 81.44,24.9 81.62,25.08 85.77,25.08 v4(85.81,25.12) ; v1(68.24,64.41) 67.8,64.41 67.48,64.74 66.26,64.74 65.96,64.45 v1(65.71,64.45) ; v1(59.21,20.69) 59.31,20.58 59.31,19.92 58.67,19.29 58.67,17.99 v1(59.05,17.61) v1(59.79,17.61) v1(60.55,17.61) ; v1(35,71.56) 35,70.93 36.98,68.95 36.98,68.46 38.48,66.96 v1(38.48,66.84) ; v1(80.16,81.21) 80.16,81.18 81.02,80.32 81.02,77.79 80.83,77.59 80.73,77.59 v1(80.45,77.31) 81.05,76.72 81.05,70.91 81.42,70.54 v2(81.42,66.81) ; v1(78.66,80.35) 78.05,80.35 v1(77.19,81.21) ; v1(85.96,64.91) 85.4,65.46 85.4,66.58 v4(84.86,67.12)
  L7-SIG w0.254: v4(38.75,43.75) 40.56,41.94 40.56,40.96 41.31,40.21 42.28,40.21 42.29,40.22 43.76,40.22 43.92,40.07 44.4,40.07 44.81,39.66 44.81,39.58 44.9,39.49 45.11,39.28 45.45,39.28 45.85,38.88 45.85,38.5 v1(46.3,38.04) 47.33,37.02 47.33,37.01 48.18,36.15 48.64,36.15 48.84,36.36 v1(48.84,36.59)
  BOTTOM w0.127: v1(66.4,68.92) 66.78,69.3 66.78,70.29 66.85,70.37 67.02,70.37 67.49,70.84 67.49,71.64 67.41,71.71 R2659.2
  BOTTOM w0.203: v6(58.29,38.35) 58.29,37.76 U8201.G1 ; v1(68.24,64.41) 68.44,64.41 v1(69.06,63.79) ; R2692.1 38.48,70.11 38.48,70.02 38.48,70.01 Q2650.5 Q2650.2 v1(38.48,66.84) 38.48,66.36 R2677.2 38.16,63.38 36.37,61.58 35.66,61.58 35.26,61.18 Q8303.2 35.26,59.92 R8317.1 34.49,59.9 C8336.1 ; v1(80.45,77.31) 79.34,77.31 79.14,77.52 U3304.1 ; v1(66.4,68.92) 66.13,68.65 66.08,68.65 R2645.1 65.69,67.9 65.81,67.78 R2688.1 R2640.1 ; v1(78.66,80.35) C3318.1 79.69,80.64 79.69,80.74 v1(80.16,81.21) ; R8826.2 31.45,17.57 31.58,17.43 v1(31.8,17.43) ; R2720.2 81.03,67.2 v2(81.42,66.81) ; v1(70.15,25.13) 70.25,25.23 R8435.1 R8431.1 ; R2636.2 66.65,62.65 66.9,62.65 R2630.1 ; v1(35,71.56) 35,72 32.92,74.08 32.92,75.7 32.67,75.96 26.52,75.96 25.35,77.12 25.35,78.32 25.04,78.63 24.72,78.63 24.28,78.19 24.28,75.82 v1(22.27,73.8)
+V1P8A_FB: length 11.5
  L6-GND w0.06: 55.09,34.1 55.19,34.1 55.36,33.92 55.76,33.92 56.2,34.35 56.53,34.35 v6(56.72,34.54)
  L6-GND w0.102: 55.09,34.1 54.9,34.1 54.72,34.27 53.81,34.27 53.58,34.05 49.18,34.05 v4(48.29,34.93)
  L7-SIG w0.102: v4(48.29,34.93) 48.11,35.11 46.69,35.11 46.36,34.78 v1(46.36,34.73)
+V1P8A_G3: length 60.8
  L4-SIG w0.254: v3(53.33,59.34) 53.66,59.01 54.42,59.01 54.5,58.94 58.04,58.94 59.64,60.54 59.64,61.45 60.13,61.94 v3(60.71,61.94) 60.71,60.68 60.52,60.49 60.52,59.16 61.05,58.63 62.24,58.63 v3(62.43,58.43)
  L5-SIG w0.254: v5(57.33,68.31) 57.11,68.09 57.11,67.94 56.82,67.65 v3(56.82,67.62) 56.23,67.03 v6(54.86,67.03)
  L6-GND w0.254: v6(60.32,62.51) 60.32,62.32 v3(60.71,61.94) ; v1(63.15,58.25) 62.96,58.43 v3(62.43,58.43) ; v4(53.33,59.77) v3(53.33,59.34)
  L7-SIG w0.254: v6(54.86,67.03) 54.78,67.12 54.25,67.12 53.65,66.51 53.61,66.51 53.16,66.06 53.16,65.81 53.53,65.44 53.71,65.44 54.51,64.64 54.51,64.01 53.75,63.26 53.75,60.47 53.33,60.04 v4(53.33,59.77) ; v5(57.33,68.31) 57.38,68.31 57.71,68.64 v6(57.71,68.68) 57.77,68.74 57.77,69.18 v6(57.71,69.23) 57.79,69.31 57.79,70.25 v6(57.71,70.33)
  BOTTOM w0.254: v1(63.15,58.25) 63.15,58.07 63.42,57.79 80.82,57.79 81.71,58.68 81.71,65.32 80.7,66.33 R2720.1 79.68,66.33 79.29,66.72 T2706.1
+V1P8A_LX: length 3
  BOTTOM w0.508: 54.52,35.26 54.21,35.57 51.72,35.57 51.65,35.49
+V1P8A_PMIC:
  vias: v9(48.11,35.68)
+V1P8S: length 524.2
  L2-SIG w0.254: v8(84.41,61.03) 84.41,64.79 84.24,64.96 83.44,64.96 v2(83.18,64.69) ; v2(33.59,83.75) 33.39,83.55 33.21,83.55 32.08,82.42 32.08,78.51 34.87,75.71 35.96,75.71 v2(36.11,75.56) 35.2,74.65 35.2,63.55 v8(35.03,63.38) 34.9,63.25 34.9,61.24 34.21,60.56 34.21,58.58 34.37,58.43 34.37,54.72 36.4,52.68 36.4,47.5 37.44,46.46 v8(37.44,44.43) ; v8(84.2,92.69) 84.71,92.18 88.85,92.18 v8(89.28,92.62)
  L3-GND w0.254: v8(84.41,61.03) 84.41,61.24 84.53,61.36 v3(84.53,61.38) ; v8(37.44,44.43) 37.44,44.13 37.54,44.03 v3(37.54,44) ; v8(84.2,92.69) 84.2,92.31 v3(84.02,92.14) ; v8(89.28,92.62) 89.54,92.36 v3(89.54,92.35) ; v3(34.65,63.48) 34.75,63.38 v8(35.03,63.38)
  L4-SIG w0.254: v3(84.02,92.14) 83.65,92.14 82.07,90.56 82.07,90.26 80.36,88.54 79.6,88.54 75.6,84.55 75.6,80.12 74.36,78.88 v3(74.18,78.88) ; v3(34.65,63.48) 34.65,63.52 32.44,65.73 30.36,65.73 30.31,65.68 29.46,64.83 21.09,64.83 20.47,65.45 v3(20.16,65.45) ; v3(72.9,37.05) 73.31,37.46 73.31,40.45 68.53,45.22 58.81,45.22 58.47,44.89 50.92,44.89 46.81,40.78 45.04,40.78 44.1,39.84 v3(44.1,39.05) ; v2(36.11,75.56) 36.11,74.83 38.43,72.5 40.57,72.5 41.38,71.68 v3(43.74,71.68) ; v3(85.06,96.07) 85.06,103.29 79.42,108.93 60.58,108.93 60.58,108.93 59.61,108.93 59.31,109.24 57.84,109.24 57.53,108.93 49.53,108.93 49.51,108.93 47.31,106.73 39,106.73 35,102.73 v3(35,101.79)
  L5-SIG w0.254: v3(89.54,92.35) 88.78,92.35 v3(85.06,96.07) ; v3(32.61,9.69) 32.03,9.1 32.03,7.22 29.21,4.4 27.41,4.4 v3(27.18,4.63) ; v3(79.4,34.91) 81.76,34.91 v3(82.65,35.8)
  L6-GND w0.254: v3(20.16,65.45) 20.15,65.46 20.15,65.67 v1(19.99,65.82) ; v3(27.18,4.63) v1(26.9,4.35) ; v1(37.99,43.75) 37.74,44 v3(37.54,44) ; v6(43.69,72.07) 43.74,72.02 v3(43.74,71.68) ; v3(32.61,9.69) 32.39,9.69 v1(32.21,9.51) ; v3(74.18,78.88) 74.04,78.74 v1(74.04,78.52) ; v1(34.74,63.84) 34.74,63.58 v3(34.65,63.48) ; v4(72.46,37.06) 72.9,37.06 72.9,37.05 v3(72.9,37.05) ; v3(35,101.79) 35,101.56 v4(35.18,101.38) ; v1(84.2,92.69) 84.2,92.31 v3(84.02,92.14) ; v1(44.39,38.78) 44.36,38.78 v3(44.1,39.05) ; v1(84.89,61.15) 84.66,61.38 v3(84.53,61.38) ; v4(89.59,91.93) 89.59,91.94 89.59,92.29 89.54,92.34 v3(89.54,92.35) ; v4(83.21,35.8) v3(82.65,35.8) ; v4(78.77,34.91) v3(79.4,34.91)
  L7-SIG w0.254: v1(89.29,33.64) v1(89.29,31.62) 89.29,31.01 v1(88.14,29.85) ; v1(44.39,38.78) 44.06,38.78 43.79,39.05 40.85,39.05 39.37,40.54 39.37,41.55 38.56,42.36 38.56,42.67 38.12,43.12 37.99,43.24 v1(37.99,43.75) ; v1(83.72,5.83) 84.03,5.52 84.03,4.81 85.12,3.72 87.22,3.72 87.87,4.37 ; v1(4.15,61.35) 4.1,61.35 3.61,61.84 3.61,63.54 5.91,65.84 19.97,65.84 v1(19.99,65.82) ; v1(60.6,13.01) 60.61,13.01 60.61,12.5 61.26,11.85 64.82,11.85 66.02,10.64 68.87,10.64 68.88,10.66 77.41,10.66 78.26,9.81 v1(78.26,9.61) 79.27,10.63 84.74,10.63 84.88,10.77 86.41,10.77 v1(86.61,10.58) v1(87.37,10.58) v1(88.13,10.58) ; 87.87,4.37 87.53,4.71 87.53,5.47 v1(87.17,5.83) 86.97,6.03 86.97,7.79 v1(86.69,8.06) 86.69,8.09 88.13,9.53 v1(88.13,10.58) ; 87.87,4.37 88.45,3.79 88.45,2.04 87.73,1.32 42.18,1.32 39.12,4.38 38.76,4.38 37.92,3.54 28.68,3.54 27.46,2.32 26.17,2.32 25.87,2.62 25.87,2.95 25.78,3.04 25.78,4.14 v1(25.94,4.3) 26.38,4.3 26.44,4.35 v1(26.9,4.35) ; v1(88.13,10.58) 88.49,10.94 88.49,29.5 v1(88.14,29.85) ; v1(36.7,98.82) 36.7,99.86 v4(35.18,101.38) 34.5,102.06 28.19,102.06 26.71,100.58 v1(26.71,97.86) ; v4(83.21,35.8) 83.49,35.52 84.53,35.52 84.76,35.29 v1(87.25,35.29) 86.22,34.26 85.17,34.26 84.6,33.69 84.6,31.89 85.08,31.4 v1(85.08,30.24) 85.62,29.69 87.53,29.69 87.69,29.85 v1(88.14,29.85) ; v4(78.77,34.91) 77.78,34.91 77.38,35.3 74.32,35.3 74.23,35.21 73.64,35.21 72.46,36.4 v4(72.46,37.06) 72.05,37.46 v1(71.68,37.46) ; v2(33.59,83.75) 33.55,83.71 v1(33.55,83.15) 33.55,82.99 34.04,82.51 34.04,82.14 34.25,81.93 34.6,81.93 34.85,82.18 34.85,84.91 35.33,85.39 35.33,96.78 v1(36.4,97.85) ; v4(89.59,91.93) 89.59,86.7 86.19,83.29 84.84,83.29 84.32,82.77 84.32,65.48 83.53,64.69 v2(83.18,64.69) 83.18,64.34 82.65,63.81 v1(81.08,63.81)
  BOTTOM w0.203: R2651.2 36.3,8.65 36.22,8.72 Q2660.5 Q2660.2 32.92,8.72 32.61,9.03 32.61,9.1 v1(32.21,9.51)
  BOTTOM w0.254: R2721.2 43.26,72.17 43.18,72.09 R2668.2 R2667.2 ; R7185.1 61.57,13.24 60.83,13.24 v1(60.6,13.01) ; v1(19.99,65.82) 19.99,66.79 R1009.2 20.21,67.46 20.07,67.6 20.07,68.74 20.29,68.97 R1048.2 20.24,69.42 20.24,71.93 20.75,72.44 21.82,72.44 T8308.1 22.86,71.4 24.35,71.4 24.61,71.67 Q2655.1 ; U7320.A1 82.98,7.01 R7373.1 ; v1(36.7,98.82) 36.7,98.16 v1(36.4,97.85) ; R8528.1 v1(71.68,37.46) R8531.1 ; U7322.A1 86.99,6.01 v1(87.17,5.83) ; R7373.1 82.47,5.32 80.17,5.32 79.66,5.83 C7391.1 79.27,6.44 79.25,6.46 U7321.C1 ; R7373.1 v1(83.72,5.83) ; v1(86.69,8.06) 86.49,7.86 U7322.B2 ; R0703.1 84.89,61.8 v1(84.89,61.15) ; v1(74.04,78.52) R2522.1 74.04,76.33 73.84,76.12 Q5401.2 ; R2515.1 81.08,63.99 v1(81.08,63.81) ; v1(34.74,63.84) R1038.1
+V1P8S_AUD_AVDD: length 1.8
  BOTTOM w0.254: R1046.1 R1009.1 21.57,66.59 R1047.1
+V1P8S_AUD_D: length 127.8
  L2-SIG w0.254: v8(33.07,68.39) 33.07,71.13 27.49,76.71 27.49,87.39 32.33,92.23 32.33,96.8 38.68,103.15 42.05,103.15 42.26,102.94 60.36,102.94 v2(62.33,104.91)
  L3-GND w0.254: v3(33.45,68.39) v8(33.07,68.39)
  L6-GND w0.254: v1(33.83,68.28) 33.73,68.39 v3(33.45,68.39)
  L7-SIG w0.254: v1(21.28,61.15) 21.78,60.65 23.19,60.65 24.9,58.94 27.99,58.94 29.31,60.26 33.07,60.26 33.43,60.61 33.43,62.29 34.21,63.07 v1(34.21,63.08)
  BOTTOM w0.178: 30.84,65.54 U1001.43
  BOTTOM w0.254: R1038.2 35.23,65.41 35.23,63.64 34.67,63.08 v1(34.21,63.08) ; R1038.2 C1022.1 C1021.2 ; R1038.2 34.74,66.19 R1026.2 R1027.2 ; v2(62.33,104.91) 64.97,107.55 66.86,107.55 v9(66.86,107.55) 66.87,107.55 84.37,107.55 86.88,105.04 87.67,105.04 88.57,105.94 88.57,106.34 88.77,106.54 R1124.2 R1127.2 ; C1021.2 33.22,66.55 33.41,66.75 33.59,66.75 33.86,67.02 33.86,68.26 v1(33.83,68.28) ; C1021.2 33.11,65.9 32.68,66.33 31.63,66.33 30.84,65.54
+V1P8S_AUD_PVDD: length 4.3
  BOTTOM w0.178: 24.28,67.54 U1001.23
  BOTTOM w0.254: 24.28,67.54 24,67.54 v9(23.76,67.79) 23.56,67.98 C1027.2 22.35,67.98 22.28,67.91 C1028.1 20.9,67.91 R1048.1
+V1P8S_EDP: length 48.6
  L4-SIG w0.254: v3(79.11,18.49) 77.66,19.95 65.1,19.95 62.97,17.82 v2(61.24,17.82)
  L5-SIG w0.254: v2(61.24,17.82) 58.93,15.5 58.93,12.99 v3(59.41,12.51)
  L6-GND w0.254: v3(59.41,12.51) 59.73,12.83 v1(59.73,13.01) ; v1(79.11,18.04) v3(79.11,18.49)
  L7-SIG w0.254: v1(59.07,13.01) v1(59.73,13.01) ; v1(62.83,19.82) 62.83,19.51 62.46,19.14 v1(61.29,19.14) 61.29,17.87 v2(61.24,17.82) 61.29,17.76 61.29,17.74 61.67,17.36 62.76,17.36 v1(62.83,17.44) ; v1(79.11,18.04) v1(79.11,15.66) 79.47,15.3 79.91,15.3 80.12,15.51 80.12,16.32 82.35,18.55 82.8,18.55 83.51,17.84 85.21,17.84 v2(85.95,17.1)
  BOTTOM w0.254: v2(85.95,17.1) R7189.1 R7186.1 R7132.2
+V1P8S_EMMC: length 40.5
  L3-GND w0.254: v3(21.84,86.95) v8(21.84,86.59)
  L6-GND w0.254: v1(21.64,87.26) 21.84,87.06 v3(21.84,86.95)
  L7-SIG w0.508: v1(27.73,88.23) 23.61,88.23 22.63,87.26 v1(21.64,87.26) ; v1(27.73,89.23) 26.95,89.23 25.93,90.26 23.58,90.26 22.82,89.49 v1(21.64,89.49) 20.88,90.26 20.88,92.14 21.49,92.75 24.76,92.75 25.12,92.38 31.16,92.38 33.22,90.32 v1(33.22,89.73) 33.22,89.49 32.08,88.35 32.08,85.89 32.97,85 32.97,83.55
  BOTTOM w0.254: v1(21.64,87.26) C1903.1 C1913.1 v1(21.64,89.49)
  vias: v1(28.22,88.73) v1(28.73,88.73) v1(32.67,82.29) v1(33.55,82.29)
+V1P8S_PMIC: length 13.5
  L6-GND w0.152: v6(56.32,34.56) 56.28,34.52 56.07,34.52 55.93,34.37 55.35,34.37 55.3,34.33 54.99,34.33 54.81,34.5 53.71,34.5 53.49,34.27 49.45,34.27 48.49,35.24 48.26,35.24 v4(47.98,35.52)
  L7-SIG w0.254: v1(45.26,38.68) 45.26,38.01 v1(45.26,38.01) 47.4,35.87 47.63,35.87 v4(47.98,35.52)
+V1P8S_S4: length 25
  L2-SIG w0.254: v8(43.68,69.08) 43.68,70.13 44.62,71.07 v8(44.62,71.27)
  L3-GND w0.254: v3(43.86,68.67) 43.68,68.85 v8(43.68,69.08) ; v8(44.62,71.27) 44.62,71.36 44.3,71.68 v3(44.3,71.69)
  L4-SIG w0.254: v3(48.86,72.26) 48.95,72.26 49.35,71.85 49.35,71.47 49.01,71.13 45.72,71.13 45.17,71.69 v3(44.3,71.69)
  L5-SIG w0.254: v3(58.01,71.74) 56.73,73.03 56.73,73.36 56.38,73.71 51,73.71 50.58,73.29 49.89,73.29 49.25,72.65 49.25,72.65 v3(48.86,72.26)
  L6-GND w0.254: v3(44.3,71.69) 44.38,71.77 v6(44.96,71.77) ; v3(58.01,71.74) 57.91,71.84 v5(57.91,72.3) ; v3(48.86,72.26) 49.13,72.53 v6(49.14,72.53) ; v3(43.86,68.67) 43.63,68.44 v6(43.63,68.28)
  L7-SIG w0.127: v5(57.91,72.3) 57.97,72.36 57.97,73.26 57.71,73.51 v6(57.71,74.19)
+V1P8S_SENSOR: length 65.6
  L4-SIG w0.381: v3(70.28,113.49) 67.14,110.35 49.33,110.35 46.24,107.26 46.13,107.15 38.83,107.15 34.39,102.71 v2(34.39,101.1)
  L6-GND w0.381: v1(70.28,114) v3(70.28,113.49)
  L7-SIG w0.381: v2(34.39,101.1) 34.39,100.95 34.76,100.58 34.76,100.07 35.26,99.58
  BOTTOM w0.254: U5804.C1 67.82,116.2
  BOTTOM w0.381: 68.8,115.01 67.82,115.99 67.82,116.2 ; 68.8,115.01 68.83,114.97 R5824.1 C5820.1 v1(70.28,114) ; 68.8,115.01 v9(68.8,115) ; C5810.1 29.08,101.78 28.82,102.04 27.39,102.04 26.77,101.42 26.77,99.37 27.58,98.57 R5860.2 27.58,97.45 27.73,97.29 28.94,97.29 29.11,97.46 C5812.1 30.11,96.89 34.34,96.89 35.23,97.77 R5866.2
  vias: v1(35.13,99.68) v1(35.31,99.43)
+V1P8SX: length 196.7
  L2-SIG w0.381: v2(12.98,108.7) 13.02,108.74 18.53,108.74 21.4,105.87 36.21,105.87 37.89,104.18 42.47,104.18 42.69,103.97 59.51,103.97 63.23,107.69 80.75,107.69 82.74,105.7 82.74,97.69 v2(83.3,97.13)
  L2-SIG w0.508: v2(24.54,84.13) 24.54,76.24 30.79,69.99 30.79,65.36 30.33,64.91 30.33,61 30.3,60.98 30.3,60.95 30.2,60.85 30.2,54.54 26.39,50.73 26.39,46.87 31.67,41.59 33.4,41.59 v2(33.53,41.72)
  L4-SIG w0.508: v2(13.08,94.37) 13.13,94.42 13.13,108.04 12.98,108.19 v2(12.98,108.7)
  L5-SIG w0.508: v3(44.93,39.48) 44.6,39.81 42.14,39.81 40.31,41.64 38.12,41.64 37.4,40.91 34.11,40.91 33.53,41.49 v2(33.53,41.72) ; v2(13.08,94.37) 13.21,94.5 21.9,94.5 23.9,92.49 23.9,85.71 24.54,85.07 v2(24.54,84.13)
  L7-SIG w0.381: v2(83.3,97.13) 82.91,97.13 81.08,98.96 76.39,98.96 v1(73.91,96.48)
  BOTTOM w0.381: R2121.1 12.87,108.81 v2(12.98,108.7) 12.98,108.03 T8307.1
  vias: v1(44.25,39.68) v1(44.46,39.44) v4(44.25,39.68) v4(44.46,39.44)
+V1P8SX_2M: length 22
  L7-SIG w0.254: v1(15.93,108.77) 15.62,109.08 14.58,109.08 13.87,109.79 13.25,109.79 v1(12.87,110.17)
  L7-SIG w0.305: v1(8.65,122.25) 8.65,120.92 9.14,120.43 9.14,111.51 v1(11.35,109.31) 12.11,110.07 v1(12.11,111.34) v1(12.87,111.34) v1(12.87,110.17)
+V1P8SX_PMIC: length 14
  L6-GND w0.152: 53.46,36.19 53.46,36.14 54.08,35.52 54.46,35.52 54.59,35.65 55.6,35.65 55.95,35.31 56.32,35.31 v6(56.32,35.31)
  L6-GND w0.254: 53.46,36.19 53.27,36.37 49.57,36.37 48.96,36.98 48.1,36.98 v4(47.68,37.4)
  L7-SIG w0.254: v1(45.26,39.63) 45.41,39.79 v1(46.65,39.79) 46.65,39.45 47.24,38.86 47.24,37.65 47.5,37.4 v4(47.68,37.4)
+V1P8U: length 43.7
  L2-SIG w0.508: v2(29.39,77.44) 30.46,78.5 30.46,85.48 34.33,89.35 34.33,96.48 38.68,100.83
  BOTTOM w0.508: 35.81,65.9 35.81,66.15 36.11,66.45 36.11,68.15 36.07,68.2 36.07,74.28 v9(34.62,75.73) 32.91,77.44 v2(29.39,77.44)
  vias: v1(38.94,101.81) v1(38.94,101.46) v3(38.66,101) v4(38.94,101.81) v4(38.94,101.46) v8(39.17,101.1) v8(39.17,100.77)
+V1P8U_EN#: length 49.2
  L2-SIG w0.102: v8(38.68,35.57) 38.33,35.93 38.33,43.46 38.18,43.61 38.18,46.55 36.99,47.74 36.99,52.92 34.95,54.96 34.95,58.98 v8(34.87,59.05)
  L3-GND w0.102: v3(38.68,35.16) v8(38.68,35.57) ; v3(35.23,58.79) 34.96,59.05 v8(34.87,59.05)
  L5-SIG w0.06: 55.09,34.25 55.18,34.25 55.27,34.34 55.65,34.34 55.85,34.14 v6(57.12,34.14)
  L5-SIG w0.102: v3(38.68,35.16) 41.02,35.16 41.35,34.83 43.51,34.83 44.04,35.37 45.88,35.37 46.06,35.19 49.73,35.19 51.24,33.68 54.37,33.68 54.93,34.25 55.09,34.25
  L6-GND w0.102: v1(35.59,58.71) 35.51,58.79 v3(35.23,58.79)
  BOTTOM w0.102: Q8303.1 37.16,60.87 36.68,60.39 36.59,60.39 R8317.2 36.11,59.23 v1(35.59,58.71)
+V1P8U_LPDDR3: length 85.5
  L4-SIG w0.254: v3(43.89,89.57) 43.89,97.93 v2(44.48,98.51) 45.44,98.51 46.2,99.27 48.34,99.27 49.44,98.18 50.32,98.18 50.75,97.75 v3(52.02,97.75) 53.07,96.7 53.07,91.96 v2(52.38,91.27) ; v2(69.9,90.51) 70.35,90.96 70.35,97.4 70.03,97.72 69.88,97.72 v3(69.77,97.83) 69.8,97.85 69.8,98.28 68.71,99.37 62.59,99.37 61.86,98.65 v2(61.86,98.56) 61.65,98.35 v3(61.65,89.54)
  L5-SIG w0.102: v3(69.7,101.41) 69.35,101.06 69.35,99.49 69.77,99.07 v3(69.77,97.83)
  L5-SIG w0.254: v2(61.86,98.56) 60.03,100.39 v2(57.53,100.39) 54.76,100.39 52.12,97.75 v3(52.02,97.75)
  L6-GND w0.076: v1(61.84,90.46) 61.62,90.25 61.62,89.88 61.65,89.86 v3(61.65,89.54) ; 69.54,97.8 69.19,97.8 68.87,97.48 v1(68.86,97.48) ; v1(44.08,90.48) 44.08,90.42 43.84,90.18 43.84,89.62 v3(43.89,89.57)
  L6-GND w0.102: v1(69.35,101.95) 69.35,101.75 v3(69.7,101.41) ; 69.54,97.8 69.75,97.8 v3(69.77,97.83)
  L6-GND w0.254: v1(51.08,97.48) 51.41,97.81 51.96,97.81 v3(52.02,97.75)
  BOTTOM w0.102: v2(57.53,100.39) 56.57,100.39 v9(56.43,100.25)
  BOTTOM w0.203: v1(44.08,90.48) 43.86,90.69 ; U1601.T16 61.64,90.69 ; v1(68.86,97.48) 68.64,97.69
  BOTTOM w0.254: v2(52.38,91.27) 52.09,90.98 U1701.R1 U1701.T1 ; v2(61.86,98.56) U1601.A16 U1601.A15 ; v2(69.9,90.51) 69.87,90.48 U1601.T1 U1601.R1 ; v2(57.53,100.39) 57.64,100.5 C1618.1 ; R1625.2 40.06,101.04 40.18,101.16 40.55,101.16 C1707.1 40.55,100.78 40.46,100.7 C1705.1 40.74,99.96 42.13,99.96 44.08,98.02 U1701.A16 U1701.A15 44.58,98.4 v2(44.48,98.51)
+V1P8U_SENSE: length 46.9
  L2-SIG w0.254: v8(38.66,43.29) 38.66,43.52 38.46,43.72 38.46,46.67 37.29,47.84 37.29,53.23 37.29,53.52 35.64,55.17 v8(35.64,62.57)
  L3-GND w0.254: v3(36.25,62.54) 35.66,62.54 v8(35.64,62.57) ; v3(38.96,42.96) 38.66,43.27 v8(38.66,43.29)
  L6-GND w0.06: 55.09,34.55 55.11,34.54 55.83,34.54 56.06,34.77 56.5,34.77 v6(56.72,34.99)
  L6-GND w0.102: 55.09,34.55 54.92,34.73 53.62,34.73 53.39,34.5 49.57,34.5 48.5,35.57 v4(48.36,35.57)
  L6-GND w0.254: v4(36.55,62.87) 36.25,62.57 v3(36.25,62.54) ; v4(39.27,42.66) v3(38.96,42.96)
  L7-SIG w0.102: v4(48.36,35.57) 45.57,38.36 45.57,38.76 45.33,39 44.87,39 44.79,39.07 44.32,39.07 44.03,39.37
  L7-SIG w0.254: 44.03,39.37 43.54,39.86 42.44,39.86 42.43,39.85 41.17,39.85 40.08,40.94 40.08,41.85 v4(39.27,42.66) ; v4(36.55,62.87) 36.55,64.41 v1(37.2,65.06)
+V2P85S: length 106.2
  L2-SIG w0.254: v8(32.61,84.29) 33.73,84.29 34.07,83.95 34.07,83.55 33.72,83.19 33.36,83.19 32.44,82.28 32.44,78.65 34.98,76.11 36.24,76.11 36.59,75.76 36.59,75.36 35.55,74.33 35.55,63.15 35.28,62.88 35.28,55.03 v8(36.93,53.38)
  L3-GND w0.254: v3(32.28,84.54) 32.36,84.54 v8(32.61,84.29) ; v3(36.55,53.79) 36.55,53.76 v8(36.93,53.38)
  L4-SIG w0.254: v3(36.55,53.79) 35.97,53.21 35.97,42.33 40.26,38.04 40.26,26.62 44.54,22.34 46.49,22.34 46.92,22.77 49.07,22.77 v3(49.23,22.6)
  L6-GND w0.152: v6(57.92,32.92) 58.19,32.65 58.19,31.71 58.37,31.54 58.37,30.79 58.24,30.67 58.24,30.41
  L6-GND w0.203: 58.24,30.41 58.24,28.89 57.76,28.41 57.76,27.44 57.23,26.91 v4(57.23,26.3)
  L6-GND w0.254: v3(32.28,84.54) 31.93,84.54 v4(31.83,84.44)
  L7-SIG w0.203: v4(57.23,26.3) 57.23,22.21 58.47,20.96 58.47,20.47 58.12,20.12 58.12,20.08 57.6,19.57 52.56,19.57 52.19,19.94 52.19,20.43 52.22,20.45 52.22,21.85 51.6,22.48 50.22,22.48 v1(49.97,22.23)
  L7-SIG w0.254: v4(31.83,84.44) 30.33,82.94 v1(30.33,82.29)
  vias: v1(49.27,22.25) v1(49.62,22.24) v4(49.27,22.25) v4(49.62,22.24)
+V2P85S_EMMC: length 21.9
  L3-GND w0.254: v3(21.78,92.22) 21.77,92.24 v8(21.77,92.58)
  L6-GND w0.254: v1(21.62,91.85) 21.62,92.06 21.77,92.21 21.76,92.22 v3(21.78,92.22)
  L7-SIG w0.508: v1(21.62,91.85) 21.74,91.73 24.59,91.73 25.08,91.23 27.45,91.23 27.81,91.6 29.36,91.6 ; v1(30.22,91.73) 30.22,91.32 31.73,89.82 v1(31.73,89.23) 31.73,88.91 31.47,88.66 31.47,85.63 32.36,84.74 32.36,84.21 31.85,83.7 v1(31.85,83.15)
  BOTTOM w0.254: R1902.2 C1900.1 C1904.1 ; v1(21.62,91.85) C1915.1 C1916.1
  vias: v1(29.73,91.23) v1(32.22,89.73)
+V2P85S_FB: length 12.1
  L6-GND w0.06: 55.09,31.29 55.9,32.1 56.58,32.1 56.93,32.46 56.93,32.57 57.09,32.72 57.26,32.72 v6(57.47,32.94)
  L6-GND w0.102: 55.09,31.29 54.25,30.45 54.25,30.05 53.81,29.62 53.81,28.65 53.52,28.36 53.52,27.67 52.81,26.96 v4(52.83,26.96)
  L7-SIG w0.102: v1(51.21,23.96) 51.21,25.42 52.76,26.96 v4(52.83,26.96)
+V2P85S_LX0: length 4.1
  L6-GND w0.203: 57.13,31.68 57.49,32.05 v6(57.49,32.54)
  L6-GND w0.508: 57.13,31.68 56.34,30.89 56.34,29.58 56.11,29.35 56.11,29.05
  vias: v1(56.11,28.6) v1(56.11,28.28) v4(56.11,28.6) v4(56.11,28.28)
+V2P85S_LX1: length 4.4
  L6-GND w0.254: 56.13,31.7 56.48,31.7 57.16,32.38 v6(57.16,32.49)
  L6-GND w0.508: 54.31,29.5 54.76,29.95 54.76,30.34 56.13,31.7
  vias: v1(54.3,28.67) v1(54.3,28.36) v4(54.3,28.67) v4(54.3,28.36)
+V2P85SX: length 194.3
  L2-SIG w0.254: v8(16.55,110.39) 18.16,110.39 21.64,106.91 36.65,106.91 38.6,104.96 42.97,104.96 43.16,104.77 59.22,104.77 62.91,108.47 84.64,108.47 v2(86.45,106.66) ; v8(74.85,21.35) 74.77,21.27 v8(61.55,21.27)
  L3-GND w0.254: v3(75.21,21.35) 75.13,21.35 75.13,21.35 v8(74.85,21.35) ; v8(16.55,110.39) 16.43,110.39 v3(16.2,110.16) ; v8(61.55,21.27) 61.51,21.27 v3(61.28,21.04)
  L4-SIG w0.254: v3(86.89,23.51) 88.16,24.78 88.16,30.46 89.46,31.75 89.46,35.29 89.03,35.72 89.03,52.71 90.23,53.91 90.23,77.73 92,79.5 92,80.47 89.08,83.4 89.08,84.69 89.33,84.95 89.33,85.63 89.08,85.89 89.08,92.55 89.72,93.2 v3(89.72,98.56)
  L5-SIG w0.254: v3(86.89,23.51) 86.79,23.51 84.01,20.74 79.53,20.74 78.92,21.35 75.13,21.35 75.13,21.35 v3(75.21,21.35)
  L6-GND w0.254: v3(61.28,21.04) 61.28,21.04 61,20.76 v1(60.64,20.76) ; v4(89.72,99.06) v3(89.72,98.56) ; v1(15.84,110.16) v3(16.2,110.16)
  L7-SIG w0.254: v2(86.45,106.66) 87.2,105.91 87.2,105.9 89.72,103.38 v4(89.72,99.06)
  BOTTOM w0.102: v1(15.84,110.16) R2123.1 ; R8401.2 58.98,20.38 60.1,20.38 60.47,20.76 v1(60.64,20.76)
+V2P85SX_2M: length 18.7
  L7-SIG w0.305: v1(14.98,109.46) v1(14.98,110.14) v1(14.98,110.83) v1(15.72,110.83) 16.1,111.21 16.1,111.87 14.94,113.04 11.23,113.04 10.79,113.48 10.79,120.41 9.25,121.95 v1(9.25,122.25)
  BOTTOM w0.102: v1(14.98,110.14) R2123.2
+V2P85SX_CCD: length 92
  L2-SIG w0.254: v2(84.38,100.56) 84.38,104.87 81.15,108.11 63.06,108.11 59.34,104.39 42.86,104.39 42.65,104.6 38.28,104.6 36.37,106.51 21.46,106.51 18.8,109.18 17.22,109.18 v8(16.74,109.66)
  L3-GND w0.254: v8(16.74,109.66) 16.46,109.66 v3(16.23,109.43)
  L5-SIG w0.508: v2(84.38,100.56) 83.8,99.97 v2(78.6,99.97)
  L6-GND w0.254: v1(15.84,109.43) v3(16.23,109.43)
  BOTTOM w0.102: v1(15.84,109.43) R2132.1
  BOTTOM w0.254: v2(78.6,99.97) 78.78,99.97 79.33,99.43 80.26,99.43 81.69,98 81.69,96.52 R2129.1 C2125.1 U2101.5
+V2P85SX_PMIC: length 12.4
  L6-GND w0.203: v4(56.77,26.3) 56.77,27.01 57.28,27.52 57.28,28.41 57.84,28.97 57.84,30.71 58.09,30.96 58.09,31.48 57.92,31.65 v6(57.92,32.54)
  L7-SIG w0.203: v1(57.76,21.19) 56.92,22.03 56.92,26.15 v4(56.77,26.3)
+V3P3_EC: length 333.1
  L2-SIG w0.508: v2(28.68,45.5) 29.24,46.06 29.24,52.21 30.99,53.96 31.01,54.01 31.01,60.48 32.84,62.31 32.84,65.03 32.18,65.68 32.18,70.75 v2(29.73,73.2) 26.68,76.26 26.68,88.1 31.62,93.05 31.62,97.29 36.48,102.14 36.48,102.55
  L4-SIG w0.254: v3(36.75,68.97) 36.45,69.28 33.3,69.28 32.64,69.93 32.64,70.29 ; v3(87.7,68.37) 87.68,68.4 82.95,68.4 81.05,70.29 80.11,70.29 79.79,69.97 v3(79.79,69.73)
  L4-SIG w0.508: v3(36.64,103.4) 39.49,106.25 47.52,106.25 49.73,108.45 57.9,108.45 58.2,108.75 59.11,108.75 59.55,108.32 65.51,108.32 72.4,101.43 74.38,101.43 74.66,101.15 76.35,101.15 78.66,98.84 78.66,94.27 v3(78.74,94.19) 73.74,94.19 72.29,92.75 72.29,83.37 v3(74.5,81.16) ; v2(29.73,73.2) 32.64,70.29
  L5-SIG w0.254: v3(78.56,72.05) 78.56,70.96 v3(79.79,69.73) ; v3(75.82,75.48) 75.82,77.75 76.07,78.01 76.07,78.81 74.5,80.38 v3(74.5,81.16)
  L5-SIG w0.508: v3(78.74,94.19) 79.02,93.91 79.02,86.47 81,84.49 v3(81,84.01) ; 35.81,44.66 34.98,45.5 v2(28.68,45.5)
  L6-GND w0.254: v1(74.09,81.16) v3(74.5,81.16) ; v3(78.56,72.05) 78.22,72.05 78.22,72.05 v1(78.2,72.05) ; v1(79.27,69.61) 79.39,69.73 v3(79.79,69.73) ; v4(88.08,68.37) v3(87.7,68.37) ; v3(36.75,68.97) v1(36.75,69.81) ; v1(76.22,74.66) 75.82,75.06 v3(75.82,75.48) ; v1(80.47,83.46) 80.47,83.47 v3(81,84.01)
  L7-SIG w0.203: v1(3.35,71.61) 9.54,71.61 9.85,71.92 14.05,71.92 14.95,72.82 22.01,72.82 22.71,73.52 25.63,73.52 25.96,73.19 v1(26.82,73.19)
  L7-SIG w0.254: v1(38.84,7.07) 38.84,7.4 39.35,7.91 39.35,8.62 37.54,10.42 35.38,10.42 33.48,12.33 33.48,13.65 34.04,14.21 34.29,14.21 v1(35.05,14.97) ; v1(90.53,67.24) 89.41,68.36 88.08,68.36 v4(88.08,68.37) ; v1(72.55,62.73) 72.55,62.22 v1(71.91,61.58) 71.4,61.07 69.7,61.07 69.29,61.48 68,61.48 v1(67.87,61.35) 68.2,61.02 69.04,61.02 71.65,58.4 75.36,58.4 v1(75.77,58.81) ; v1(72.15,71.58) 72.25,71.58 73.06,72.4 74.12,72.4 75.77,74.05 75.77,74.22 v1(76.22,74.66) ; v1(75.39,62.85) 75.39,66.06 77.05,67.72 77.05,67.72 77.95,68.63 77.95,71.81 v1(78.2,72.05) ; v1(31.8,19.54) 30.96,19.54 v1(30.91,19.49)
  BOTTOM w0.203: C3006.1 U3001.38
  BOTTOM w0.229: 71.76,74.2 U3001.6 71.76,71.92 72.1,71.58 v1(72.15,71.58)
  BOTTOM w0.254: v1(75.39,62.85) 75.39,62.65 75.11,62.37 ; 75.11,62.37 75.53,61.95 76.39,61.95 76.68,61.66 76.68,60.79 R3081.2 77.47,60 77.47,59.42 77.19,59.14 76.1,59.14 v1(75.77,58.81) ; 75.11,62.37 74.5,62.37 74.3,62.57 C3004.1 C3006.1 73.76,62.55 73.74,62.52 R3082.2 73.25,62.47 73.01,62.47 72.98,62.49 72.98,62.49 R3060.2 ; 71.76,74.2 71.76,74.79 71.08,75.47 70.74,75.47 70.08,74.81 69.1,74.81 68.92,74.64 68.51,74.64 R3077.2 67.46,74.34 R3066.2 ; v1(80.47,83.46) 81.17,82.75 81.17,76.36 R3061.2 ; v1(31.8,19.54) 31.93,19.42 33.17,19.42 R8811.2 33.73,19.54 34.06,19.21 34.57,19.21 34.87,18.91 34.87,17.24 34.88,17.23 35.48,16.63 35.48,16.32 35.05,15.88 v1(35.05,14.97) ; v1(36.75,69.81) 36.76,69.82 Q3007.1 ; v2(28.68,45.5) 28.44,45.26 28.44,20.06 28.91,19.59 30.23,19.59 30.46,19.36 30.79,19.36 v1(30.91,19.49) ; v1(26.82,73.19) 29.72,73.19 v2(29.73,73.2) ; v1(78.2,72.05) 76.76,73.5 76.76,74.71
  vias: v1(37.08,44.84) v1(37.07,44.54) v3(36.65,44.82) v3(36.65,44.23) v4(37.08,44.84) v4(37.07,44.54) v8(36.35,103.11) v8(36.64,103.03)
