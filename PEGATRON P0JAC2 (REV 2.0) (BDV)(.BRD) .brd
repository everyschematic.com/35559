# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V1P2S on BOTTOM (solid shape): 54.37,63.53 54.4,63.48 54.45,63.44 54.45,63.34 54.34,63.24 54.31,63.2 54.15,63.04 54.15,62.35 53.62,61.82 52.6,61.82 52.35,61.38 52.35,60.02 52.33,60 51.78,60 51.74,60.05 51.74,61.48 52.22,61.95 52.22,61.96 52.61,62.35 53.26,62.35 53.4,62.49 53.4,62.49 53.62,62.72 53.62,62.81 53.68,62.88 53.71,62.96 53.72,63.01 53.74,63.04 53.76,63.04 53.92,63.15 53.97,63.34 53.97,63.36 53.99,63.39 54.01,63.39 54.06,63.41 54.11,63.44 54.15,63.48 54.18,63.53 54.19,63.56 54.36,63.56
+V1P2S_EDP_8622 on BOTTOM (solid shape): 76.28,19.49 76.28,19.03 76.18,18.93 73.76,18.93 73.48,19.21 72.82,19.21 72.72,19.31 72.72,19.44 72.8,19.52 73.53,19.52 73.69,19.67 76.1,19.67
+V1P2SX on BOTTOM (solid shape): 54.6,63.19 54.67,63.1 54.77,63.05 54.83,62.98 54.84,62.97 54.87,62.87 54.93,62.8 54.93,61.95 54.61,61.63 54.61,59.29 54.56,59.24 54.05,59.24 53.95,59.34 53.95,61.97 54.28,62.29 54.28,62.93 54.43,63.09 54.46,63.12 54.49,63.15 54.53,63.19
+V1P2SX on BOTTOM (solid shape): 44.48,72.82 45.03,72.82 45.1,72.79 45.13,72.72 45.29,72.46 45.6,72.48 45.63,72.5 45.65,72.49 45.72,72.56 45.76,72.57 45.82,72.57 45.91,72.48 45.91,72.37 45.84,72.29 45.8,72.2 45.8,72.18 45.75,72.14 45.7,72.14 45.59,72.12 45.5,72.06 45.47,72.03 45.44,71.99 45.29,71.99 45.23,72.04 44.37,72.04 44.37,72.04 44.25,72.04 43.92,72.37 43.92,72.49 43.8,72.49 43.79,72.5 43.39,72.5 43.31,72.58 43.31,73.1 43.33,73.13 44.18,73.13
+V1P2SX on L2-SIG (solid shape): 44.68,49.08 44.68,47.69 44.5,47.52 43.95,47.52 43.72,47.75 43.72,49.1 43.78,49.16 44.59,49.16
+V1P2SX on L6-GND (solid shape): 44.04,47.99 44.05,47.94 44.07,47.88 44.12,47.83 44.12,47.64 43.33,46.85 42.98,46.85 42.77,47.07 42.77,47.51 42.96,47.71 43.07,47.71 43.37,47.6 43.54,47.87 43.54,47.9 43.68,48.04 43.99,48.04
+V1P05S on BOTTOM (solid shape): 81.43,32.98 81.43,30.03 80.95,29.55 78.54,29.55 78.18,29.91 78.18,32.7 78.59,33.11 81.31,33.11
+V1P05S on BOTTOM (solid shape): 72.57,32.52 72.57,31.73 72.52,31.68 71.73,31.68 71.45,31.68 71.3,31.68 71.27,31.71 71.27,32.57 71.32,32.62 72.47,32.62
+V1P05S on BOTTOM (solid shape): 44.97,73.48 45.53,73.48 45.64,73.34 45.64,73.21 45.52,73.14 45.47,73.01 45.45,72.99 45.43,72.99 45.36,72.98 45.29,72.95 44.54,72.95 44.23,73.26 43.36,73.26 43.21,73.4 43.21,73.8 43.28,73.87 44.58,73.87
+V1P05S on BOTTOM (solid shape): 62.92,72.09 62.92,71.02 63,70.94 63.71,70.94 65.31,70.94 65.33,70.93 65.85,70.93 65.93,70.84 65.93,70.29 65.91,70.27 62.33,70.27 62.27,70.33 61.9,70.33 61.68,70.54 61.68,70.57 61.62,70.75 61.44,70.81 61.43,70.81 61.39,70.84 61.35,70.9 61.31,70.94 61.27,71.01 61.3,71.09 61.38,71.3 61.3,71.52 61.27,71.59 61.31,71.66 61.39,71.96 61.13,72.14 61.11,72.22 61.05,72.32 60.99,72.38 60.94,72.45 60.97,72.53 60.99,72.56 61.08,72.59 61.16,72.55 61.46,72.4 61.72,72.62 61.73,72.63 61.76,72.66 62.35,72.66
+V1P05S on L2-SIG (solid shape): 65.81,70.37 65.81,68.54 65.51,68.23 64.39,68.23 64.08,68.54 64.08,70.57 64.14,70.62 65.56,70.62
+V1P05S on L2-SIG (solid shape): 72.34,32.7 72.34,31.86 72.11,31.63 71.35,31.63 71.07,31.91 71.07,32.52 71.37,32.83 72.21,32.83
+V1P05S on L2-SIG (solid shape): 82.57,34.93 82.57,31.8 81.83,31.06 81.08,31.06 80.79,31.35 80.79,34.95 81.19,35.36 82.14,35.36
+V1P05S on L3-GND (solid shape): 65.63,70.62 65.63,69.5 65.48,69.35 64.26,69.35 64.08,69.53 64.08,70.65 64.26,70.82 65.43,70.82
+V1P05S on L3-GND (solid shape): 72.14,32.57 72.14,31.38 71.91,31.15 70.84,31.15 70.61,31.38 70.61,32.55 70.8,32.74 71.97,32.74
+V1P05S on L4-SIG (solid shape): outline of 464 points within 49.61,69.76 65.48,74.2
+V1P05S on L5-SIG (solid shape): 81.54,32.87 81.54,31.19 81.01,30.66 79.57,30.66 78.99,31.23 78.99,32.32 79.85,33.18 81.23,33.18
+V1P05S on L5-SIG (solid shape): 56.42,73.34 56.42,73.03 56.34,72.94 55.63,72.94 55.1,72.41 54.79,72.41 54.56,72.65 54.56,72.79 54.64,72.97 54.6,73.17 54.79,73.36 55.53,73.36 55.64,73.48 56.29,73.48
+V1P05S on L5-SIG (solid shape): 72.92,32.13 72.92,31.94 73.06,31.8 73.07,31.79 73.15,31.65 73.28,31.57 73.29,31.57 73.8,31.06 73.8,30.6 73.33,30.13 72.04,30.13 71.85,30.32 71.86,30.35 71.69,30.71 71.29,30.64 71.22,30.61 71.14,30.64 70.44,31.34 70.44,32.09 70.8,32.45 72.61,32.45
+V1P05S on L6-GND (solid shape): 72.52,32.5 72.52,31.66 72.14,31.28 70.92,31.28 70.59,31.61 70.59,32.12 71.12,32.65 72.37,32.65
+V1P05S on L7-SIG (solid shape): outline of 251 points within 53.18,72.44 56.43,74.06
+V1P05S_LX on BOTTOM (solid shape): 66.45,34.79 66.45,33.07 66.39,33.01 65.82,33.01 65.79,33.04 65.79,34.85 65.89,34.95 66.29,34.95
+V1P05S_LX on L6-GND (solid shape): 61.54,34.05 62.18,34.05 62.21,34.07 62.59,34.07 62.79,33.87 62.79,33.74 62.66,33.61 62.1,33.61 62,33.72 61.34,33.72 61.06,33.99 61.06,34.12 61.14,34.2 61.39,34.2
+V1P05S_PMIC on BOTTOM (solid shape): 70.94,33.87 71.12,33.69 71.12,31.86 70.99,31.73 70.36,31.73 70.31,31.79 70.31,32.47 70.27,32.51 69.08,32.51 68.61,32.98 67.97,32.98 67.82,33.13 67.82,34.55 68.12,34.86 70.94,34.86
+V1P8_EC on BOTTOM (solid shape): 66.98,68.36 66.98,68.18 67.54,68.18 67.67,68.06 69.09,68.06 69.11,68.03 69.11,67.88 69.09,67.85 67.67,67.85 67.64,67.83 67.64,67.68 67.67,67.65 69.06,67.65 69.09,67.62 69.09,67.55 68.99,67.45 67.46,67.45 67.41,67.5 67.41,67.7 67.35,67.76 66.81,67.76 66.57,68.01 66.57,68.39 66.65,68.46 66.88,68.46
+V1P8A on BOTTOM (solid shape): 47.09,38.8 47.09,38.59 46.8,38.3 46.8,37.77 46.71,37.68 46.1,37.68 45.97,37.8 45.97,38.59 45.85,38.72 45.85,38.92 45.86,38.93 45.86,39.02 46,39.17 46.72,39.17
+V1P8A_G3 on BOTTOM (solid shape): 59.73,63.14 59.78,63.1 59.84,63.08 59.86,63.07 59.9,63.02 59.9,63.01 60.03,62.76 60.31,62.72 60.62,62.72 60.74,62.67 60.76,62.67 61.61,61.82 61.61,60.31 61.33,60.03 60.94,60.03 60.83,60.13 60.83,61.53 59.52,62.84 59.52,63.07 59.6,63.15 59.72,63.15
+V1P8A_LX on BOTTOM (solid shape): 51.84,36.38 51.84,34.48 51.74,34.38 51,34.38 50.78,34.6 50.78,36.33 50.85,36.41 51.82,36.41
+V1P8A_LX on BOTTOM (solid shape): 54.9,35.26 55.69,35.26 55.83,35.11 55.93,35.11 56.01,35.04 56.01,34.94 55.92,34.86 54.53,34.86 54.19,35.2 54.19,35.58 54.26,35.65 54.51,35.65
+V1P8A_PMIC on BOTTOM (solid shape): 47.92,36.78 47.92,36.34 47.98,36.28 49.53,36.28 49.78,36.03 49.78,34.55 49.61,34.38 48.82,34.38 48.81,34.36 47.77,34.36 47.47,34.07 46.79,34.07 46.74,34.12 46.74,35.04 46.42,35.35 46.42,36.19 46.3,36.31 46,36.31 45.87,36.43 45.87,36.81 45.92,36.87 47.83,36.87
+V1P8S_EMMC on L7-SIG (solid shape): 33.27,83.5 33.27,82.89 33.66,82.51 33.66,82.18 33.6,82.13 32.67,82.13 32.54,82.25 32.54,82.61 32.26,82.89 32.26,83.15 32.38,83.15 32.39,83.1 32.4,83.06 32.42,83.01 32.45,82.97 32.48,82.94 32.52,82.91 32.56,82.89 32.61,82.88 32.65,82.87 32.7,82.87 32.75,82.88 32.79,82.9 32.83,82.93 32.87,82.96 32.9,82.99 32.92,83.04 32.94,83.08 32.94,83.13 32.94,83.17 32.94,83.22 32.92,83.27 32.9,83.31 32.87,83.35 32.83,83.38 32.79,83.4 32.75,83.42 32.7,83.43 32.65,83.43 32.61,83.43 32.56,83.41 32.52,83.39 32.48,83.36 32.45,83.33 32.42,83.29 32.4,83.24 32.39,83.2 32.38,83.15 32.26,83.15 32.26,83.35 32.56,83.65 33.12,83.65
+V1P8S_EMMC on L7-SIG (solid shape): outline of 139 points within 26.44,87.87 28.88,89.85
+V1P8S_S4 on BOTTOM (solid shape): 45.17,71.87 45.22,71.82 45.41,71.82 45.42,71.81 45.52,71.65 45.69,71.6 45.72,71.6 45.77,71.56 45.77,71.55 45.8,71.49 45.84,71.43 45.88,71.4 45.95,71.36 45.95,71.27 45.93,71.26 45.86,71.22 45.81,71.16 45.72,71.16 45.7,71.18 45.63,71.26 45.54,71.32 45.53,71.32 45.39,71.34 45.25,71.29 45.21,71.25 44.63,71.25 43.75,70.37 43.43,70.37 43.33,70.47 43.33,71.69 43.45,71.8 44.04,71.8 44.15,71.91 45.13,71.91
+V1P8S_S4 on BOTTOM (solid shape): 45.75,69.18 45.8,69.17 45.84,69.15 45.9,69.1 45.92,69.06 45.92,69.01 45.86,68.94 45.82,68.86 45.81,68.82 45.77,68.76 45.62,68.73 45.55,68.69 45.49,68.63 45.45,68.55 45.45,68.54 45.43,68.52 45.4,68.51 45.37,68.5 45.25,68.46 45.11,68.46 44.79,68.13 43.26,68.13 43.26,68.64 43.31,68.69 44.21,68.69 44.52,69 45.61,69
+V1P8S_SENSOR on BOTTOM (solid shape): 35.59,99.86 35.59,97.62 35.48,97.52 35.03,97.52 34.93,97.62 34.93,99.81 35,99.88 35.56,99.88
+V1P8S_SENSOR on BOTTOM (solid shape): 30.25,101.1 30.91,101.1 30.96,101.05 30.96,100.57 30.91,100.52 30.76,100.52 30.61,100.67 29.95,100.67 29.52,101.1 28.83,101.1 28.8,101.13 28.8,101.61 28.86,101.66 29.69,101.66
+V1P8S_SENSOR on BOTTOM (solid shape): 30.73,98.84 30.73,98.69 30.66,98.61 30.05,98.61 29.97,98.54 29.97,98.16 29.72,97.9 29.72,97.83 29.46,97.57 28.88,97.57 28.83,97.62 28.83,98.16 28.85,98.18 29.44,98.18 29.46,98.18 29.62,98.33 29.62,98.53 29.95,98.86 30.71,98.86
+V1P8U on BOTTOM (solid shape): 40.16,102.7 40.16,101.53 40.08,101.46 39.22,101.46 39.18,101.42 39.09,101.42 39.09,101.33 39.07,101.3 38.74,101.3 38.74,101.72 38.58,101.72 38.58,102.7 38.71,102.83 40.03,102.83
+V1P8U_PMIC on BOTTOM (solid shape): 36.89,65.43 36.89,63.29 36.7,63.1 35.94,63.1 35.87,63.18 35.87,64.02 36.04,64.2 36.22,64.2 36.35,64.32 36.35,64.6 36.25,64.7 35.56,64.7 35.48,64.78 35.48,65.26 35.69,65.47 36.86,65.47
+V2P85S on BOTTOM (solid shape): 51.16,23.15 51.16,22.69 51,22.54 50.44,22.54 49.98,22.08 48.26,22.08 48.11,22.23 48.11,22.77 48.35,23.01 49.04,23.01 49.05,23.02 49.63,23.02 49.84,23.23 51.08,23.23
+V2P85S_EMMC on L7-SIG (solid shape): 30.48,91.86 30.48,91.2 30.35,91.07 29.52,91.07 29.13,91.45 29.13,91.88 29.24,91.98 30.35,91.98
+V2P85S_EMMC on L7-SIG (solid shape): 32.01,90.05 32.15,89.96 32.32,89.97 32.35,89.98 32.41,89.93 32.41,89.24 31.88,88.71 31.19,88.71 30.94,88.96 30.94,89.05 31.01,89.05 31.03,89.04 31.5,89.19 31.09,89.48 30.99,89.48 30.94,89.57 30.94,89.93 31.06,90.05
+V2P85S_LX0 on BOTTOM (solid shape): 56.46,28.71 56.46,27.09 56.31,26.93 55.93,26.93 55.75,27.11 55.75,28.61 55.91,28.76 56.41,28.76
+V2P85S_LX1 on BOTTOM (solid shape): 54.57,28.65 54.57,27.05 54.39,26.87 53.89,26.87 53.84,26.92 53.84,28.72 53.94,28.83 54.39,28.83
+V2P85S_LX1 on L6-GND (solid shape): 54.76,29.6 54.79,29.51 54.74,29.44 54.55,29.05 54.88,28.76 54.91,28.75 54.93,28.71 54.93,28.15 54.78,28 54.29,28 54.04,28.25 54.04,29.63 54.23,29.82 54.54,29.82
+V2P85S_PMIC on BOTTOM (solid shape): 56.82,32.17 56.82,32.12 56.79,32.1 56.79,32.09 56.69,31.99 56.69,31.93 56.67,31.91 56.62,31.86 56.59,31.8 56.58,31.79 55.72,30.92 55.47,30.92 54.99,30.44 54.99,30.24 53.71,28.95 53.67,28.95 53.67,28.92 53.47,28.71 53.47,26.89 52.99,26.4 52.99,23.25 52.55,22.82 51.51,22.82 51.51,23.52 51.52,23.52 51.52,24.41 51.51,24.41 51.51,27.85 51.54,27.87 51.96,27.87 52.71,28.62 52.71,29.38 54.32,31 54.61,31 54.86,31.24 55.65,31.24 55.95,31.54 56.33,31.92 56.39,31.93 56.41,31.94 56.49,31.99 56.53,32.08 56.54,32.13 56.58,32.17 56.61,32.22 56.77,32.22
+V3P3_EC on BOTTOM (solid shape): 68.2,62.47 68.2,61.22 68.28,61.15 68.28,60.66 68.23,60.61 67.69,60.61 67.54,60.77 67.54,62.47 67.64,62.57 68.1,62.57
+V3P3_EC on BOTTOM (solid shape): 38.46,44.5 38.46,44.08 38.36,43.98 38,43.98 37.94,44.05 37.35,44.05 37.34,44.05 37.05,44.05 36.97,44.13 36.97,44.98 37.01,45.03 37.93,45.03
+V3P3_EC on BOTTOM (solid shape): 76.93,74.79 76.93,74.41 76.88,74.36 76.18,74.36 75.98,74.16 75.98,73.81 75.87,73.7 75.87,72.2 75.85,72.17 75.67,72.17 75.65,72.18 75.65,73.66 75.59,73.72 75.59,74.2 75.69,74.31 75.75,74.31 75.75,74.74 75.92,74.91 76.81,74.91
+V3P3_EC on L5-SIG (solid shape): 36.98,45.12 36.98,43.93 36.83,43.77 36.09,43.77 35.31,44.56 35.31,45.15 35.54,45.37 36.73,45.37
+V3P3A on BOTTOM (solid shape): 2.16,89.14 2.16,87.03 2.03,86.9 1.32,86.9 1.22,87 1.22,89.09 1.32,89.19 2.11,89.19
+V3P3A on BOTTOM (solid shape): 42.67,37.65 42.67,36.66 43.05,36.66 43.13,36.59 43.13,36.33 43,36.2 41.38,36.2 41.2,36.38 41.2,37.86 41.3,37.96 42.37,37.96
+V3P3A on L2-SIG (solid shape): 2.4,73.76 2.4,71.33 2.29,71.23 1.41,71.23 1.27,71.37 1.27,73.82 1.41,73.97 2.19,73.97
+V3P3A on L2-SIG (solid shape): 23.06,6.84 23.06,5.55 22.86,5.34 21.64,5.34 21.44,5.55 21.44,6.87 21.54,6.97 22.94,6.97
+V3P3A on L2-SIG (solid shape): 2.32,88.44 2.32,87.08 1.65,87.08 1.3,87.44 1.3,88.58 1.5,88.78 1.98,88.78
+V3P3A on L3-GND (solid shape): 2.26,88.66 2.26,87.79 2.13,87.67 1.4,87.67 1.27,87.79 1.27,88.68 1.37,88.78 2.13,88.78
+V3P3A on L4-SIG (solid shape): 57.07,23.76 57.07,23.12 56.72,22.77 54.92,22.77 54.69,23 54.69,23.73 54.94,23.99 56.85,23.99
+V3P3A on L5-SIG (solid shape): 56.49,23.33 56.49,22.49 56.08,22.08 54.38,22.08 53.8,22.67 53.8,23.76 54.13,24.09 55.73,24.09
+V3P3A on L5-SIG (solid shape): 23.09,6.84 23.09,4.43 22.01,4.43 21.95,4.49 21.95,5.63 21.57,6.02 21.57,6.92 21.67,7.02 22.91,7.02
+V3P3A on L6-GND (solid shape): 2.27,88.39 2.27,87.08 2.2,87 1.32,87 1.27,87.06 1.27,88.4 1.37,88.5 2.16,88.5
+V3P3A on L6-GND (solid shape): 56.72,22.84 56.72,22.11 56.44,21.83 55.5,21.83 54.89,22.44 54.89,23.2 55.09,23.4 56.16,23.4
+V3P3A on L6-GND (solid shape): 43.28,38.59 43.28,37.91 42.88,37.5 41.5,37.5 41.3,37.7 41.3,37.88 41.48,38.06 42.11,38.06 42.22,38.16 42.27,38.2 42.31,38.25 42.77,38.72 43.16,38.72
+V3P3A_LX0 on BOTTOM (solid shape): 59.18,32.66 59.23,32.65 59.26,32.61 59.26,32.58 59.25,32.54 59.26,32.47 59.29,32.41 59.29,32.4 59.29,32.28 59.29,32.26 59.25,32.14 59.29,32.01 59.29,32 59.29,30.9 60.15,30.03 60.15,26.86 60.15,26.86 59.35,26.86 59.23,26.98 59.23,28.58 59.67,29.02 59.67,30.08 59.03,30.72 59.03,31.7 59.04,31.83 58.99,31.95 58.99,32.1 58.98,32.2 58.94,32.29 58.92,32.34 58.93,32.37 58.98,32.49 58.98,32.61 59.01,32.65 59.06,32.66
+V3P3A_LX1 on BOTTOM (solid shape): 58.46,32.21 58.46,32.18 58.45,32.12 58.47,32.05 58.47,31.74 58.5,31.71 58.5,30.24 58.5,30.24 58.5,30.08 58.85,29.73 58.85,26.91 58.78,26.83 57.52,26.83 57.42,26.93 57.42,28.62 58.22,29.42 58.22,31 58.2,31.02 58.2,31.28 58.21,31.29 58.21,31.58 58.26,31.77 58.21,31.96 58.23,32.01 58.28,32.04 58.27,32.1 58.3,32.15 58.41,32.26
+V3P3A_PMIC on BOTTOM (solid shape): 58.09,30.95 58.09,29.52 57.66,29.09 57.51,29.09 57.2,28.79 57.2,26.02 57.38,25.84 57.38,21.73 57.3,21.65 56.74,21.65 56.69,21.7 56.69,21.9 56.72,21.93 56.72,22.46 56.41,22.77 54.81,22.77 54.71,22.87 54.71,25.82 54.81,25.92 55.17,25.92 55.35,25.74 55.35,25.31 55.53,25.13 56.08,25.13 56.36,25.41 56.36,25.94 56.67,26.25 56.67,29.09 57.29,29.71 57.41,29.71 57.41,29.84 57.58,30.01 57.58,31 57.66,31.07 57.96,31.07
+V3P3S on BOTTOM (solid shape): 88.24,63.61 88.24,62.44 87.99,62.19 86.06,62.19 86.01,62.24 86.01,62.72 86.08,62.8 86.92,62.8 87.15,63.03 87.15,63.61 87.25,63.71 88.14,63.71
+V3P3S on BOTTOM (solid shape): 90.78,110.04 90.78,109.41 90.7,109.33 89.13,109.33 89.05,109.41 89.05,109.99 89.15,110.09 90.73,110.09
+V3P3S on BOTTOM (solid shape): 37.67,47.17 37.67,46.94 37.76,46.85 38.42,46.85 38.67,46.6 38.67,46.32 38.4,46.05 37.15,46.05 37.06,46.14 37.06,46.15 36.78,46.43 36.78,47.21 36.79,47.21 37.63,47.21
+V3P3S on BOTTOM (solid shape): 52.99,19.29 52.99,18.5 53.06,18.42 53.26,18.42 53.34,18.35 53.34,17.94 53.24,17.84 52.35,17.84 52.25,17.94 52.25,18.75 52.17,18.83 51.89,18.83 51.77,18.96 51.77,19.31 51.87,19.42 52.86,19.42
+V3P3S on BOTTOM (solid shape): 85,8.56 85,7.57 84.91,7.47 84.89,7.47 84.81,7.4 83.18,7.4 83.14,7.41 83.1,7.4 82.95,7.55 82.95,7.91 83.08,8.04 83.94,8.04 84.11,8.21 84.11,8.4 84.32,8.61 84.95,8.61
+V3P3S on BOTTOM (solid shape): 88.6,9.24 88.6,7.38 88.52,7.3 87.14,7.3 87.13,7.31 87.05,7.35 86.96,7.35 86.94,7.35 86.8,7.49 86.8,7.75 86.85,7.8 87.49,7.8 87.72,8.03 87.72,8.45 87.73,8.46 87.73,9.22 87.91,9.4 88.44,9.4
+V3P3S on BOTTOM (solid shape): 81.18,9.99 81.18,9.53 81.05,9.41 79.82,9.41 79.6,9.19 79.6,9.05 79.6,8.31 79.86,8.31 79.98,8.19 79.98,7.52 79.88,7.42 79.68,7.42 79.68,7.43 79.51,7.59 79.51,7.61 79.43,7.78 79.27,7.85 79.25,7.86 78.66,8.44 78.66,9.17 79.43,9.17 79.43,10.07 79.49,10.13 81.04,10.13
+V3P3S on L2-SIG (solid shape): 52.3,20.84 52.3,19.92 52.12,19.75 51.28,19.75 50.9,20.13 50.9,20.89 51.05,21.04 52.1,21.04
+V3P3S on L2-SIG (solid shape): 33.69,59.09 33.69,58.38 33.39,58.09 33.39,57.21 32.08,57.21 32.08,58.68 32.94,59.54 33.23,59.54
+V3P3S on L2-SIG (solid shape): 88.72,61.37 88.42,61.07 87.2,61.07 87.02,61.25 87.02,62.63 87.6,63.2 88.72,63.2
+V3P3S on L2-SIG (solid shape): 90.88,110.07 90.88,108.85 90.5,108.47 88.9,108.47 88.27,109.1 88.27,109.94 88.57,110.25 90.7,110.25
+V3P3S on L2-SIG (solid shape): 34.51,49.44 34.51,47.74 34.34,47.56 33.19,47.56 32.84,47.91 32.84,49.34 33.1,49.59 34.37,49.59
+V3P3S on L2-SIG (solid shape): 37.21,46.37 37.21,44.43 37.3,44.25 37.5,44.21 37.53,44.22 38.02,43.72 38.02,43.55 38.18,43.39 38.18,42.73 37.82,42.38 37.29,42.38 37.29,42.38 36.65,42.38 35.6,43.42 35.6,43.98 35.28,44.3 35.28,47.07 35.52,47.3 36.28,47.3
+V3P3S on L2-SIG (solid shape): 50.56,107.12 50.63,107.09 50.66,107.02 50.89,106.79 51.12,107.02 51.15,107.09 51.22,107.12 52.16,107.12 52.23,107.09 52.26,107.02 52.29,106.9 52.38,106.82 52.38,105.14 52.25,105.01 50.19,105.01 50.04,105.17 50.04,107.02 50.14,107.12
+V3P3S on L3-GND (solid shape): 52.65,20.36 52.65,19.31 52.48,19.14 51.64,19.14 51.33,19.44 51.33,20.48 51.44,20.58 52.43,20.58
+V3P3S on L3-GND (solid shape): 88.52,62.8 88.52,61.83 88.32,61.63 87.48,61.63 87.2,61.91 87.2,62.82 87.3,62.93 88.39,62.93
+V3P3S on L3-GND (solid shape): 51.77,105.88 51.77,105.11 51.72,105.06 50.09,105.06 49.94,105.22 49.94,105.78 50.17,106 51.64,106
+V3P3S on L3-GND (solid shape): 38.21,43.34 38.21,42.73 38.03,42.55 37.24,42.55 36.96,42.83 36.96,43.34 37.14,43.52 38.03,43.52
+V3P3S on L3-GND (solid shape): 37.29,46.14 37.29,45.84 37.15,45.69 36.64,45.69 36,46.33 35.53,46.33 35.37,46.48 35.37,46.97 35.46,47.06 36.37,47.06
+V3P3S on L3-GND (solid shape): 34.15,48.28 34.15,48.06 34.25,47.96 34.41,47.96 34.5,47.87 34.5,47.72 34.45,47.67 33.54,47.67 33.42,47.54 33.16,47.54 33.06,47.65 33.06,48.19 33.22,48.36 34.08,48.36
+V3P3S on L4-SIG (solid shape): 88.62,62.98 88.62,61.99 88.42,61.78 87.35,61.78 86.97,62.16 86.97,62.72 87.3,63.05 88.55,63.05
+V3P3S on L5-SIG (solid shape): 51.69,105.83 51.69,104.97 51.62,104.9 48.8,104.9 48.67,105.03 48.67,105.9 48.79,106.03 51.49,106.03
+V3P3S on L5-SIG (solid shape): 37.34,46.53 37.34,45.73 37.23,45.62 36.42,45.62 34.95,47.1 32.52,47.1 32.24,47.38 32.24,48.33 32.49,48.58 35.29,48.58
+V3P3S on L6-GND (solid shape): 40.84,100.42 40.84,99.6 40.51,99.27 40.41,99.27 39.95,99.73 39.95,100.49 40.06,100.59 40.67,100.59
+V3P3S on L6-GND (solid shape): 52.88,19.47 52.88,18.93 52.65,18.7 51.66,18.7 51.49,18.88 51.49,19.52 51.64,19.67 52.68,19.67
+V3P3S on L6-GND (solid shape): 88.32,63.03 88.32,62.34 88.16,62.19 87.3,62.19 87.12,62.37 87.12,63 87.2,63.08 88.27,63.08
+V3P3S on L6-GND (solid shape): 32.85,48.35 32.85,48.1 32.91,48.03 33.43,48.03 33.6,47.86 33.6,47.34 33.46,47.2 32.35,47.2 32.15,47.4 32.15,47.92 32.15,47.92 32.15,48.24 32.39,48.47 32.72,48.47
+V3P3S on L6-GND (solid shape): 37.5,46.99 37.5,46.03 37.16,45.69 36.8,45.69 36.72,45.77 36.63,45.81 36.41,46.02 36.41,46.76 36.6,46.95 36.61,46.95 36.87,47.2 37.29,47.2
+V3P3S on L7-SIG (solid shape): 33.17,47.56 34.25,47.56 34.57,47.23 34.57,46.92 34.52,46.87 32.71,46.87 32.36,47.23 32.22,47.23 32.14,47.31 32.14,47.88 32.18,47.92 32.81,47.92
+V3P3S_S4 on BOTTOM (solid shape): 45.77,68.06 45.85,68.03 45.89,68 45.93,67.98 45.97,67.97 45.97,67.88 45.93,67.87 45.83,67.79 45.77,67.68 45.76,67.65 45.72,67.61 45.7,67.61 45.55,67.55 45.45,67.42 45.45,67.41 45.43,67.39 45.4,67.38 45.3,67.35 45.21,67.29 45.03,67.29 44.86,67.47 43.44,67.47 43.38,67.54 42.54,67.54 42.52,67.56 42.52,67.88 42.58,67.94 45.23,67.94 45.48,67.88 45.69,68.02
+V3P3S_SD on BOTTOM (solid shape): 89.82,63.46 89.82,61.25 89.69,61.12 88.7,61.12 88.6,61.22 88.6,63.64 88.75,63.79 89.48,63.79
+V3P3S_SD on BOTTOM (solid shape): 87.33,67.68 89.61,67.68 89.74,67.55 89.74,67.27 89.56,67.09 86.37,67.09 86.3,67.02 85.44,67.02 85.34,67.12 85.34,67.62 85.55,67.83 87.17,67.83
+V3P3S_SD on L7-SIG (solid shape): 87.48,68.16 87.48,67.29 87.4,67.22 85.56,67.22 85.09,67.69 85.09,68.11 85.21,68.23 86.18,68.23 86.18,68.23 87.4,68.23
+V3P3S_SENSOR on TOP (solid shape): 92.41,116.95 92.41,115.55 92.08,115.22 91.47,115.22 91.26,115.43 91.26,116.98 91.34,117.05 92.3,117.05
+V3P3S_SENSOR on BOTTOM (solid shape): 92.53,116.27 92.53,112.61 90.17,110.25 89.1,110.25 89.03,110.32 89.03,110.86 88.8,111.08 87.54,111.08 87.48,111.14 87.48,111.66 87.7,111.88 88.26,111.88 88.27,111.87 89.74,111.87 91.31,113.45 91.31,116.34 91.39,116.42 92.38,116.42
+V3P3SX on L2-SIG (solid shape): 34.11,58.07 34.11,56.17 33.58,56.17 33.52,56.23 33.52,58.03 33.61,58.12 34.06,58.12
+V3P3SX on L3-GND (solid shape): 34.1,58.08 34.32,57.91 34.6,57.95 34.8,57.95 34.98,57.77 34.98,57.62 34.67,57.31 33.81,57.31 33.58,57.54 33.58,58.18 34.01,58.18
+V3P3SX on L6-GND (solid shape): 46.03,20.05 46.03,19.7 45.77,19.44 44.96,19.44 44.78,19.62 44.78,20.15 44.93,20.3 45.78,20.3
+V3P3SX_G3 on BOTTOM (solid shape): 59.13,63.26 59.13,63.26 59.17,63.22 59.21,63.15 59.28,63.11 59.31,63.1 59.35,63.09 59.39,63.05 59.39,62.79 60.71,61.48 60.71,60.79 60.63,60.72 60.3,60.72 60.07,60.95 60.07,61.35 60.05,61.35 58.74,62.66 58.74,62.83 58.8,62.94 58.81,63.07 58.75,63.2 58.64,63.29 58.62,63.3 58.62,63.43 58.65,63.45 58.67,63.48 58.7,63.52 58.73,63.55 58.84,63.55
+V5P0S on BOTTOM (solid shape): 49.07,19.24 49.07,18.22 49.68,17.61 49.68,14.79 49.51,14.61 48.82,14.61 48.39,15.05 48.39,16.8 48.03,17.15 48.03,19.39 48.11,19.47 48.84,19.47
+V5P0S on L4-SIG (solid shape): 30.47,53.08 30.47,52.92 30.35,52.66 30.47,52.4 30.47,51.91 30.15,51.6 29.97,51.6 29.34,52.23 29.34,53.09 29.49,53.24 30.3,53.24
+V5P0S on L6-GND (solid shape): 30.6,53.38 30.6,53 30.44,52.9 30.36,52.72 30.06,52.43 29.77,52.43 29.41,52.79 29.41,53.34 29.3,53.45 29.3,53.64 29.38,53.72 30.26,53.72
+V5P0S on L7-SIG (solid shape): 32.8,59.35 32.8,58.96 33.07,58.68 33.07,58.12 32.91,57.96 32.03,57.96 31.83,58.16 31.83,59.33 31.9,59.41 32.74,59.41
+V5P0S on L7-SIG (solid shape): 31.9,55.1 31.9,54.62 30.74,53.45 29.24,53.45 29.16,53.53 29.16,54.37 29.26,54.47 30.15,54.47 30.23,54.54 30.4,54.62 30.48,54.79 30.94,55.25 31.75,55.25
+V5P0S_AUD on BOTTOM (solid shape): 31.63,64.49 31.72,64.35 31.86,64.26 32.02,64.1 32.02,63.88 31.88,63.74 31.65,63.74 31.47,63.91 31.47,63.99 31.19,64.27 30.73,64.27 30.71,64.25 30.1,64.25 30.1,64.45 30.73,64.45 30.78,64.5 31.62,64.5
+V5P0S_LX on BOTTOM (solid shape): 60.45,32.57 60.45,32.01 61.01,31.45 61.54,31.45 62.26,30.74 63.09,30.74 63.17,30.67 63.17,30.52 63.67,30.02 64.14,30.02 64.14,30.02 64.3,30.02 64.88,30.59 65.28,30.59 65.36,30.51 65.36,29.65 64.54,28.84 63.25,28.84 60.2,31.89 60.2,32.57 60.25,32.62 60.4,32.62
+V5P0S_O on BOTTOM (solid shape): 49.84,19.39 49.84,18.63 51.21,17.26 51.56,17.26 51.89,16.93 51.89,16.29 51.13,15.53 51.13,14.72 50.95,14.54 50.24,14.54 50.09,14.69 50.09,17.54 49.3,18.32 49.3,19.36 49.4,19.47 49.76,19.47
+V5P0S_O on L7-SIG (solid shape): 61.83,20.79 63.42,20.79 63.53,20.69 63.53,20.15 63.45,20.08 61.75,20.08 61.68,20.14 61.47,20.14 61.46,20.16 61.42,20.19 61.38,20.21 61.34,20.22 61.29,20.23 61.25,20.22 61.2,20.21 61.17,20.2 60.68,20.2 60.56,20.32 60.25,20.32 60.02,20.54 60.02,20.76 60.39,20.76 60.39,20.71 60.41,20.67 60.43,20.62 60.45,20.59 60.49,20.56 60.52,20.53 60.57,20.51 60.61,20.5 60.66,20.5 60.7,20.51 60.75,20.52 60.79,20.54 60.82,20.57 60.85,20.61 60.87,20.64 60.89,20.69 60.9,20.73 60.9,20.78 60.89,20.82 60.87,20.87 60.85,20.91 60.82,20.94 60.79,20.97 60.75,20.99 60.7,21 60.66,21.01 60.61,21.01 60.57,21 60.52,20.98 60.49,20.95 60.45,20.92 60.43,20.89 60.41,20.84 60.39,20.8 60.39,20.76 60.02,20.76 60.02,21.35 59.87,21.5 59.19,21.5 59.04,21.66 59.04,22.29 59.31,22.56 60.06,22.56
+V5P0S_PMIC on BOTTOM (solid shape): 60.04,32.6 60.04,31.84 60.95,30.93 60.96,30.93 62.47,29.42 62.47,26.66 62.65,26.48 62.65,24.88 62.41,24.64 62.41,23.1 62.01,22.7 62,22.69 62,21.6 61.67,21.27 60.5,21.27 60.22,21.55 60.22,22.82 61.1,23.7 61.1,30.19 59.81,31.48 59.81,32.6 59.86,32.65 59.99,32.65
+V5P0S_SUS on BOTTOM (solid shape): 74.85,49.9 74.85,47.71 74.12,46.97 72.95,46.97 72.9,47.03 72.9,48.47 72.82,48.55 72.47,48.55 72.29,48.73 72.29,50.76 72.24,50.81 70.77,50.81 70.59,50.99 70.59,51.95 70.71,52.08 72.67,52.08
+VCC_LX0 on BOTTOM (solid shape): 61.21,42.61 61.21,42.2 60.88,41.87 59.44,41.87 59.28,42.02 59.28,42.63 59.36,42.71 61.11,42.71
+VCC_LX1 on BOTTOM (solid shape): 64.61,42.9 64.61,42.71 63.75,41.84 61.72,41.84 61.49,42.07 61.49,42.45 61.72,42.68 63.2,42.68 63.68,43.16 64.35,43.16
+VCC_LX1 on BOTTOM (solid shape): 61.53,39.01 61.53,38.4 61.11,37.98 61.09,37.98 60.93,37.89 60.88,37.71 60.87,37.66 60.83,37.62 60.61,37.62 60.57,37.66 60.56,37.71 60.56,37.76 60.55,37.82 60.55,37.96 60.96,38.37 60.96,38.97 61.14,39.15 61.39,39.15
+VCC_LX2 on BOTTOM (solid shape): 63.27,39.56 63.27,39.1 62.99,38.82 62.79,38.82 62.05,38.09 62.05,37.18 61.68,36.8 61.44,36.8 61.4,36.84 61.39,36.89 61.39,36.99 61.42,37.07 61.5,37.1 61.67,37.14 61.76,37.29 61.76,37.59 61.76,37.59 61.76,38.91 62.09,39.24 62.44,39.24 62.44,39.34 62.45,39.34 62.45,39.54 62.56,39.66 63.17,39.66
+VCC_LX3 on BOTTOM (solid shape): 62.79,36.92 62.79,36.51 62.3,36.02 61.43,36.02 61.39,36.05 61.39,36.12 61.54,36.27 61.87,36.27 62.57,36.97 62.74,36.97
+VCC_LX3 on BOTTOM (solid shape): 66.27,39.68 66.27,37.65 66.19,37.58 65.58,37.58 65.38,37.78 65.38,38.73 65.18,38.94 64.66,38.94 64.56,39.04 64.56,39.46 64.84,39.74 66.22,39.74
+VCC_LX4 on BOTTOM (solid shape): 66.29,37.09 66.29,35.42 66.14,35.26 65.41,35.26 65.28,35.39 65.28,37.02 65.46,37.2 66.19,37.2
+VCC_LX4 on BOTTOM (solid shape): 63.75,35.57 63.75,35.24 63.69,35.18 61.6,35.18 61.55,35.19 61.45,35.19 61.41,35.23 61.4,35.28 61.4,35.37 61.45,35.42 61.56,35.42 61.83,35.42 61.9,35.44 62.68,35.44 62.87,35.62 63.7,35.62
+VDDIO on L6-GND (solid shape): 69.24,13.37 69.24,12.86 69.14,12.76 67.89,12.76 67.69,12.96 67.69,13.27 67.87,13.45 69.16,13.45
+VDDQ on BOTTOM (solid shape): 45.82,31.18 45.82,30.24 44.66,30.24 44.58,30.32 44.32,30.32 43.9,30.74 43.9,31.65 44.16,31.91 45.09,31.91
+VDDQ on BOTTOM (solid shape): 55.98,34.22 55.98,34.07 55.92,34.01 54.75,34.01 54.18,33.44 51.56,33.44 51.51,33.49 48.87,33.49 48.64,33.72 48.64,34.02 48.87,34.25 55.96,34.25
+VDDQ on BOTTOM (solid shape): 46,82.74 46,80 45.34,79.33 45.34,79.23 41.48,75.37 40.28,75.37 39.92,75.02 37.67,75.02 33.94,78.75 33.94,81.34 34.29,81.7 35.13,81.7 35.15,81.72 35.43,81.72 36.45,82.74 40.95,82.74 41.3,83.09 45.64,83.09
+VDDQ on L2-SIG (solid shape): 45.77,32.47 45.77,30.85 44.98,30.06 43.83,30.06 42.83,31.06 42.83,32.32 43.36,32.85 45.39,32.85
+VDDQ on L2-SIG (solid shape): 42.35,78.73 42.35,67.4 41.38,66.43 41.38,56.95 41.62,56.72 41.62,56.65 40.73,55.76 39.04,55.76 38.54,56.26 38.54,67.18 39.37,68.01 39.37,68.64 38.54,69.47 38.54,75.37 36.15,77.76 34.87,77.76 33.53,79.11 33.53,81.82 33.81,82.1 38.98,82.1
+VDDQ on L7-SIG (solid shape): outline of 142 points within 44.07,30.64 49.66,34.17
+VDDQ_LPDDR3 on BOTTOM (solid shape): outline of 97 points within 45.75,92.11 49.24,95.64
+VDDQ_LPDDR3 on BOTTOM (solid shape): outline of 165 points within 63.5,92.12 67.23,95.85
+VDDQ_LPDDR3 on BOTTOM (solid shape): outline of 4092 points within 35.43,74.05 73.62,100.7
+VDDQ_LX on BOTTOM (solid shape): 56.46,33.46 56.46,33.26 56.41,33.21 55.68,33.21 54.38,31.91 53.7,31.91 53.47,32.14 53.47,32.39 53.54,32.47 54.23,32.47 55.26,33.5 56.43,33.5
+VDDQ_PMIC on BOTTOM (solid shape): 50.04,32.42 50.04,28.31 49.84,28.1 49.84,27.49 49.78,27.44 45.11,27.44 44.99,27.56 44.99,29.3 45.22,29.52 48.01,29.52 48.34,29.85 48.34,30.29 48.35,30.3 48.35,31.11 48.74,31.51 48.74,32.47 48.9,32.62 49.84,32.62
+VDDQ_SOC on BOTTOM (solid shape): outline of 112 points within 46.13,78.8 60.11,81.57
+VDDQ_VTT on BOTTOM (solid shape): 46.15,33.06 46.15,32.72 46.05,32.62 45.36,32.62 44.91,32.7 44.67,32.32 44.64,32.25 44.57,32.22 43.76,32.22 43.66,32.11 43.21,32.11 43.05,32.27 43.05,32.98 43.59,33.51 45.7,33.51
+VDDQ_VTT_MEM on BOTTOM (solid shape): 45.21,35.58 45.21,33.82 45.06,33.67 44.36,33.67 44.36,33.77 43.63,33.77 43.5,33.9 43.5,34.66 44.17,35.34 44.17,35.59 44.41,35.83 44.96,35.83
+VDDQ_VTT_MEM on BOTTOM (solid shape): 75.92,102.65 75.92,101.81 75.69,101.58 71.27,101.58 71.18,101.68 71.18,102.28 69,102.28 69,101.61 68.92,101.53 61.82,101.53 61.72,101.64 61.72,102.27 61.62,102.37 52.81,102.37 52.68,102.24 52.68,101.71 52.63,101.66 45.49,101.66 45.37,101.79 45.37,102.73 45.44,102.8 75.77,102.8
+VDDQ_VTT_MEM on L2-SIG (solid shape): 53.74,27.16 53.74,26.34 53.43,26.03 53.26,26.03 53.13,26 53.03,25.91 52.65,25.91 52.03,26.53 52.03,27.29 52.22,27.49 53.41,27.49
+VDDQ_VTT_MEM on L3-GND (solid shape): 53.57,27.53 53.57,26.58 52.85,25.86 51.74,25.86 51.49,26.11 51.49,26.94 52.25,27.7 53.41,27.7
+VDDQ_VTT_MEM on L4-SIG (solid shape): 47.23,101.84 47.23,101.26 47.08,101.1 47.06,101.1 46.99,101.07 46.92,101.04 44.61,101.04 44.46,101.19 44.46,101.99 44.84,102.37 46.71,102.37
+VDDQ_VTT_MEM on L6-GND (solid shape): 53.08,26.42 53.08,25.66 52.92,25.5 51.69,25.5 51.34,25.86 51.34,26.22 51.72,26.6 52.9,26.6
+VDDQ_VTT_MEM on L6-GND (solid shape): 47.53,102.1 47.53,101.7 47.23,101.39 47.21,101.39 47.07,101.35 46.99,101.25 46.98,101.21 46.67,101.21 46.5,101.29 46.33,101.21 45.96,101.21 45.8,101.29 45.63,101.21 45.15,101.21 45.05,101.32 45.05,101.75 45.59,102.3 47.34,102.3
+VDDQ_VTT_MEM on L7-SIG (solid shape): 53.05,25.84 53.05,25.57 52.91,25.44 52.91,24.53 52.83,24.45 51.71,24.45 51.55,24.61 51.55,25.53 51.94,25.93 52.96,25.93
+VDDQ_VTT_PMIC on BOTTOM (solid shape): 48.51,32.17 48.51,31.71 48.36,31.56 45.92,31.56 45.7,31.79 45.7,32.27 45.75,32.32 48.36,32.32
AGND_AUD on TOP (solid shape): outline of 164 points within 3.79,58.07 29.44,70.72
AGND_AUD on BOTTOM (solid shape): 8.54,66.91 16.89,66.91 18.11,65.69 18.11,64.88 17.98,64.75 12.98,64.75 12.89,64.82 12.91,64.93 13.55,65.57 13.58,65.56 14.03,66.33 13.26,65.89 13.27,65.86 12.47,65.06 11.51,65.06 11.41,65.12 11.44,65.23 11.73,65.53 11.76,65.52 12.2,66.29 11.44,65.84 11.44,65.82 11.04,65.41 9.92,65.41 9.87,65.44 9.88,65.5 9.94,65.56 9.97,65.55 10.41,66.32 9.64,65.87 9.65,65.84 9.52,65.71 8.85,65.71 8.71,65.85 8.6,66.49 7.96,66.38 5.13,66.38 4.85,66.66 4.85,66.76 4.88,66.79 4.88,66.94 4.97,67.03 8.43,67.03
AGND_AUD on L2-SIG (solid shape): outline of 148 points within 3.79,58.02 29.44,70.72
AGND_AUD on L3-GND (solid shape): outline of 405 points within 3.79,58.02 29.44,70.72
AGND_AUD on L4-SIG (solid shape): outline of 391 points within 3.79,58.02 29.22,70.72
AGND_AUD on L5-SIG (solid shape): 19.66,63.53 19.69,63.6 19.77,63.63 21.87,61.53 21.87,60.03 21.83,60.02 21.61,59.89 21.52,59.66 21.45,59.57 21.34,59.59 19.66,61.27
AGND_AUD on L5-SIG (solid shape): 25.83,70.55 25.85,70.45 25.78,70.38 25.5,70.09 25.62,69.72 25.65,69.64 25.62,69.57 25.54,69.49 25.45,69.46 25.38,69.52 24.92,69.75 24.65,69.32 24.62,69.24 24.58,69.17 24.56,69.14 24.55,69.12 24.14,69.12 21.98,66.96 19.29,66.96 19.2,67.02 19.22,67.13 19.91,67.82 19.91,70.06 20.58,70.72 25.65,70.72
AGND_AUD on L5-SIG (solid shape): outline of 255 points within 5.28,58.02 29.44,69.6
AGND_AUD on L6-GND (solid shape): outline of 411 points within 3.79,58.02 29.44,70.72
AGND_AUD on L7-SIG (solid shape): outline of 352 points within 4.32,58.02 29.44,70.72
AVCC on BOTTOM (solid shape): 71.07,64.91 71.07,62.29 70.56,61.78 69.62,61.78 68.99,61.15 68.63,61.15 68.5,61.27 68.5,62.27 68.71,62.47 70.69,62.47 70.85,62.63 70.85,64.92 71.06,64.92
GND on TOP (solid shape): outline of 14380 points within 0.51,0.51 101.1,124.29
GND on BOTTOM (solid shape): 48.08,30.21 46.1,30.21 46.1,30.77 48.08,30.77
GND on BOTTOM (solid shape): 43.08,63.08 42.98,62.98 42.52,62.98 42.44,63.05 42.44,66.54 43.08,66.54
GND on BOTTOM (solid shape): 54.41,25.84 54.41,23.05 54.1,22.74 53.59,22.74 53.19,23.15 53.19,25.89 53.24,25.94 54.31,25.94
GND on BOTTOM (solid shape): 70.79,39.28 70.79,35.32 70.66,35.19 69.95,35.19 69.8,35.34 69.8,39.18 70.08,39.46 70.61,39.46
GND on BOTTOM (solid shape): 72.44,34.78 72.44,32.98 72.26,32.8 71.68,32.8 71.63,32.85 71.63,34.81 71.65,34.83 72.39,34.83
GND on BOTTOM (solid shape): 75.95,41.46 75.95,40.98 75.67,40.7 74.5,40.7 74.35,40.86 74.35,41.49 74.45,41.59 75.82,41.59
GND on BOTTOM (solid shape): 87.53,69.35 87.53,68.07 87.43,67.97 85.71,67.97 85.61,68.06 85.61,69.34 85.79,69.52 87.36,69.52
GND on BOTTOM (solid shape): 92,69.38 92,68.26 91.77,68.03 89.92,68.03 89.48,68.46 89.48,69.35 89.71,69.58 91.8,69.58
GND on BOTTOM (solid shape): 31.05,17.46 31.05,16.65 31,16.6 29.99,16.6 29.82,16.77 29.82,17.48 29.94,17.6 30.92,17.6
GND on BOTTOM (solid shape): 35.33,24.67 35.33,22.23 35.18,22.08 32.84,22.08 32.61,22.31 32.61,24.57 32.79,24.75 35.26,24.75
GND on BOTTOM (solid shape): 46.3,22.92 46.3,22.67 46.23,22.59 45.01,22.59 44.83,22.77 44.83,23.33 45.9,23.33
GND on BOTTOM (solid shape): 29.87,67.98 29.87,63.48 29.82,63.43 25.34,63.43 25.25,63.53 25.25,67.89 25.35,67.99 26.62,67.99 26.69,68.06 29.79,68.06
GND on BOTTOM (solid shape): 71.88,29.27 72.44,29.27 72.54,29.17 72.54,28.66 72.39,28.51 68.28,28.51 68.17,28.61 68.17,29.6 68.25,29.68 71.48,29.68
GND on BOTTOM (solid shape): 77.8,33.06 77.8,32.52 77.65,32.37 74.37,32.37 74.07,32.67 73.46,32.67 73.38,32.75 73.38,33.13 73.58,33.33 77.52,33.33
GND on BOTTOM (solid shape): 48.4,50.52 48.4,43.18 48.39,43.16 48.21,42.99 47.6,42.99 47.47,43.11 47.47,50.78 47.6,50.91 48,50.91
GND on BOTTOM (solid shape): 89.46,50.91 89.46,49.26 89.28,49.08 89.03,49.08 88.67,48.73 85.73,48.73 85.37,49.08 85.37,50.86 85.73,51.22 89.15,51.22
GND on BOTTOM (solid shape): 59.92,61.17 59.92,60.41 59.94,60.39 60.66,60.39 60.68,60.36 60.68,60.11 60.58,60 59.74,60 59.54,60.21 59.54,61.2 59.59,61.25 59.84,61.25
GND on BOTTOM (solid shape): 30.81,27.31 30.81,26.43 31.04,26.2 31.04,25.16 30.94,25.05 29.87,25.05 29.57,25.36 29.57,26.3 29.9,26.63 29.9,27.21 30.05,27.37 30.76,27.37
GND on BOTTOM (solid shape): 43.08,70.77 43.08,68.18 43.05,68.16 42.49,68.16 41.92,68.73 41.13,68.73 40.76,69.1 40.76,70.62 41.02,70.88 42.98,70.88
GND on BOTTOM (solid shape): 58.85,32.12 58.85,31.84 58.88,31.81 58.88,30.41 59.46,29.83 59.46,29.19 59.08,29.19 59,29.27 59,29.91 58.62,30.29 58.62,32.14 58.7,32.22 58.75,32.22
GND on BOTTOM (solid shape): 73.05,60.06 73.99,60.06 74.04,60 74.04,59.73 73.91,59.6 72.8,59.6 71.93,60.46 71.04,60.46 70.97,60.54 70.97,60.92 71.04,61 72.11,61
GND on BOTTOM (solid shape): 75.64,35.95 75.64,34.3 75.51,34.17 74.96,34.17 74.83,34.3 74.83,34.93 74.65,35.11 73.43,35.11 73.34,35.21 73.34,35.72 73.84,36.22 75.38,36.22
GND on BOTTOM (solid shape): 42.92,73.8 42.92,72.6 42.8,72.48 42.37,72.48 42.16,72.68 42.16,73.24 42.24,73.41 42.23,73.61 42.46,73.84 42.88,73.84
GND on BOTTOM (solid shape): 55.25,61.17 55.25,60.59 55.4,60.44 55.83,60.44 55.91,60.36 55.91,60.16 55.8,60.06 55.5,60.06 55.27,59.83 55.27,59.37 55.19,59.29 54.94,59.29 54.84,59.39 54.84,61.2 54.89,61.25 55.17,61.25
GND on BOTTOM (solid shape): 59.52,40.67 59.52,37.94 59.62,37.83 59.62,37.67 59.57,37.62 59.2,37.62 59.15,37.62 59.1,37.62 59.07,37.62 59.06,37.63 59.06,40.65 59.13,40.73 59.46,40.73
GND on BOTTOM (solid shape): 73.43,44.49 73.43,42.4 73.36,42.33 72.87,42.33 72.75,42.2 72.75,41.97 72.67,41.89 72.16,41.89 72.06,42 72.06,44.08 72.21,44.23 72.59,44.23 72.64,44.28 72.64,44.51 72.77,44.64 73.28,44.64
GND on BOTTOM (solid shape): 73.46,27.04 73.86,27.04 73.97,26.93 73.97,26.68 73.86,26.58 72.54,26.58 71.76,25.79 70.79,25.79 70.69,25.89 70.69,26.12 70.84,26.27 71.32,26.27 71.86,26.81 71.86,27.42 71.96,27.52 72.97,27.52
GND on BOTTOM (solid shape): 57.18,32.19 57.18,31.73 56.19,30.74 56.19,29.96 56.03,29.8 55.53,29.8 55.42,29.91 55.42,30.46 55.73,30.77 55.86,30.77 56.95,31.86 56.95,32.14 57.05,32.24 57.13,32.24
GND on BOTTOM (solid shape): 76.71,45.12 76.71,44.49 76.84,44.36 78.72,44.36 78.82,44.26 78.82,40.96 78.54,40.68 77.09,40.68 76.89,40.88 76.89,41.64 76.81,41.72 76.38,41.72 76.23,41.87 76.23,44.33 76.38,44.49 76.38,45.17 76.66,45.17
GND on BOTTOM (solid shape): 56.02,53.3 56.02,52.39 55.85,52.22 54.65,52.22 54.57,52.31 54.57,52.66 54.41,52.82 53.57,52.82 53.47,52.71 53.47,52.33 53.34,52.21 47.85,52.21 47.68,52.38 47.68,53.48 47.8,53.6 55.71,53.6
GND on BOTTOM (solid shape): 66.78,71.38 66.78,70.9 66.9,70.9 66.98,70.83 66.98,70.6 66.95,70.57 66.6,70.57 66.57,70.6 66.57,70.99 66.41,70.99 66.35,71.05 65.38,71.05 65.33,71.1 65.33,71.41 65.41,71.49 66.67,71.49
GND on BOTTOM (solid shape): 36.02,27.29 36.02,26.12 35.33,25.44 35.33,25.08 35.28,25.03 35.13,25.03 35.08,25.08 35.08,25.66 35.05,25.69 34.9,25.69 34.85,25.64 34.85,25.08 34.77,25 34.65,25 34.56,25.09 34.56,27.1 34.82,27.37 35.94,27.37
GND on BOTTOM (solid shape): 54.94,35.85 55.95,35.85 56.03,35.77 56.03,35.29 56,35.26 55.88,35.26 55.75,35.39 54.99,35.39 54.43,35.95 52.73,35.95 51.97,36.71 51.77,36.71 51.49,36.99 51.49,37.4 51.51,37.42 53.37,37.42
GND on BOTTOM (solid shape): 60.94,28.81 60.94,23.73 59.84,22.64 58.83,22.64 58.73,22.54 58.73,21.8 58.47,21.55 57.91,21.55 57.71,21.75 57.71,25.84 57.79,25.92 58.57,25.92 58.73,25.77 58.73,25.23 58.94,25.02 59.91,25.02 60.1,25.21 60.1,25.44 60.34,25.68 60.34,28.85 60.38,28.89 60.86,28.89
GND on BOTTOM (solid shape): 74.85,46.75 76.76,46.75 76.96,46.54 76.96,45.7 76.86,45.6 74.75,45.6 74.72,45.64 74.72,46.11 74.03,46.11 74.03,45.94 73.86,45.78 73.86,45.53 73.74,45.4 73.36,45.4 73.18,45.58 73.18,45.99 72.85,46.32 72.85,46.8 72.9,46.85 74.75,46.85
GND on BOTTOM (solid shape): 33.27,41.44 33.53,41.33 33.79,41.44 34.85,41.44 35,41.28 35,40.88 34.9,40.78 34.52,40.78 34.27,40.54 34.27,38.91 34.21,38.85 32.72,38.85 32.18,39.38 32.18,41.31 32.31,41.44
GND on BOTTOM (solid shape): 70.49,50.63 72.06,50.63 72.11,50.58 72.11,50 71.93,49.82 71.93,48.73 71.86,48.65 70.64,48.65 70.52,48.53 70.47,48.53 70.47,47.36 70.58,47.36 70.64,47.3 70.94,47.3 71.02,47.23 71.02,45.4 71.12,45.3 71.12,44.33 71.04,44.26 69.65,44.26 69.55,44.36 69.55,50.58 69.7,50.73 70.38,50.73
GND on BOTTOM (solid shape): 7.19,64.09 7.19,63.1 7.16,63.09 7.01,62.95 7,62.74 6.99,62.65 6.9,62.6 4.64,62.6 4.64,63.6 4.64,64.22 7.07,64.22
GND on BOTTOM (solid shape): 57.53,41.34 57.53,39.01 58.04,38.51 58.04,37.7 57.99,37.65 57.89,37.65 57.73,37.8 57.73,37.98 57.56,38.16 57.56,38.54 56.92,39.17 56.92,41.39 57.02,41.49 57.38,41.49
GND on BOTTOM (solid shape): 77.57,84.57 77.57,83.8 77.83,83.55 79.05,83.55 79.07,83.52 79.07,83.04 78.99,82.97 77.95,82.97 77.8,82.81 77.8,82.03 77.52,81.75 76.45,81.75 76.33,81.87 76.33,82.66 76.28,82.71 74.8,82.71 74.7,82.61 74.7,82.56 74.65,82.51 74.27,82.51 74.22,82.56 74.22,83.52 74.27,83.58 76.23,83.58 76.33,83.68 76.33,84.49 76.56,84.72 77.42,84.72
GND on BOTTOM (solid shape): 15.58,79.52 15.65,79.55 15.73,79.53 16.37,78.88 16.37,77.1 16.41,77.1 16.41,77 16.36,77 16.31,76.99 16.24,76.97 15.95,77.25 15.95,77.87 15.58,78.24 15.58,79.07 15.56,79.07 15.56,79.45 15.56,79.48 15.58,79.51
GND on BOTTOM (solid shape): 65.91,69.96 65.91,68.87 65.81,68.77 65.46,68.77 65.3,68.92 65.3,69.3 65.13,69.48 64.62,69.48 64.44,69.3 64.44,66.41 64.54,66.3 65.84,66.3 65.86,66.28 65.86,65.87 65.79,65.8 64.62,65.8 64.44,65.62 64.44,62.75 64.39,62.7 63.96,62.7 63.83,62.82 63.83,69.4 63.68,69.55 63.09,69.55 63.07,69.58 63.07,69.94 63.12,69.99 65.89,69.99
GND on BOTTOM (solid shape): 64.44,36.23 64.44,35.87 64.34,35.77 62.78,35.77 62.61,35.6 61.9,35.6 61.86,35.6 61.8,35.58 61.58,35.58 61.52,35.59 61.38,35.58 61.23,35.44 61.23,35.32 61.16,35.24 61.06,35.24 61.01,35.29 61.01,35.8 61.06,35.85 62.38,35.85 62.84,36.31 63.37,36.31 63.45,36.38 64.29,36.38
GND on BOTTOM (solid shape): 28.66,99.75 28.66,97.64 28.59,97.58 27.93,97.58 27.89,97.62 27.89,98.66 27.33,99.23 27.31,99.33 27.4,99.4 27.66,99.51 27.79,99.77 27.85,99.79 27.92,99.81 27.95,99.82 28.59,99.82
GND on BOTTOM (solid shape): 46.08,36 46.08,34.3 46.27,34.11 46.55,34.11 46.55,34.08 46.61,34.08 46.61,34.07 46.73,33.94 47.53,33.94 47.82,34.24 48.21,34.24 48.21,33.89 48.77,33.33 49.02,33.33 49.18,33.18 49.18,32.98 49.15,32.95 48.92,32.95 48.41,32.45 46.32,32.45 46.32,33.09 46.28,33.09 46.28,33.11 45.75,33.64 45.49,33.64 45.34,33.8 45.34,34.02 45.34,34.02 45.34,36 45.42,36.08 46,36.08
GND on BOTTOM (solid shape): 10.43,74.93 10.53,74.87 10.51,74.76 10.32,74.57 10,74.57 10,73.85 10.64,73.85 10.64,74.17 10.93,74.46 11.78,74.46 11.87,74.37 11.87,74.15 10.87,74.15 10.87,73.52 10.67,73.32 10.51,73.37 10.34,73.33 10.33,73.33 10.29,73.33 9.78,73.84 9.78,74.66 10.04,74.93
GND on BOTTOM (solid shape): 47.5,41.23 47.5,40.33 47.74,40.08 47.74,38.5 47.9,38.34 47.9,37.7 47.83,37.63 47.04,37.63 46.93,37.74 46.93,38.25 47.22,38.54 47.22,38.85 47,39.07 47,40.17 46.31,40.17 46.31,40.17 45.17,40.17 44.98,40.24 44.8,40.17 44.12,40.17 43.87,40.42 43.87,40.57 43.54,40.57 43.41,40.7 43.41,41.06 43.82,41.46 47.27,41.46
GND on BOTTOM (solid shape): 43.21,27.8 43.27,27.89 43.38,27.87 43.52,27.73 43.52,27.06 44.08,27.06 44.24,26.91 44.24,26.18 43.22,26.18 43.22,25.41 42.68,25.41 42.62,25.47 42.62,26.39 42.72,26.49 43.23,26.49 43.23,27.18 42.47,27.18 42.42,27.15 42.28,27.29 42.28,27.72 42.3,27.73 42.41,27.75 42.47,27.66 42.47,27.38 43.21,27.38
GND on BOTTOM (solid shape): 28.68,101.69 28.68,100.16 28.64,100.13 27.95,100.13 27.92,100.14 27.89,100.15 27.85,100.15 27.83,100.15 27.81,100.14 27.77,100.13 27.74,100.13 27.66,100.13 27.63,100.13 27.6,100.15 27.55,100.18 27.5,100.2 27.45,100.21 27.39,100.21 27.34,100.21 27.28,100.2 27.23,100.18 27.19,100.17 27.16,100.16 27.13,100.17 27.11,100.18 27.08,100.2 27.07,100.22 27.06,100.26 28.56,100.26 28.56,101.03 27.88,101.03 27.88,100.26 27.06,100.26 27.06,101.3 27.51,101.75 28.62,101.75
GND on BOTTOM (solid shape): 62.06,32.5 62.15,32.5 62.36,32.29 65,32.29 65.41,31.89 65.41,31.62 65.21,31.42 64.5,31.42 64.49,31.43 63.2,31.43 63.15,31.38 63.15,31.15 63.07,31.07 62.38,31.07 61.71,31.74 61,31.74 60.63,32.12 60.63,32.57 60.68,32.62 60.79,32.62 60.85,32.56 60.85,32.54 61.32,32.35 61.1,32.8 61.07,32.8 61.03,32.84 61.03,32.98 61.08,33.03 61.53,33.03
GND on BOTTOM (solid shape): 57.66,61.2 57.66,60.64 57.79,60.51 58.34,60.51 58.45,60.41 58.45,59.9 58.41,59.86 58.38,59.87 58.27,59.87 58.17,59.83 57.61,59.83 57.61,58.81 58.12,58.81 58.29,58.63 58.29,58.18 58.12,58 57.68,58 57.61,58.03 57.58,58.11 57.46,58.39 57.17,58.48 57.09,58.5 57.05,58.58 57.05,59 57.09,59 57.09,59.4 57.06,59.42 57.06,61.34 57.07,61.35 57.51,61.35
GND on BOTTOM (solid shape): 54.86,5.22 54.86,5.07 54.78,4.99 54.71,4.82 54.77,4.64 54.79,4.61 54.71,4.41 54.77,4.24 54.8,4.2 54.59,3.99 54.59,3.54 51.71,3.54 51.71,4.09 51.89,4.36 51.78,4.66 51.75,4.73 51.78,4.81 51.86,4.91 51.89,5.04 51.89,5.06 52.01,5.18 52.01,5.49 54.59,5.49
GND on BOTTOM (solid shape): 44.78,29.68 45.07,29.68 45.12,29.65 45.11,29.59 45.05,29.54 44.84,29.54 44.84,27.91 44.86,27.91 44.86,27.51 44.86,27.51 45.06,27.31 48.82,27.31 48.92,27.21 49.96,27.21 50.22,27.47 50.22,27.72 50.27,27.77 51,27.77 51.05,27.72 51.05,24.67 50.9,24.52 50.9,23.71 50.75,23.56 50.65,23.56 50.62,23.53 49.66,23.53 49.58,23.45 49.12,23.45 49.07,23.5 49.07,23.76 49.18,23.86 49.38,23.86 49.63,24.11 50.22,24.11 50.22,25.59 50.09,25.71 49.38,25.71 48.64,26.45 48.21,26.45 48.21,26.44 46.5,26.44 46.5,25.92 46.04,25.46 44.93,25.46 44.83,25.56 44.83,26.18 44.69,26.18 44.69,27.1 44.41,27.38 44.41,28.62 44.42,28.64 44.42,29.24 44.45,29.25 44.63,29.42 44.67,29.66 44.67,29.69 44.72,29.74
GND on BOTTOM (solid shape): outline of 83 points within 52.53,31.12 56.79,33.06
GND on BOTTOM (solid shape): 54.25,79.18 54.25,78.9 54.43,78.72 54.43,78.72 54.43,78.56 54.4,78.5 54.38,78.44 54.34,78.38 54.28,78.35 54.27,78.35 54.2,78.38 54.17,78.44 54.08,78.59 53.91,78.63 53.81,78.61 53.73,78.54 53.66,78.5 53.41,78.59 53.25,78.51 53.17,78.47 53.08,78.52 53.01,78.6 52.9,78.63 52.75,78.58 52.65,78.38 52.58,78.35 52.57,78.35 52.5,78.38 52.47,78.44 52.45,78.51 52.4,78.58 52.4,78.77 52.53,78.89 52.56,79.07 52.56,79.08 52.84,79.36 54.08,79.36
GND on BOTTOM (solid shape): 46.41,74.24 46.51,74.14 46.65,74.11 46.74,73.94 46.92,73.87 47.03,73.89 47.12,73.96 47.2,74 47.28,73.96 47.32,73.92 47.36,73.9 47.55,73.86 47.72,73.96 47.81,73.96 47.88,73.89 47.88,73.8 47.3,73.22 47.25,73.17 47.17,73.17 47.16,73.2 47.07,73.3 46.94,73.35 46.93,73.35 46.85,73.53 46.66,73.6 46.65,73.6 46.61,73.67 46.56,73.74 46.37,73.83 46.1,73.74 46.03,73.78 45.99,73.81 45.96,73.84 45.91,73.9 45.93,73.98 45.95,74.03 45.98,74.09 46.02,74.14 46.09,74.14 46.14,74.16 46.21,74.19 46.27,74.24
GND on BOTTOM (solid shape): 61.87,64.55 61.87,63.16 62.58,62.46 62.58,61.36 63.04,60.89 63.04,60.56 62.97,60.49 62.48,60.49 62.38,60.39 62.38,60.18 62.21,60 61.82,60 61.74,60.09 61.74,61.93 60.83,62.84 60.77,62.84 60.67,62.88 60.28,62.88 60.22,62.87 60.11,62.91 60.06,63.01 60.06,63.08 59.96,63.22 59.89,63.23 59.86,63.25 59.83,63.27 59.83,63.43 59.88,63.48 60.02,63.48 60.08,63.43 60.15,63.4 60.21,63.37 60.23,63.31 60.5,63.04 60.77,63.31 60.78,63.36 60.82,63.39 60.87,63.41 61.05,63.63 60.92,63.89 60.92,63.94 60.95,63.99 61,64.01 61.14,64.24 60.98,64.46 60.93,64.48 60.93,64.58 61,64.64 61.04,64.73 61.06,64.76 61.1,64.76 61.26,64.79 61.37,64.9 61.39,64.92 61.49,64.92
GND on BOTTOM (solid shape): 57.51,79.17 57.51,79.1 57.52,79.06 57.52,79.04 57.53,79.04 57.53,78.97 57.71,78.8 57.8,78.72 58.12,78.72 58.16,78.78 58.23,78.83 58.3,78.79 58.35,78.75 58.65,78.75 58.69,78.75 58.7,78.76 58.8,78.8 58.9,78.76 58.94,78.72 59,78.72 59,78.6 58.97,78.57 58.93,78.52 58.71,78.52 58.64,78.56 58.6,78.6 58.44,78.63 58.31,78.54 58.29,78.52 58.11,78.52 57.96,78.59 57.8,78.54 57.79,78.52 57.23,77.96 57.05,77.96 56.95,78.06 56.95,78.16 56.98,78.2 57,78.24 57.01,78.26 57.04,78.29 57.06,78.33 57.07,78.37 57.07,78.42 57.07,78.47 57.1,78.48 57.14,78.47 57.2,78.47 57.25,78.48 57.41,78.69 57.25,78.89 57.23,78.91 57,78.93 56.89,78.72 56.86,78.66 56.81,78.63 56.71,78.57 56.65,78.48 56.62,78.45 56.43,78.45 56.42,78.48 56.39,78.55 56.33,78.6 56.33,78.69 56.54,78.9 56.54,79.13 56.67,79.26 57.42,79.26
GND on BOTTOM (solid shape): 61.8,78.32 61.8,75.42 61.72,75.35 61.37,75.35 61.36,75.37 61.27,75.46 61.15,75.48 61.14,75.48 61.08,75.51 61.05,75.56 60.98,75.67 60.87,75.73 60.85,75.73 60.81,75.78 60.81,75.93 60.85,75.94 60.92,75.96 60.99,76.01 61.01,76.06 61.03,76.1 61.07,76.16 61.13,76.18 61.18,76.18 61.23,76.2 61.4,76.46 61.15,76.63 61.13,76.63 61.06,76.64 61.02,76.69 60.97,76.78 60.95,76.82 60.92,76.85 60.88,76.87 60.81,76.9 60.81,77 60.85,77.04 60.91,77.07 60.95,77.11 61.01,77.17 61.04,77.25 61.04,77.27 61.09,77.32 61.11,77.31 61.36,77.54 61.1,77.74 61.04,77.74 61.04,77.83 61.08,77.88 61.1,77.88 61.23,77.96 61.28,78.1 61.22,78.26 61.06,78.32 60.99,78.35 60.96,78.42 60.91,78.55 60.79,78.63 60.74,78.66 60.72,78.73 60.49,78.95 60.28,78.71 60.26,78.63 60.19,78.59 60.1,78.56 60.04,78.5 59.96,78.45 59.88,78.48 59.84,78.52 59.84,78.8 60.2,79.16 60.96,79.16
GND on BOTTOM (solid shape): 50.17,79.26 50.17,79.05 50.17,79.02 50.22,78.88 50.35,78.8 50.39,78.77 50.43,78.73 50.47,78.67 50.51,78.67 50.51,78.6 50.5,78.58 50.44,78.51 50.42,78.41 50.39,78.34 50.31,78.31 50.29,78.31 50.24,78.33 50.23,78.37 50.19,78.55 50.03,78.65 50,78.67 49.99,78.71 49.88,78.94 49.62,78.94 49.48,78.7 49.67,78.48 49.72,78.45 49.75,78.39 49.78,78.26 49.88,78.17 49.91,78.16 49.91,78.03 49.8,77.93 49.67,77.93 49.59,78 49.46,78.03 49.41,78.07 49.34,78.24 49.21,78.31 49.19,78.31 49.14,78.36 49.14,78.38 49.11,78.47 49.04,78.54 48.87,78.59 48.73,78.51 48.64,78.47 48.56,78.52 48.48,78.6 48.37,78.63 48.22,78.57 48.14,78.39 48.1,78.38 48.05,78.38 47.98,78.4 47.94,78.46 47.92,78.52 47.88,78.57 47.88,78.72 47.91,78.75 47.93,78.75 47.97,78.77 48.05,78.8 48.13,78.77 48.17,78.75 48.51,78.75 48.55,78.79 48.61,78.83 48.68,78.79 48.72,78.75 49.06,78.75 49.1,78.77 49.12,78.79 49.19,78.81 49.32,78.95 49.32,79.02 49.33,79.06 49.33,79.21 49.38,79.26 50.16,79.26
GND on BOTTOM (solid shape): 56.06,65.18 56.08,65.16 56.12,65.08 55.99,64.8 56.12,64.51 56.08,64.44 56.05,64.4 55.97,64.37 55.69,64.5 55.41,64.37 55.12,64.5 54.84,64.37 54.56,64.5 54.27,64.37 54.2,64.4 53.91,64.49 53.72,64.26 53.71,64.23 53.68,64.21 53.58,64.18 53.5,64.12 53.42,64.08 53.35,64.12 53.27,64.18 53.17,64.21 53.14,64.23 53.12,64.26 53.08,64.37 53,64.46 53,64.57 53.03,64.59 53.06,64.62 53.14,64.66 53.22,64.62 53.24,64.61 53.54,64.56 53.69,64.83 53.67,64.91 53.62,64.97 53.6,65.04 53.63,65.11 53.67,65.17 53.79,65.17 53.86,65.1 53.96,65.07 53.99,65.05 54.01,65.01 54.05,64.86 54.18,64.75 54.27,64.73 54.37,64.75 54.48,64.84 54.54,64.97 54.54,64.99 54.65,65.08 54.73,65.13 54.78,65.19 54.79,65.2 54.89,65.22 54.91,65.2 54.99,65.13 55.09,65.1 55.12,65.08 55.14,65.05 55.18,64.94 55.26,64.86 55.57,64.75 55.75,65.02 55.87,65.08 55.94,65.19 55.95,65.22 56.02,65.22
GND on BOTTOM (solid shape): outline of 84 points within 45.26,62.87 47.84,65.19
GND on BOTTOM (solid shape): outline of 94 points within 41.71,74.53 47.25,79.21
GND on BOTTOM (solid shape): outline of 367 points within 51.09,76.36 54.48,78.32
GND on BOTTOM (solid shape): outline of 555 points within 45.89,92.22 51.71,99.07
GND on BOTTOM (solid shape): outline of 171 points within 49.9,69.04 55.97,73
GND on BOTTOM (solid shape): outline of 261 points within 52.82,65.52 58.95,71.38
GND on BOTTOM (solid shape): outline of 947 points within 28.85,88.36 33.6,92.61
GND on BOTTOM (solid shape): outline of 1166 points within 47.31,64.07 53.53,72.31
GND on BOTTOM (solid shape): outline of 1629 points within 48.2,70.16 58.69,77.72
GND on BOTTOM (solid shape): outline of 15031 points within 0.51,0.51 101.1,124.29
GND on L2-SIG (solid shape): 36.17,51.63 36.17,47.88 35.99,47.7 35.36,47.7 35.26,47.81 35.26,51.5 35.42,51.66 36.14,51.66
GND on L2-SIG (solid shape): 38.4,49.82 38.4,49.1 38.32,49.02 37.62,49.02 37.52,49.12 37.52,50.05 37.63,50.17 38.06,50.17
GND on L2-SIG (solid shape): 79.76,53.93 79.76,48.59 79.69,48.49 79.58,48.52 76.81,51.29 76.81,54.06 76.89,54.14 79.55,54.14
GND on L2-SIG (solid shape): 39.79,31.77 39.85,31.86 39.96,31.84 40.62,31.19 40.62,31.18 43.21,28.58 43.21,28.23 43.05,28.08 42.42,28.08 40.44,30.05 39.79,30.7
GND on L2-SIG (solid shape): 28.85,50.07 28.85,46.22 28.66,46.02 27.75,46.02 26.75,47.02 26.75,50.2 26.77,50.26 26.83,50.3 26.98,50.25 27.14,50.31 28.62,50.31
GND on L2-SIG (solid shape): 90.05,61.65 90.16,61.68 90.22,61.58 90.22,59.51 85.59,54.89 85.48,54.87 85.42,54.96 85.42,57.03
GND on L2-SIG (solid shape): 82.58,45.13 82.64,45.23 82.75,45.2 83.1,44.85 83.1,28.08 82.04,27.02 81.93,27 81.87,27.1 81.87,29.7 81.05,30.52 81.05,30.81 81.18,30.94 81.88,30.94 82.69,31.75 82.69,34.98 82.58,35.1
