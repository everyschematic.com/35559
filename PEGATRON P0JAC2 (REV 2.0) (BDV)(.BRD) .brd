# Allegro board PEGATRON P0JAC2 (REV 2.0) (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_I2C_CFG: length 3.1
  BOTTOM w0.102: U7107.10 71.47,21.15 70.8,21.82 v9(70.8,21.99) 70.8,22.65 R7108.2 R7106.1
EDP_LVDS_0+_R: length 7.3
  L5-SIG w0.081: v3(59.34,4.45) 59.49,4.61 59.71,4.61 59.93,4.61 59.95,4.63 61.61,6.29 v3(63.51,6.29)
  L6-GND w0.102: v1(58.85,4.45) v3(59.34,4.45) ; v3(63.51,6.29) 63.93,6.29 v1(63.94,6.29)
  BOTTOM w0.107: CON7305.9 58.66,4.26 v1(58.85,4.45)
EDP_LVDS_0-_R: length 7.2
  L5-SIG w0.081: v3(63.54,6.86) 63.26,6.58 61.5,6.58 59.81,4.89 59.48,4.89 v3(59.34,5.04)
  L6-GND w0.102: v1(63.94,6.84) 63.93,6.84 63.55,6.84 v3(63.54,6.86) ; v1(58.85,4.81) 59.11,4.81 v3(59.34,5.04)
  BOTTOM w0.107: v1(58.85,4.81) 58.96,4.91 CON7305.8
EDP_LVDS_1+_R: length 10.2
  L5-SIG w0.081: v3(63.2,8.34) 62.97,8.12 60.59,8.12 58.24,5.76 58.24,4.97 58.1,4.83 57.69,4.83 v3(57.58,4.94)
  L6-GND w0.102: v1(58.09,4.81) 57.71,4.81 v3(57.58,4.94) ; v3(63.2,8.34) 63.3,8.23 v1(63.94,8.23)
  BOTTOM w0.107: CON7305.12 57.76,5.15 v1(58.09,4.81)
EDP_LVDS_1-_R: length 10.3
  L5-SIG w0.081: v3(63.2,7.63) 62.99,7.83 60.71,7.83 58.52,5.64 58.52,4.85 58.21,4.54 57.77,4.54 v3(57.61,4.38)
  L6-GND w0.102: v1(63.94,7.68) 63.25,7.68 v3(63.2,7.63) ; v1(58.09,4.45) 57.68,4.45 v3(57.61,4.38)
  BOTTOM w0.107: CON7305.11 58.06,4.42 v1(58.09,4.45)
EDP_LVDS_2+_R: length 10.4
  L5-SIG w0.081: v3(56.54,4.35) 56.75,4.35 56.76,4.35 56.84,4.27 56.84,3.95 57.01,3.78 57.2,3.59 60.7,3.59 61.99,4.89 63.55,4.89 v3(63.58,4.86)
  L6-GND w0.102: v3(63.58,4.86) 63.67,4.94 v1(63.94,4.94) ; v1(57,4.43) 56.62,4.43 v3(56.54,4.35)
  BOTTOM w0.107: v1(57,4.43) 56.86,4.29 CON7305.15
EDP_LVDS_2-_R: length 10.4
  L5-SIG w0.081: v3(56.54,4.94) 56.84,4.64 56.87,4.64 56.88,4.63 57.13,4.38 57.13,4.07 57.31,3.88 60.58,3.88 61.89,5.19 63.12,5.19 63.23,5.29 63.23,5.3 v3(63.23,5.3)
  L6-GND w0.102: v3(56.54,4.94) 56.85,4.94 v1(57,4.78) ; v1(63.94,5.49) 63.42,5.49 v3(63.23,5.3)
  BOTTOM w0.107: v1(57,4.78) 57.16,4.94 CON7305.14
EDP_LVDS_3+_R: length 14.5
  L5-SIG w0.081: v3(63.55,2.73) 63.55,2.73 63.23,3.05 63.11,3.05 63.05,2.99 63.05,2.35 63.01,2.31 55.15,2.31 54.14,3.32 54.14,4.22 54.3,4.38 v3(54.48,4.38)
  L6-GND w0.102: v3(63.55,2.73) 63.56,2.72 v1(63.96,2.72) ; v3(54.48,4.38) 54.66,4.56 54.81,4.56 v1(54.97,4.4)
  BOTTOM w0.107: CON7305.21 55.06,3.33 54.85,3.54 54.85,3.89 55.06,4.09 55.06,4.31 v1(54.97,4.4)
EDP_LVDS_3-_R: length 14.5
  L5-SIG w0.081: v3(54.48,4.96) 53.86,4.34 53.86,3.2 55.04,2.03 63.13,2.03 63.28,2.17 v3(63.56,2.17)
  L6-GND w0.102: v3(54.48,4.96) 54.64,4.81 v1(54.97,4.81) ; v1(63.96,2.17) v3(63.56,2.17)
  BOTTOM w0.107: v1(54.97,4.81) 55.36,5.2 CON7305.20
EDP_LVDS_C+_R: length 11.7
  L5-SIG w0.081: v3(55.45,4.89) 55.69,4.64 55.82,4.64 56.07,4.4 56.07,3.81 56.75,3.13 60.92,3.13 61.79,4 62.32,4 v3(62.42,4.1)
  L6-GND w0.102: v1(62.99,4.1) 62.56,4.1 v3(62.42,4.1) ; v3(55.45,4.89) 55.63,4.71 v1(55.9,4.71)
  BOTTOM w0.107: LX7325.2 62.99,4.09 v1(62.99,4.1) ; v1(55.9,4.71) 55.96,4.76 CON7305.18
EDP_LVDS_C-_R: length 11.8
  L5-SIG w0.081: v3(62.41,3.54) 62.23,3.72 61.91,3.72 61.04,2.84 60.8,2.84 56.63,2.84 56.47,3.01 55.78,3.69 55.78,4.21 55.71,4.28 v3(55.45,4.28)
  L6-GND w0.102: v3(62.41,3.54) 62.51,3.44 v1(62.99,3.44) ; v3(55.45,4.28) 55.5,4.33 v1(55.91,4.33)
  BOTTOM w0.107: LX7325.3 63.48,3.54 63.37,3.44 v1(62.99,3.44) ; CON7305.17 56.26,3.98 v1(55.91,4.33)
EDP_PD#: length 90.5
  L4-SIG w0.109: v3(38.53,56.02) 38.76,56.02 39.9,54.87 39.9,54.06 v3(40.77,53.2) ; v3(61.77,19.62) 61.77,19.22 60.68,18.12 57.61,18.12 57.27,17.79 45.72,17.79 42.34,21.17 39.68,21.17 38.68,22.16 38.68,33.36 38.3,33.74 38.3,35.95 38.63,36.28 38.63,37.71 37.43,38.91 36.96,38.91 36.7,39.17 36.7,40.02 34.85,41.87 34.85,43.94 34.19,44.6 34.19,51.02 v3(33.91,51.29)
  L5-SIG w0.109: v3(40.77,53.2) 40.55,53.42 39.92,53.42 39.44,52.94 39.44,52.58 38.16,51.29 v3(33.91,51.29) ; v3(38.05,62.93) 38.28,63.15 44.25,63.15 45.6,64.5 45.6,64.81 46.25,65.47 46.25,65.55 v6(46.92,66.21)
  L6-GND w0.102: v1(61.29,20) 61.39,20 v3(61.77,19.62) ; v3(38.05,62.93) 38.28,62.7 v4(38.35,62.7) ; v3(38.53,56.02) v4(38.53,56.4)
  L7-SIG w0.084: v4(38.35,62.7) 38.19,62.53 38.19,58.2 39.1,57.28 39.1,56.97 v4(38.53,56.4) ; v1(61.29,20) 61.47,19.82 v1(62.18,19.82)
  BOTTOM w0.31: v9(62.29,20.94) 62.18,20.83 v1(62.18,19.82)
EDP_PD#_N: length 11.1
  L7-SIG w0.084: v1(70.47,20.96) 70.46,20.96 69.7,20.2 66.27,20.2 65.3,19.24 65.3,19.02 v1(65.2,18.91) v1(64.43,18.91) 62.71,18.91 62.18,18.38 v1(62.18,17.72)
  BOTTOM w0.31: v1(65.2,18.91) 65.2,19.61 v9(65.36,19.78)
EDP_RLV_CFG: length 5.1
  BOTTOM w0.102: U7107.18 73.98,17.86 R7109.2 74.24,18.44 74.35,18.55 75.91,18.55 R7110.2 76.9,18.67 v9(76.9,19.03)
EDP_RLV_SSC: length 3.7
  BOTTOM w0.102: U7107.19 73.69,17.36 73.82,17.23 R7119.2 74.69,16.77 75.89,16.77 R7107.2
EDP_RST#: length 90.7
  L4-SIG w0.109: v3(81.32,77.08) 79.88,75.65 78.14,75.65 77.92,75.42 77.92,75.1 78.14,74.88 78.42,74.88 80.25,73.05 80.25,71.66 79.2,70.61 79.2,69.48 80.26,68.42 81.68,68.42 85.33,64.76 85.33,59.31 86.03,58.62 86.03,58.2 86.74,57.48 86.74,41.42 v3(85.11,39.79) ; v3(79.16,82.91) 76.99,80.74 76.99,78.62 76.97,78.6 76.97,77.75 75.53,76.31 72.91,76.31 72.71,76.11 v3(72.71,75.25)
  L5-SIG w0.109: v3(76.07,35.19) 76.28,35.19 80.88,39.79 v3(85.11,39.79) ; v3(79.16,82.91) 79.16,81.89 81.32,79.73 v3(81.32,77.08)
  L6-GND w0.102: v1(76.07,34.55) v3(76.07,35.19) ; v3(72.71,75.25) 72.51,75.06 v4(72.41,75.06)
  L7-SIG w0.06: 64.95,73.72 64.16,72.93 64.03,72.93 64.02,72.93 63.75,72.93 63.45,72.63 62.36,72.63 62.08,72.91 61.14,72.91 60.86,73.19 60.5,73.19 60.33,73.01 59.98,73.01 v6(59.97,73.02)
  L7-SIG w0.084: 64.95,73.72 65.02,73.79 67.38,73.79 67.52,73.65 71.4,73.65 71.87,74.12 71.87,74.66 72.27,75.06 v4(72.41,75.06)
EDP_RST#_N: length 7.2
  L7-SIG w0.102: v1(63.48,19.82) 63.73,19.57 v1(64.43,19.57) 65.2,19.57 66.11,20.48 69.49,20.48 v1(69.97,20.96)
EDP_RST#_R: length 27.8
  L4-SIG w0.109: v3(63.22,18.91) 63.66,18.91 64.98,20.23 73.13,20.23 76.38,23.48 76.38,32.78 v3(76.81,33.21)
  L6-GND w0.102: v4(62.94,18.6) 62.94,18.63 v3(63.22,18.91) ; v1(76.81,33.69) v3(76.81,33.21)
  L7-SIG w0.084: v1(63.48,17.64) 63.48,17.98 62.94,18.53 v4(62.94,18.6) ; v1(76.07,33.69) v1(76.81,33.69)
EMMC_CLK: length 36.2
  L4-SIG w0.109: v3(28.54,82.55) 29.17,82.55 29.23,82.48 29.23,78.72 33.13,74.82 33.13,73.7 33.52,73.31 33.52,71.85 33.66,71.71 34.28,71.71 34.38,71.61 34.38,70.61 34.16,70.39 33.87,70.39 v3(33.35,69.87)
  L5-SIG w0.06: 44.25,65.42 45.28,66.44 45.28,67.16 45.95,67.83 46.22,67.83 46.58,68.19 46.69,68.19 v6(46.97,68.47)
  L5-SIG w0.109: v3(33.35,69.87) 32.96,69.87 32.74,69.66 32.74,69.48 32.94,69.28 33.86,69.28 34.06,69.07 34.06,67.75 36.59,65.23 44.06,65.23 44.25,65.42
  L6-GND w0.102: v3(28.54,82.55) v1(28.8,82.29)
EMMC_CLK_R: length 9.1
  L7-SIG w0.084: v1(28.73,89.73) 29.7,89.73 30.58,88.86 30.58,87.41 30.06,86.89 30.06,85.77 29.54,85.25 v1(29.54,83.15) v1(28.8,83.15)
EMMC_CMD: length 44.5
  L4-SIG w0.109: v3(28.55,81.9) 28.84,81.62 28.84,78.6 32.77,74.67 32.77,73.55 33.1,73.22 33.1,72 32.94,71.84 32.33,71.84 32.18,71.69 32.18,71.46 32.87,70.77 v3(33.1,70.77)
  L5-SIG w0.06: v6(46.08,68.8) 46,68.71 45.54,68.71 44.76,67.93 44.76,67.76 44.76,67.76 44.76,67.66 43.94,66.84 43.94,66.36 43.83,66.25
  L5-SIG w0.109: v3(33.1,70.77) 33.82,70.77 35.49,69.1 35.49,68.38 37.86,66.01 43.59,66.01 43.83,66.25
  L6-GND w0.102: v4(32.84,71.05) 32.84,71.03 v3(33.1,70.77) ; v4(28.17,82.01) 28.43,82.01 28.54,81.9 v3(28.55,81.9)
  L7-SIG w0.084: v4(32.84,71.05) 32.56,71.33 v1(32.56,71.89) ; v4(28.17,82.01) 26.23,82.01 25.88,82.36 25.88,82.81 29.42,86.35 29.42,87.16 29.96,87.69 29.96,88 v1(28.73,89.23)
EMMC_DATA_0: length 46
  L4-SIG w0.109: v3(32.22,86.46) 31.78,86.46 29.6,84.28 29.6,84.19 29.6,78.87 33.49,74.97 33.49,73.89 34.75,72.63 34.75,70.24 34.25,69.73 v3(33.95,69.73)
  L5-SIG w0.06: v6(48.34,68.74) 48.21,68.74 48.04,68.57 47.7,68.57 47.59,68.68 46.42,68.68 46.22,68.47 45.64,68.47 45,67.83 45,66.7 44.15,65.86
  L5-SIG w0.109: 44.15,65.86 43.89,65.59 36.87,65.59 34.47,68 34.47,69.21 v3(33.95,69.73)
  L6-GND w0.102: v4(33.67,69.45) v3(33.95,69.73) ; v3(32.22,86.46) 32.23,86.46 32.55,86.46 v4(32.58,86.46)
  L7-SIG w0.084: v4(33.67,69.45) 32.43,69.45 32.08,69.11 v1(31.78,69.11) ; v1(34.22,88.23) 33.98,88.48 33.02,88.48 32.82,88.27 32.82,86.52 32.75,86.46 v4(32.58,86.46)
EMMC_DATA_1: length 45.8
  L4-SIG w0.109: v3(29.21,74.48) 29.21,75.32 27.58,76.95 27.58,78.29 27.08,78.78 27.08,83.26 32.56,88.73 v3(34.58,88.73)
  L5-SIG w0.06: v6(47.51,68.47) 47.49,68.47 47.08,68.07 46.63,68.07 46.24,67.68 45.97,67.68 45.4,67.11 45.4,66.32 44.56,65.48 44.56,65.21 44.25,64.91
  L5-SIG w0.109: 44.25,64.91 44.21,64.86 36.44,64.86 33.96,67.34 33.66,67.34 29.21,71.78 v3(29.21,74.48)
  L6-GND w0.102: v1(34.22,88.73) v3(34.58,88.73)
EMMC_DATA_2: length 45.2
  L4-SIG w0.109: v3(32.33,73.62) 32.33,74.56 31.01,75.88 30.85,75.88 30.56,75.59 30.31,75.59 30.04,75.86 30.04,76.06 30.43,76.45 30.43,76.61 29.91,77.13 29.7,77.13 29.28,76.72 29.1,76.72 28.42,77.4 28.42,77.76 28.77,78.12 28.77,78.3 28.59,78.49 28.59,80.29 28.42,80.45 28.04,80.45 27.93,80.57 27.93,82.79 28.1,82.96 29.28,82.96 29.37,83.06 29.37,83.39 29.24,83.52 29.03,83.52 28.91,83.65 28.91,83.89 31.86,86.85 33.75,86.85 34.97,88.06 34.97,89.2 34.88,89.29 v3(34.6,89.29)
  L6-GND w0.102: v3(34.6,89.29) 34.28,89.29 v1(34.22,89.23) ; v3(32.33,73.62) 32.35,73.62 32.58,73.39 v4(32.6,73.39)
  L7-SIG w0.06: 45.17,68.53 45.74,68.53 45.81,68.46 46.1,68.46 46.26,68.3 46.49,68.3 46.66,68.46 v6(46.66,68.72)
  L7-SIG w0.084: 45.17,68.53 44.07,67.43 43.19,67.43 42.99,67.23 41.43,67.23 41.05,66.85 39.45,66.85 37.59,68.71 37.59,70.07 34.29,73.38 32.61,73.38 32.6,73.39 v4(32.6,73.39)
EMMC_DATA_3: length 43.6
  L4-SIG w0.109: v3(32.24,72.37) 32.4,72.21 32.66,72.21 32.76,72.32 32.76,73.06 32.64,73.18 31.04,73.18 30.41,73.81 30.41,74.32 30.65,74.56 30.65,74.8 30.58,74.87 30.25,74.87 30.23,74.89 28,77.13 28,77.94 28.14,78.08 28.14,78.97 28.07,79.03 27.72,79.03 27.51,79.24 27.51,83.09 32.59,88.17 32.75,88.17 32.84,88.08 32.84,87.41 32.96,87.29 33.28,87.29 v3(33.45,87.46)
  L6-GND w0.102: v3(33.45,87.46) v1(33.73,87.73) ; v3(32.24,72.37) 32.28,72.41 v4(32.62,72.41)
  L7-SIG w0.06: 44.88,67.76 44.95,67.83 45.97,67.83 46.27,68.13 46.61,68.13 v6(46.66,68.17)
  L7-SIG w0.084: v4(32.62,72.41) 33.13,72.92 34.21,72.92 37.22,69.91 37.22,68.56 39.3,66.48 39.49,66.48 39.84,66.13 40.25,66.13 40.6,66.48 41.18,66.48 41.18,66.48 41.2,66.48 41.58,66.86 43.18,66.86 43.4,67.08 44.2,67.08 44.88,67.76
EMMC_DATA_4: length 42.6
  L4-SIG w0.109: v3(30.02,74.1) 29.74,74.1 29.65,74.19 29.65,75.18 27.79,77.04 27.79,78.38 27.3,78.87 27.3,83.17 32.6,88.48 32.97,88.48 v3(33.39,88.05)
  L5-SIG w0.06: 43.61,66.4 43.61,66.68 44.64,67.71 44.64,67.98 45.49,68.83 45.83,68.83 46,69 47.89,69 47.93,69.04 v6(48.05,69.04)
  L5-SIG w0.109: v3(30.02,74.1) 30.02,73.81 31.99,71.84 33.04,71.84 35.7,69.19 35.7,68.5 37.98,66.22 43.43,66.22 43.61,66.4
  L6-GND w0.102: v1(33.73,88.21) 33.57,88.05 v3(33.39,88.05)
EMMC_DATA_5: length 44.2
  L4-SIG w0.109: v3(34.18,88.25) 34.18,87.59 33.65,87.06 31.78,87.06 27.72,83 27.72,80.29 27.84,80.17 28.11,80.17 28.21,80.08 28.21,79.79 28.11,79.7 27.82,79.7 27.75,79.62 27.75,79.3 27.8,79.24 28.2,79.24 28.35,79.1 28.35,77.99 28.21,77.85 28.21,77.22 29.11,76.32 29.27,76.32 29.65,76.7 29.87,76.7 29.99,76.58 29.99,76.42 29.61,76.04 29.61,75.82 30.34,75.08 30.61,75.08 30.93,75.41 31.06,75.41 31.39,75.09 31.39,74.91 30.63,74.15 30.63,73.89 30.87,73.64 31.69,73.64 v3(31.75,73.59)
  L6-GND w0.102: v1(33.73,88.76) 33.73,88.71 v3(34.18,88.25) ; v4(31.84,73.24) 31.84,73.5 v3(31.75,73.59)
  L7-SIG w0.06: v6(46.02,68.25) 45.84,68.25 45.54,67.95 44.81,67.95 44.72,67.86
  L7-SIG w0.084: 44.72,67.86 44.1,67.23 43.29,67.23 43.1,67.05 41.5,67.05 41.12,66.67 41.11,66.67 41.11,66.67 40.52,66.67 40.17,66.31 39.92,66.31 39.57,66.67 39.38,66.67 37.41,68.64 37.41,69.99 34.29,73.11 31.98,73.11 v4(31.84,73.24)
EMMC_DATA_6: length 46.4
  L4-SIG w0.109: v3(33.37,89.23) 32.76,89.23 26.87,83.35 26.87,78.69 27.36,78.2 27.36,76.87 28.8,75.43 v3(28.8,74.96)
  L5-SIG w0.06: 44.68,65.07 44.68,65.43 45.52,66.27 45.52,67.06 45.86,67.4 46.87,67.4 47.31,67.85 47.31,67.98 47.71,68.39 48.1,68.39 v6(48.29,68.2)
  L5-SIG w0.109: 44.68,65.07 44.26,64.65 36.22,64.65 36.21,64.66 33.83,67.04 33.66,67.04 28.8,71.89 v3(28.8,74.96)
  L6-GND w0.102: v1(33.73,89.23) v3(33.37,89.23)
EMMC_DATA_7: length 45.8
  L4-SIG w0.109: v3(28.25,74.94) 28.25,75.69 27.15,76.78 27.15,78.12 26.66,78.61 26.66,78.78 26.66,78.78 26.66,83.44 33.01,89.79 v3(33.29,89.79)
  L5-SIG w0.06: 43.96,66.05 44.07,66.16 44.07,66.81 44.88,67.61 44.88,67.88 45.59,68.59 46.17,68.59 46.37,68.8 47.78,68.8 v6(47.81,68.77)
  L5-SIG w0.109: v3(28.25,74.94) 28.42,75.11 28.42,75.12 28.64,75.34 28.96,75.34 29.6,74.71 29.6,73.92 32.72,70.8 32.72,70.61 32.94,70.38 33.84,70.38 34.68,69.55 34.68,68.09 36.96,65.8 43.71,65.8 43.96,66.05
  L6-GND w0.102: v1(33.73,89.73) 33.69,89.77 33.29,89.77 33.29,89.79 v3(33.29,89.79)
EMMC_RCOMP: length 9.9
  L5-SIG w0.06: 43.33,66.94 43.34,66.96 43.54,66.96 43.98,67.39 44.02,67.44 44.4,67.81 44.4,68.07 45.39,69.07 45.73,69.07 45.9,69.24 47.79,69.24 47.91,69.36 48.34,69.36 v6(48.56,69.59)
  L5-SIG w0.127: v3(40.39,66.82) 43.04,66.82 43.16,66.94 43.33,66.94
  L6-GND w0.127: v3(40.39,66.82) 40.15,66.58 v1(40.06,66.58)
EMMC_RESET: length 45
  L4-SIG w0.109: v3(27.66,74.93) 27.66,75.65 26.89,76.42 26.89,78.03 26.16,78.76 v3(26.16,83)
  L5-SIG w0.06: v6(48.65,69.04) 48.45,69.24 47.96,69.24 47.84,69.12 45.95,69.12 45.78,68.95 45.44,68.95 44.52,68.03 44.52,67.76 43.46,66.7 43.46,66.55
  L5-SIG w0.109: 43.46,66.55 43.34,66.43 38.1,66.43 35.91,68.62 35.91,69.42 32.57,72.75 31.38,72.75 30.41,73.72 30.41,74.26 29.12,75.55 28.3,75.55 27.68,74.93 v3(27.66,74.93)
  L6-GND w0.102: v1(28.07,75.5) 28.07,75.34 v3(27.66,74.93) ; v4(26.53,83) v3(26.16,83)
  L7-SIG w0.084: v1(29.73,89.23) 29.73,88.67 30.2,88.2 30.2,87.51 29.73,87.04 29.73,86.2 v4(26.53,83)
GA_SCL_R: length 3.5
  L3-GND w0.102: v8(31.5,37.22) 31.5,36.81 v3(31.4,36.71)
  L6-GND w0.102: v1(31.41,37.17) 31.4,37.15 v3(31.4,36.71)
  L7-SIG w0.084: v1(31.89,35.58) 31.41,36.05 v1(31.41,37.17) v1(30.66,37.17)
GA_SDA_R: length 4.7
  L3-GND w0.102: v3(29.85,36.68) v8(29.85,37.27)
  L6-GND w0.102: v3(29.85,36.68) 29.85,37.11 v1(29.93,37.19)
  L7-SIG w0.084: v1(29.31,37.19) v1(29.93,37.19) 31.08,36.04 31.08,35.89 v1(31.89,35.08)
GASG_BAT_GD#: length 11.4
  L7-SIG w0.102: v1(32.39,35.08) 32.61,35.3 33,35.3 33.4,35.7 33.4,37.93 34.14,38.67 34.59,38.67 34.97,38.28 34.97,38.07 35.13,37.91 37.85,37.91 39.2,39.26 v1(40,39.26)
GASG_BAT_LOW: length 48.2
  L3-GND w0.102: v8(30.02,34.93) v3(30.56,34.93)
  L5-SIG w0.109: v3(30.56,34.93) 30.56,36.23 30.84,36.51 30.84,37.12 31.88,38.16 31.88,41.13 27.36,45.65 27.36,49.62 28.17,50.43 31.12,50.43 v3(32.08,51.39)
  L6-GND w0.102: v1(32.44,51.55) 32.28,51.39 v3(32.08,51.39) ; v3(30.56,34.93) v4(31.01,34.93)
  L7-SIG w0.084: v1(32.16,53.93) 32.33,54.11 32.33,56.07 32.69,56.42 32.69,57.21 33.5,58.02 33.5,58.76 v1(33.55,58.81) ; v1(31.89,34.58) 31.55,34.58 31.19,34.93 v4(31.01,34.93)
  BOTTOM w0.31: Q3007.3 37.16,69.02 37.83,68.36 Q2650.3 37.83,66.54 37.69,66.41 37.69,65.64 37.79,65.54 37.79,63.53 36.21,61.96 34.98,61.96 34.59,61.58 34.01,61.58 33.48,61.04 33.48,58.89 v1(33.55,58.81) ; v1(32.44,51.55) 32.86,51.97 32.86,53.23 v1(32.16,53.93)
GASG_BAT_LOW_EC: length 101.3
  L4-SIG w0.102: v3(35.41,82.59) 35.41,82.71 40.31,87.61 40.31,99.37 40.49,99.55 40.49,101.51 42.04,103.06 53.52,103.06 v3(55.17,101.41)
  L6-GND w0.102: v4(55.55,101.41) v3(55.17,101.41) ; v1(35.41,82.23) v3(35.41,82.59)
  L7-SIG w0.102: v4(55.55,101.41) 55.78,101.64 61.82,101.64 62.15,101.97 68.15,101.97 68.58,101.53 70.92,101.53 71.27,101.18 71.27,100.99 71.32,100.94 71.32,89.58 71.58,89.33 71.58,89.25 72.78,88.05 72.78,78.91 72.69,78.82 72.69,76.89 v1(70.92,75.12) ; v1(70.97,73.16) 70.67,73.46 68.99,73.46 v1(68.86,73.33)
  BOTTOM w0.102: v1(68.86,73.33) 68.71,73.48 R3077.1 68.91,74.18 68.91,74.23 69.22,74.53 70.33,74.53 v1(70.92,75.12) ; v1(35.41,82.23) 35.05,81.87 34.21,81.87 33.76,81.42 33.76,78.67 37.56,74.87 Q3007.2
GASG_GND_SIGNAL: length 33.7
  L4-SIG w0.102: v3(33.53,38.34) 31.95,38.34 v3(31.47,38.82)
  L6-GND w0.102: v3(33.53,38.34) 33.73,38.14 v1(33.73,37.86) ; v4(31.12,38.92) 31.37,38.92 v3(31.47,38.82)
  L7-SIG w0.102: v1(35.25,37.45) 34.77,37.93 34.77,38.2 34.5,38.46 34.27,38.46 33.73,37.92 v1(33.73,37.86) ; v1(35.25,37.45) 35.78,37.45 35.81,37.49 v1(36.42,37.49) 38.77,37.49 38.9,37.36 v1(40.29,37.36) ; v1(35.25,37.45) 34.44,36.64 v1(34.44,36.24) 34.11,35.92 34.11,35.34 33.35,34.58 v1(32.89,34.58) v1(32.39,34.58) 32.1,34.29 32.1,33.56 31.47,32.93 30.02,32.93 v1(29.58,32.49) 29.58,33.2 v1(29.58,33.21) 30.07,33.69 30.07,34.95 v1(29.6,35.42) ; v4(31.12,38.92) 31.12,39.18 30.84,39.46 30.23,39.46 29.9,39.79 v1(26.06,39.79) 26.44,40.17 26.44,44 v1(25.73,44.71)
GASG_SOC_INT: length 147.3
  L2-SIG w0.102: v8(68.56,71.94) 68.56,69.57 75.95,62.18 75.95,59.85 78.92,56.88 80.33,56.88 81.32,55.89 81.32,53.41 80.67,52.77 80.67,48.6 84.1,45.17 84.1,17.1 70.79,3.79 48.92,3.79 46.91,5.8 46.91,14.89 38.18,23.63 38.18,25.98 33.86,30.3 33.86,34.9 v8(33.14,35.62)
  L3-GND w0.102: v8(33.14,35.62) 33.1,35.58 v3(32.76,35.58) ; v3(68.87,72.11) 68.73,72.11 v8(68.56,71.94)
  L6-GND w0.102: v1(68.2,72.74) 68.83,72.11 v3(68.87,72.11) ; v3(32.76,35.58) v1(32.39,35.58)
  L7-SIG w0.102: v1(68.2,72.74) 68.67,72.74 68.99,73.06 v1(70.56,73.06)
  BOTTOM w0.102: R3066.1 68.2,72.74 v1(68.2,72.74)
GASG_SRN: length 4.1
  L7-SIG w0.102: v1(34.39,38.19) v1(34.39,37.45) 34.11,37.45 v1(33.73,37.07) 33.73,35.56 v1(33.24,35.08)
  BOTTOM w0.102: v1(33.24,35.08) U8901.B1
GASG_SRP: length 3.6
  L7-SIG w0.102: v1(32.89,35.58) 32.15,36.31 v1(32.15,37.27) 32.41,37.27 32.61,37.07 v1(32.86,37.07) v1(32.86,37.86)
GPI_HOMESCREEN#: length 88.4
  L5-SIG w0.109: v6(47.75,65.92) 47.75,64.53 46.42,63.21 46.42,60.45 45.5,59.53 44.25,59.53 v3(43.15,58.43) ; v3(38.68,52.79) 38.51,52.97 37.06,52.97 36.32,52.23 34.57,52.23 34.06,52.74 33.68,52.74 33.27,53.14 33.27,53.14 33.01,53.4 32.67,53.4 32.39,53.12 32.39,52.69 30.71,51.01 22.53,51.01 v3(22.35,51.19)
  L6-GND w0.102: v4(38.84,53.15) 38.68,52.99 v3(38.68,52.79) ; v4(42.82,58.26) 42.97,58.26 v3(43.15,58.43) ; v3(22.35,51.19) v4(21.97,51.19)
  L7-SIG w0.084: v4(21.97,51.19) 21.64,50.86 21.64,35.19 22.2,34.63 22.2,8.64 24.68,6.16 26.21,6.16 26.52,6.46 27.31,6.46 v1(28.52,5.24) ; v4(42.82,58.26) 42.73,58.26 42.57,58.09 42.57,56.88 41.62,55.93 41.62,54.39 41.27,54.04 39.73,54.04 v4(38.84,53.15)
GPIO_RCOMP18: length 6
  L4-SIG w0.127: v3(64.52,63.52) 64.52,63.69 63.3,64.91 v3(61.98,64.91)
  L5-SIG w0.06: v6(60.22,66.49) 61.38,65.33 61.55,65.33 v3(61.98,64.91)
  L6-GND w0.127: v3(64.52,63.52) 64.68,63.69 v6(64.86,63.69)
GPIO_SOC_V1P0SX_S: length 6.2
  L3-GND w0.06: v8(47.63,62.9) 47.4,62.67 v3(47.35,62.67)
  L5-SIG w0.06: 48.26,66.82 48.12,66.96 47.95,66.96 47.83,66.84 47.83,66.84 47.8,66.82 47.68,66.82 47.43,67.07 v6(47.27,67.07)
  L5-SIG w0.109: v3(47.35,62.67) 47.35,62.87 48.41,63.93 48.41,66.67 48.26,66.82
GYRO_IRQ: length 131.6
  L4-SIG w0.109: v3(75.91,69.84) 75.89,69.84 75.48,70.25 75.48,74.46 76.66,75.64 76.66,75.94 77.22,76.5 77.22,79.64 82.52,84.94 82.52,88.55 83.22,89.25 83.8,89.25 84.96,90.41 85.52,90.41 89.12,94.01 89.12,98.72 88.43,99.41 88.43,103.08 80.57,110.93 74.93,110.93 v3(74.2,111.66) 71.26,114.6 67.98,114.6 66.22,112.84 40.73,112.84 28.58,100.68 v3(28.58,100.64)
  L6-GND w0.102: v1(28.22,100.64) v3(28.58,100.64) ; v3(74.2,111.66) 74.2,111.2 v1(74.19,111.19) ; v3(75.91,69.84) 75.83,69.84 v4(75.62,69.64)
  L7-SIG w0.084: v4(75.62,69.64) 75.62,69.09 74.94,68.41 74.94,68.41 74.94,67.94 74.01,67.01 73.74,67.01 72.84,67.91 71.91,67.91 71.48,67.48 71.36,67.48 70.3,67.48 69.6,66.78 69.6,66.47 69.6,66.47 69.6,66.42 69.05,65.87 65.85,65.87 65,65.02 64.73,65.02 64.6,65.15 64.6,65.4 64.44,65.57 64.07,65.57 62.91,66.74 60.57,66.74 v6(60.52,66.78)
  BOTTOM w0.31: v1(74.19,111.19) v9(74.19,110.67)
HDA_RCOMP: length 10.6
  L5-SIG w0.06: 43.33,69.46 43.48,69.46 43.48,69.46 44.09,69.46 44.64,70.01 44.86,70.01 44.87,70 45.27,70 45.48,70.22 46.97,70.22 47.41,70.66 47.85,70.66 47.9,70.61 48.45,70.61 v6(48.58,70.74)
  L5-SIG w0.127: 43.33,69.46 40.34,69.46 v3(40.1,69.69)
  L6-GND w0.127: v3(40.1,69.69) 39.97,69.82 v1(39.97,70.05)
  BOTTOM w0.127: R2506.1 40.09,69.38 v9(40.26,69.21)
HDMI_CLK_DN_CON: length 10.1
  L5-SIG w0.094: v3(90.04,38.78) 90.74,38.07 91.34,37.48 94.26,37.48 94.86,38.08 94.86,39.66 94.99,39.79 95.17,39.79 95.51,39.46 CON0901.14
  L6-GND w0.102: v1(89.4,38.69) 89.66,38.44 89.98,38.44 90.04,38.51 v3(90.04,38.78)
  L7-SIG w0.076: v1(88.51,38.53) 88.63,38.4 89.11,38.4 v1(89.4,38.69)
HDMI_CLK_DP_CON: length 10
  L5-SIG w0.094: v3(90.61,38.77) 90.61,38.48 91.42,37.67 94.18,37.67 94.67,38.16 94.67,39.65 94.48,39.84 CON0901.12
  L6-GND w0.102: v3(90.61,38.77) 90.61,38.44 90.52,38.35 90.17,38.35 90.06,38.24 89.64,38.24 v1(89.4,37.99)
  L7-SIG w0.076: v1(89.4,37.99) 89.19,38.21 89.19,38.21 88.82,38.21 v1(88.55,37.94)
HDMI_DATA0_DN_CON: length 6.8
  L3-GND w0.102: v3(92.06,39.9) 92.2,40.04 v8(92.58,40.04)
  L5-SIG w0.094: v3(90.04,41.74) 89.87,41.57 89.63,41.57 89.42,41.36 89.42,40.59 90.04,39.96 92,39.96 v3(92.06,39.9)
  L6-GND w0.102: v1(89.4,41.74) v3(90.04,41.74)
  L7-SIG w0.076: v1(89.4,41.74) 89.08,41.42 88.71,41.42 v1(88.55,41.59)
HDMI_DATA0_DP_CON: length 6.8
  L3-GND w0.102: v8(92.58,40.44) 92.39,40.25 92.25,40.25 v3(92.04,40.47)
  L5-SIG w0.094: v3(90.04,41.13) 90.04,41.26 89.93,41.37 89.71,41.37 89.61,41.27 89.61,40.67 90.12,40.16 91.74,40.16 92.04,40.45 v3(92.04,40.47)
  L6-GND w0.102: v3(90.04,41.13) 90.04,41.23 89.89,41.39 89.53,41.39 89.4,41.26 v1(89.4,41.08)
  L7-SIG w0.076: v1(88.55,41.04) 88.74,41.23 89.25,41.23 v1(89.4,41.08)
HDMI_DATA1_DN_CON: length 11.4
  L5-SIG w0.094: CON0901.8 94.63,40.64 94.79,40.8 94.79,41.62 92.08,44.32 92.08,44.48 92.08,44.48 92.08,44.64 92.08,44.64 92.08,45.24 91.71,45.62 91.18,46.15 89.99,47.33 89.99,47.49 v3(89.79,47.69)
  L6-GND w0.102: v3(89.79,47.69) 89.64,47.84 v1(89.4,47.84)
  L7-SIG w0.076: v1(89.4,47.84) 89.18,47.62 88.71,47.62 v1(88.5,47.83)
HDMI_DATA1_DP_CON: length 11.4
  L5-SIG w0.094: CON0901.6 95.07,41.04 94.98,41.13 94.98,41.7 92.28,44.4 92.28,45.32 90.19,47.41 90.19,47.51 v3(90.35,47.67)
  L6-GND w0.102: v1(89.4,47.18) 89.86,47.18 v3(90.35,47.67)
  L7-SIG w0.076: v1(89.4,47.18) 89.15,47.43 88.74,47.43 v1(88.5,47.18)
HDMI_DATA2_DN_CON: length 7.7
  L3-GND w0.102: v3(92.03,41.2) 92.05,41.2 92.09,41.24 v8(92.58,41.24)
  L5-SIG w0.094: v3(92.03,41.2) 92.59,41.75 92.59,43.09 90.89,44.79 v3(90.1,44.79)
  L6-GND w0.102: v3(90.1,44.79) 90.02,44.71 89.48,44.71 v1(89.4,44.79)
  L7-SIG w0.076: v1(89.4,44.79) 89.18,44.57 88.71,44.57 v1(88.5,44.79)
HDMI_DATA2_DP_CON: length 7.7
  L3-GND w0.102: v8(92.58,41.64) 92.41,41.47 92.33,41.47 v3(92.05,41.76)
  L5-SIG w0.094: v3(92.05,41.76) 92.32,41.76 92.39,41.83 92.39,43.01 90.81,44.59 90.51,44.59 v3(90.1,44.18)
  L6-GND w0.102: v3(90.1,44.18) 90.1,44.25 89.84,44.51 89.47,44.51 89.4,44.44 v1(89.4,44.13)
  L7-SIG w0.076: v1(88.5,44.14) 88.74,44.38 89.15,44.38 v1(89.4,44.13)
HDMI_DDC_SCL_CONN: length 11.6
  L3-GND w0.102: v8(92.58,38.84) v3(92.2,38.84)
  L6-GND w0.102: v3(92.2,38.84) v4(92.2,38.41)
  L7-SIG w0.084: v4(92.2,38.41) 92.91,38.41 93.15,38.18 93.15,37.38 90.76,34.99 v1(88.89,34.99) 88.89,34.19 87.68,32.98 v1(87.37,32.98) v1(86.53,32.98)
HDMI_DDC_SDA_CONN: length 13.8
  L7-SIG w0.084: CON0901.18 94.97,38.64 90.94,34.6 89.88,34.6 88.9,33.63 v1(88.9,32.52) 86.25,32.52 v1(85.82,32.09) v1(85.82,32.83)
HDMI_HPD_CONN: length 18.1
  L3-GND w0.102: v8(92.58,42.04) v3(93,42.04)
  L6-GND w0.102: v3(93,42.04) v4(93,41.61)
  L7-SIG w0.084: v1(85.82,30.29) 85.82,30.82 85.55,31.09 85.55,32.94 85.71,33.1 85.99,33.1 86.38,32.71 87.67,32.71 89.77,34.8 90.85,34.8 93.42,37.36 93.42,41.19 v4(93,41.61)
HOME_BUTTON#_CON: length 8.2
  L7-SIG w0.084: v1(26.32,2.68) 26.32,3.37 v1(26.19,3.5) 26.23,3.54 26.85,3.54 v1(26.9,3.49) 27.1,3.49 27.94,4.33 27.94,4.96 v1(27.66,5.24) 25.6,5.24 v1(25.5,5.14)
  BOTTOM w0.31: C2036.1 26.14,5.04 v9(26.33,5.22) 26.32,5.23 R2040.2
HOME_BUTTON_CON: length 12.8
  L7-SIG w0.084: v1(25.45,2.68) 25.43,2.7 25.43,4.16 26.25,4.99 27.43,4.99 27.66,4.76 v1(27.66,4.51) ; v1(21.79,5.27) 23.47,5.27 v1(24.85,3.9)
  BOTTOM w0.31: v1(24.85,3.9) 24.85,3.39 24.76,3.3 R2088.1 v1(25.45,2.68) ; R2097.2 29.36,4.99 29,4.62 29,4.19 28.88,4.07 27.79,4.07 27.66,4.2 v1(27.66,4.51)
HOME_BUTTON_CON_R: length 11.5
  L7-SIG w0.102: v1(39.1,5.47) 39.1,5.22 37.69,3.82 30.05,3.82 29.82,4.05 29.82,4.78 30.1,5.06 v1(30.23,5.06)
HOME_KEY#_3V3: length 64.9
  L5-SIG w0.06: v6(57.53,35.35) 57.44,35.44 57.44,35.47 57.25,35.66 56.95,35.66 56.02,36.59 55.58,36.59 55.43,36.73 55.09,36.73
  L5-SIG w0.109: 55.09,36.73 46.84,36.73 46.07,37.5 42.79,37.5 42.72,37.56 42.72,37.56 42.36,37.93 42.36,37.93 40.04,40.25 39.62,40.25 39.18,39.81 33.95,39.81 32.27,38.13 32.27,36.97 30.95,35.66 30.95,34.72 30.04,33.81 30.04,18.81 30.91,17.94 30.91,17.18 31.24,16.85 31.24,9.13 31.63,8.74 31.63,7.33 29.16,4.86 v3(28.8,4.86)
  L6-GND w0.102: v3(28.8,4.86) 28.8,4.78 v1(28.52,4.51)
HOME_KEY#_EC: length 110.9
  L4-SIG w0.102: v3(76.28,68.26) 76.5,68.26 77.34,67.42 77.34,65.97 76.45,65.08 76.45,64.4 77.85,63 77.85,61.54 77.67,61.36 77.67,57.24 79.05,55.86 79.54,55.86 80.62,54.78 80.62,53.35 80.88,53.09 80.88,46.48 81.57,45.79 81.57,37.2 82.33,36.44 83.07,36.44 84.32,35.19 84.32,32.44 83.25,31.37 83.25,16.79 70.23,3.77 v3(69.55,3.77)
  L5-SIG w0.102: v3(40.06,7.07) 40.34,7.07 45.87,1.53 67.31,1.53 v3(69.55,3.77)
  L6-GND w0.102: v1(39.7,7.07) v3(40.06,7.07) ; v1(76.51,67.94) 76.51,68.04 v3(76.28,68.26)
  BOTTOM w0.102: Q2001.6 39.39,6.12 39.7,6.44 v1(39.7,7.07)
HOMEKEY_VIB_INT#: length 89.5
  L7-SIG w0.084: v1(40.44,64.55) 40.82,64.93 41.09,64.93 41.26,64.93 41.59,65.27 41.59,65.43 41.59,65.64 41.75,65.8 42.41,65.8 42.49,65.72 42.88,65.72 43.1,65.49 44.83,65.49 45.06,65.72 46.28,65.72 v6(46.35,65.65) ; v1(27.18,6.18) 26.87,5.88 24.69,5.88 21.97,8.59 21.97,34.45 21.41,35.01 21.41,50.76 20.75,51.42 20.12,51.42 19.84,51.7 19.84,52.08 20.32,52.56 25.5,52.56 26.57,53.63 27.79,53.63 28.35,53.07 31.34,53.07 31.59,53.32 32.33,53.32 33,53.98 34.27,53.98 34.8,54.52 34.8,55.28 35.15,55.64 36.14,55.64 36.92,56.41 36.92,58.67 36.53,59.06 36.53,60.84 36.86,61.17 36.86,63.89 37.52,64.55 v1(38.96,64.55)
  BOTTOM w0.31: v1(40.44,64.55) v1(38.96,64.55)
I2C_0_SCL: length 260
  L4-SIG w0.109: v3(15.57,62.39) 4.56,62.39 2.5,64.45 2.5,67.34 5.83,70.68 13.15,70.68 15.98,73.51 15.98,78.97 17.2,80.19 17.2,90.22 17.35,90.38 17.35,99.78 19.47,101.9 23.41,101.9 v3(25.65,99.65) 26.01,99.3 30.08,99.3 v3(33.59,95.78)
  L5-SIG w0.06: v6(48.09,71.28) 47.95,71.28 47.69,71.02 47.26,71.02 46.85,70.61 45.64,70.61 45.37,70.88 44.66,70.88 44.19,70.4
  L5-SIG w0.109: 44.19,70.4 43.48,70.4 43.48,70.4 40.77,70.4 40.39,70.78 38.94,70.78 29.88,79.85 29.88,79.96 29.87,79.96 29.87,87.3 28.98,88.19 28.98,91.65 33.3,95.97 33.4,95.97 v3(33.59,95.78) 34.54,94.83 36.45,94.83 38.66,97.04 39.8,97.04 39.85,97.09 42.08,97.09 42.82,97.82 42.82,97.82 43.16,98.17 43.16,99.22 44.48,100.54 44.48,101.25 45.05,101.82 72.23,101.82 v3(74.12,99.93) 74.16,99.89 74.16,98.22 77.49,94.88 77.49,80.32 78.35,79.46 78.35,77.75 77.58,76.98 77.58,74.86 76.51,73.79 76.51,70.82 76.7,70.63 76.7,67.49 v3(76.68,67.47) ; v3(15.57,62.39) 16.38,62.39 21.1,57.67 21.1,50.99 30.53,41.57 v3(30.53,38.52) 30.53,37.98 29.38,36.83 29.38,25.36 v3(28.42,24.4)
  L6-GND w0.102: v3(25.65,99.65) 25.4,99.4 v1(25.35,99.4) ; v1(77.37,67.54) 76.75,67.54 v3(76.68,67.47) ; v3(28.42,24.4) 28.47,24.36 v4(28.47,24.04) ; v1(30.66,38.13) 30.66,38.38 v3(30.53,38.52) ; v1(74.47,99.93) v3(74.12,99.93)
  L7-SIG w0.084: v4(28.47,24.04) 28.47,19.84 29.68,18.63 31,18.63 31.3,18.92 32.04,18.92 32.61,19.49 32.61,19.69 v1(32.87,19.95)
  BOTTOM w0.31: T3005.1 25.05,99.1 v1(25.35,99.4)
I2C_0_SDA: length 261.8
  L4-SIG w0.109: v3(16,61.99) 4.45,61.99 2.13,64.3 2.13,67.49 5.68,71.04 13,71.04 15.61,73.66 15.61,79.12 16.83,80.34 16.83,90.37 16.99,90.53 16.99,99.93 19.32,102.27 23.78,102.27 v3(25.81,100.24) 26.36,99.69 29.9,99.69 29.9,99.69 30.2,99.69 33.49,96.4 v3(33.56,96.4)
  L5-SIG w0.06: v6(48.37,71.02) 47.86,71.02 47.74,70.9 47.31,70.9 46.9,70.49 45.59,70.49 45.32,70.76 44.79,70.76 44.07,70.04 43.48,70.04 43.48,70.04 43.33,70.04
  L5-SIG w0.109: v3(76.81,66.91) 77.07,67.17 77.07,70.78 76.87,70.98 76.87,71.51 78.69,73.32 78.69,75.42 78.16,75.94 78.16,77.05 78.72,77.6 78.72,79.64 77.86,80.5 77.86,95.03 74.52,98.37 74.52,100.27 v3(74.12,100.67) 72.6,102.18 44.55,102.18 42.8,100.43 42.8,98.32 41.93,97.46 39.7,97.46 39.65,97.4 38.47,97.4 36.27,95.21 34.75,95.21 33.56,96.39 ; 33.56,96.39 33.21,96.39 28.6,91.79 28.6,88.05 29.51,87.15 29.51,79.7 38.79,70.42 40.24,70.42 40.62,70.04 43.33,70.04 ; 33.56,96.39 v3(33.56,96.4) ; v3(28.42,24.96) 29.01,25.55 29.01,36.97 29.93,37.89 v3(29.93,38.76) 29.93,41.66 20.74,50.84 20.74,57.52 16.27,61.99 v3(16,61.99)
  L6-GND w0.102: v1(74.47,100.67) v3(74.12,100.67) ; v1(29.93,38.13) v3(29.93,38.76) ; v4(28.81,24.93) 28.46,24.93 v3(28.42,24.96) ; v1(77.12,67.14) 77.04,67.14 v3(76.81,66.91) ; v3(25.81,100.24) 25.48,100.24 v1(25.38,100.14)
  L7-SIG w0.084: v1(32.18,19.95) 32.18,19.53 31.91,19.27 31.17,19.27 30.87,18.97 29.82,18.97 28.81,19.98 v4(28.81,24.93)
I2C_1_SCL: length 162.9
  L4-SIG w0.109: v3(33.14,93.66) 32.95,93.84 32.95,93.84 32.72,94.07 32.72,94.08 28.94,97.85 26.08,97.85 26.08,97.85 25.6,97.85 25.58,97.85 22.83,100.6 20.89,100.6 19.41,99.13 19.41,80.51 17.3,78.39 17.3,76.49 17.41,76.39 18.28,76.39 22.21,72.45 25.83,72.45 28.91,69.37 28.91,67.78 29.38,67.3 30.18,67.3 30.43,67.55 v3(30.76,67.55)
  L5-SIG w0.06: v6(47.77,71.59) 47.07,71.59 46.75,71.27 46,71.27
  L5-SIG w0.109: v3(44.79,99.63) 44.04,98.89 44.04,98.13 42.28,96.37 40.16,96.37 40.08,96.29 39.09,96.29 36.89,94.09 33.57,94.09 v3(33.14,93.66) 31.61,92.14 31.61,83.48 31.19,83.05 31.19,80.49 33.7,77.98 34.89,77.98 36.93,75.94 36.93,75.64 36.93,75.64 36.93,75.27 39.38,72.82 40.63,72.82 41.61,71.84 43.05,71.84 43.25,72.04 45.08,72.04 45.85,71.27 46,71.27
  L6-GND w0.102: v4(44.78,100.09) 44.79,100.09 v3(44.79,99.63) ; v3(30.76,67.55) 30.76,67.54 v1(30.4,67.54)
  L7-SIG w0.084: v4(44.78,100.09) 44.01,100.86 44.01,101.2 44.73,101.92 44.72,101.93 44.72,102.15 44.89,102.32 74.76,102.32 74.96,102.52 75.64,102.52 v1(76.78,101.38) 76.83,101.33 78.79,101.33 79.74,100.38 80.81,100.38 83.78,97.41 83.78,95.95 85.47,94.27 v1(85.55,94.27) ; v1(34.68,67.75) 33.73,67.75 33.52,67.54 v1(30.4,67.54)
  BOTTOM w0.31: v9(77.19,100.4) 76.78,100.81 v1(76.78,101.38)
I2C_1_SDA: length 162.6
  L4-SIG w0.109: v3(30.79,66.99) 30.39,66.99 30.33,66.94 29.23,66.94 28.51,67.66 28.51,69.26 25.68,72.09 22.06,72.09 18.13,76.02 17.25,76.02 16.93,76.34 16.93,78.54 19.05,80.66 19.05,99.28 20.74,100.97 22.98,100.97 25.73,98.22 25.75,98.22 29.12,98.22 v3(33.1,94.23)
  L5-SIG w0.06: v6(46.64,71.05) 45.71,71.05 45.44,71.32 43.61,71.32 43.46,71.47 43.33,71.47
  L5-SIG w0.109: 43.33,71.47 41.46,71.47 40.48,72.46 39.53,72.46 39.22,72.46 36.57,75.12 36.57,75.79 34.74,77.61 33.85,77.61 33.55,77.61 30.82,80.34 30.82,83.2 31.25,83.63 31.25,92.37 v3(33.1,94.23) 33.32,94.45 33.41,94.45 33.42,94.45 36.64,94.45 38.86,96.68 39.96,96.68 40.01,96.73 42.25,96.73 43.54,98.02 43.54,98.98 v3(44.19,99.63)
  L6-GND w0.102: v3(30.79,66.99) 30.79,66.99 30.63,67.14 v1(30.4,67.14) ; v3(44.19,99.63) v4(44.19,100.03)
  L7-SIG w0.084: v1(34.68,67.07) 34.6,67.14 v1(30.4,67.14) ; v4(44.19,100.03) 44.19,100.16 43.67,100.67 43.67,101.62 43.98,101.93 43.98,102.15 44.49,102.66 74.59,102.66 74.8,102.88 75.76,102.88 76.97,101.67 78.93,101.67 79.88,100.72 80.95,100.72 84.12,97.55 84.12,97.55 84.3,97.37 84.3,95.91 v1(85.55,94.67)
I2C_2_SCL: length 229.1
  L4-SIG w0.109: v3(23.55,31.27) 23.55,28.16 32.01,19.7 36.67,19.7 38.32,18.05 39.84,18.05 46.23,11.66 49.12,11.66 49.71,12.26 56.92,12.26 57.42,11.76 71.34,11.76 74.78,15.19 76.02,15.19 76.6,14.61 77.51,14.61 78.26,15.36 78.26,16.16 78.51,16.42 v3(79.76,16.42)
  L5-SIG w0.06: 43.33,70.77 43.41,70.77 43.41,70.77 43.48,70.77 43.48,70.77 44.25,70.77 44.48,71 45.42,71 45.69,70.73 46.8,70.73 47.21,71.14 47.64,71.14 48.06,71.56 v6(48.33,71.56)
  L5-SIG w0.109: 43.33,70.77 41.01,70.77 40.63,71.15 39.14,71.15 30.24,80.05 30.24,87.48 v3(29.81,87.9) ; v2(20.37,6.28) 20.13,6.53 20.13,14.22 21.98,16.07 21.98,29.7 v3(23.55,31.27) 24.18,31.9 24.18,38.46 18.72,43.93 18.72,58.22 15.96,60.97 6.97,60.97 3.22,64.73 3.22,68.57 3.84,69.2 3.84,71.59 3.84,72.71 2.25,74.3 2.25,84.13 3.22,85.1 4.57,85.1 4.88,84.8 11.84,84.8 13.68,86.63 14.79,86.63 15.47,87.31 17.87,87.31 22.41,82.77 v3(23.17,82.77)
  L6-GND w0.102: v3(29.81,87.9) 29.66,87.74 v4(29.49,87.74) ; v1(79.76,15.66) v3(79.76,16.42) ; v4(23.56,82.77) v3(23.17,82.77)
  L7-SIG w0.084: v4(23.56,82.77) 23.84,83.05 24.5,83.05 27.93,86.48 27.93,86.71 28.49,87.28 28.72,87.28 29.19,87.74 v4(29.49,87.74) ; v2(20.37,6.28) 20.37,5.86 v1(20.3,5.78)
I2C_2_SDA: length 227.9
  L4-SIG w0.109: v3(78.46,17.54) 77.74,16.81 77.74,15.35 77.36,14.97 76.75,14.97 76.17,15.56 74.62,15.56 71.19,12.12 57.57,12.12 57.07,12.62 49.56,12.62 48.96,12.02 46.38,12.02 40,18.41 38.47,18.41 36.82,20.06 32.16,20.06 23.93,28.29 23.93,31.47 v3(23.55,31.85)
  L5-SIG w0.06: v6(47.52,71.34) 47.25,71.34 46.75,70.85 45.74,70.85 45.46,71.13 43.33,71.13
  L5-SIG w0.109: v3(29.46,88.4) 29.89,88.4 30.76,87.53 30.76,83.44 30.61,83.29 30.61,80.25 39.28,71.58 40.8,71.58 41.26,71.13 43.33,71.13 ; v3(23.15,83.33) 22.37,83.33 18.03,87.68 15.32,87.68 15.17,87.53 14.64,87 13.53,87 11.69,85.16 5.03,85.16 4.72,85.47 3.07,85.47 1.88,84.28 1.88,74.15 3.48,72.56 3.48,69.35 2.85,68.72 2.85,64.58 6.82,60.61 15.81,60.61 18.35,58.06 18.35,43.78 23.82,38.31 23.82,32.12 v3(23.55,31.85) 21.62,29.91 21.62,16.22 19.76,14.37 v2(19.76,6.31)
  L6-GND w0.102: v4(29.16,88.2) 29.27,88.2 v3(29.46,88.4) ; v4(23.55,83.39) 23.21,83.39 v3(23.15,83.33) ; v1(78.46,18.04) v3(78.46,17.54)
  L7-SIG w0.084: v2(19.76,6.31) 19.8,6.28 v1(19.8,5.78) ; v4(29.16,88.2) 29.16,88.19 28.58,87.61 28.35,87.61 27.59,86.85 27.59,86.62 24.36,83.39 v4(23.55,83.39)
I2C_3_SCL: length 74
  L4-SIG w0.109: v3(39.45,101.66) 39.62,101.49 39.62,100.25 39.75,100.12 39.75,87.64 34.13,82.02 34.13,80.17 34.54,79.77 34.92,79.77 38.43,76.25 38.43,75.74 38.41,75.72 v3(38.41,75.42)
  L5-SIG w0.109: v3(12.52,107.1) 14.55,105.06 35.69,105.06 38.99,101.76 39.35,101.76 v3(39.45,101.66)
  L6-GND w0.102: v1(12.16,107.1) v3(12.52,107.1) ; v4(38.41,75.03) v3(38.41,75.42)
  L7-SIG w0.06: v6(48.56,71.88) 48.35,71.88 48.16,72.07 47.96,72.07 47.7,71.82 47.7,71.81 47.58,71.69 47.38,71.69 47.28,71.79 47.27,71.79 46.99,72.07 46.79,72.07 46.71,71.99 46.04,71.99 45.84,72.19 45.52,72.19 45.43,72.1
  L7-SIG w0.084: 45.43,72.1 45.42,72.11 44.35,72.11 44.02,72.44 42.46,72.44 42.19,72.71 41.56,72.71 41.08,73.19 40.66,73.19 39.95,73.9 39.53,73.9 v4(38.41,75.03)
  BOTTOM w0.31: v9(12.97,106.04) 12.16,106.85 v1(12.16,107.1)
I2C_3_SDA: length 72.3
  L4-SIG w0.109: v3(38.05,75.9) 34.55,79.4 34.37,79.4 33.77,80 33.77,82.17 39.06,87.46 39.06,87.46 39.37,87.78 39.37,94.59 39.06,94.9 39.06,100.56 39.25,100.76 39.25,101.24 39.06,101.44 39.06,101.83 v3(39.45,102.22)
  L5-SIG w0.109: v3(39.45,102.22) 39.35,102.12 39.21,102.12 35.91,105.42 14.76,105.42 v3(12.49,107.7)
  L6-GND w0.102: v3(12.49,107.7) 12.35,107.83 v1(12.16,107.83) ; v4(38.05,75.12) 38,75.17 38,75.85 v3(38.05,75.9)
  L7-SIG w0.06: 42.61,72.29 43.98,72.29 44.29,71.97 45.05,71.97 45.05,71.97 45.48,71.97 45.59,72.07 45.79,72.07 46.06,71.81 46.64,71.81 46.86,71.59 v6(47.2,71.59)
  L7-SIG w0.084: v4(38.05,75.12) 38.05,74.9 39.41,73.54 39.83,73.54 40.52,72.86 40.94,72.86 41.43,72.37 42.22,72.37 42.3,72.29 42.61,72.29
I2C_4_SCL: length 134
  L3-GND w0.102: v3(92.2,117.46) v8(91.83,117.46)
  L4-SIG w0.109: v3(24.5,79.27) 24.07,79.7 24.07,84.4 30.46,90.79 32.86,90.79 35.44,93.37 35.44,98.59 32.96,101.07 v3(32.96,101.99) 42.31,111.34 65.25,111.34 v3(65.3,111.39)
  L6-GND w0.102: v3(92.2,117.46) v4(92.74,117.46) ; v4(24.88,79.26) 24.51,79.26 v3(24.5,79.27) ; v3(65.3,111.39) 65.3,112 v1(65.35,112.05) ; v3(32.96,101.99) 32.92,101.95 v4(32.92,101.64)
  L7-SIG w0.06: v6(46.07,71.6) 45.08,71.6 45.05,71.57 44.85,71.57 44.6,71.82 43.08,71.82
  L7-SIG w0.084: v4(32.92,101.64) 32.92,101.55 34.08,100.4 34.27,100.2 34.27,98.88 v1(34.37,98.79) ; v1(65.35,112.05) 68.69,108.71 88.33,108.71 v1(88.57,108.95) 88.95,109.33 88.95,110.35 92.74,114.13 v4(92.74,117.46) ; 43.08,71.82 41.39,71.82 40.68,72.52 40.38,72.52 39.71,73.19 39.29,73.19 37.66,74.81 37.66,75.74 35.27,78.13 32.3,78.13 30.58,79.85 25.47,79.85 v4(24.88,79.26)
  BOTTOM w0.31: v9(64.2,111.08) 65.17,112.05 v1(65.35,112.05)
I2C_4_SDA: length 142.7
  L3-GND w0.102: v3(93.45,117.46) 93.45,117.46 v8(94.08,117.46)
  L4-SIG w0.109: v3(67.41,112.46) 66.73,111.77 42.18,111.77 32.42,102.01 v3(32.42,101.28) 32.42,100.99 35.08,98.34 35.08,93.53 32.71,91.16 30.31,91.16 23.7,84.55 23.7,79.51 v3(24.51,78.71)
  L6-GND w0.102: v4(93.23,116.9) 93.23,117.24 v3(93.45,117.46) ; v3(24.51,78.71) 24.53,78.73 v4(24.86,78.73) ; v1(67.59,112.05) 67.41,112.23 v3(67.41,112.46) ; v4(32.42,101.64) v3(32.42,101.28)
  L7-SIG w0.06: 43.33,71.48 44.57,71.48 44.62,71.42 45.71,71.42 v6(46.07,71.06)
  L7-SIG w0.084: v4(24.86,78.73) 25.64,79.51 30.44,79.51 32.16,77.8 35.1,77.8 37.31,75.58 37.31,74.39 39.52,72.18 40.54,72.18 41.25,71.48 43.33,71.48 ; v1(34.37,98.05) 33.94,98.49 33.94,100.06 32.42,101.57 v4(32.42,101.64) ; v1(67.59,112.05) 67.25,112.39 65.22,112.39 65.02,112.19 65.02,111.91 68.55,108.37 88.5,108.37 89.03,108.9 v1(89.31,108.9) 89.31,110.23 93.23,114.15 v4(93.23,116.9)
  BOTTOM w0.31: v9(68.58,111.32) 68.32,111.32 v1(67.59,112.05)
I2C_5_SCL: length 249.5
  L4-SIG w0.109: v3(46.53,71.99) 46.24,72.28 43.62,72.28 42.71,73.19 42.68,73.19 42.53,73.35 38.5,73.35 37.27,74.59 37.27,75.52 32.97,79.81 32.97,80.37 32.17,81.17 32.17,82.67 32.4,82.89 33.83,82.89 38.81,87.88 38.81,94.63 38.69,94.75 38.69,94.77 38.67,94.79 v3(38.67,99.77) ; v3(2.94,70.37) 1.77,69.2 1.77,64.15 5.1,60.82 15.52,60.82 18.4,57.94 18.4,10.08 19.33,9.15 19.33,6.16 23.74,1.75 72.44,1.75 75.86,5.17 75.86,6.45 v3(76.25,6.84)
  L5-SIG w0.109: v3(2.94,70.37) 2.52,70.79 2.52,71.78 2.52,71.78 2.52,72.59 1.21,73.9 1.21,86.49 2.39,87.67 2.39,88.69 1.21,89.88 1.21,94.19 3.3,96.27 23.04,96.27 29.52,102.75 35.24,102.75 37.82,100.17 38.27,100.17 v3(38.67,99.77)
  L6-GND w0.06: v6(46.88,71.87) 46.65,71.87 v3(46.53,71.99)
  L6-GND w0.102: v3(76.25,6.84) 76.26,6.84 v1(76.64,6.84)
I2C_5_SDA: length 248.6
  L4-SIG w0.109: v3(46.14,71.59) 45.66,72.07 43.54,72.07 42.62,72.98 38.35,72.98 36.75,74.58 36.75,75.51 32.6,79.66 32.6,80.22 31.81,81.02 31.81,82.82 32.25,83.25 33.68,83.25 38.31,87.89 38.31,99.58 v3(38.1,99.78) ; v3(76.25,6) 76.25,4.9 72.74,1.39 23.59,1.39 18.96,6.02 18.96,8.94 18.04,9.86 18.04,57.78 15.37,60.45 4.95,60.45 1.41,64 1.41,64.3 1.41,64.3 1.41,69.38 2.96,70.93 v3(2.96,70.93)
  L5-SIG w0.109: v3(38.1,99.78) 37.61,99.78 35.02,102.37 29.65,102.37 23.19,95.91 3.51,95.91 1.58,93.98 1.58,90.02 2.76,88.84 2.76,87.52 1.58,86.34 1.58,74.05 2.96,72.66 v3(2.96,70.93)
  L6-GND w0.06: v3(46.14,71.59) 46.14,71.47 46.31,71.3 v6(46.33,71.3)
  L6-GND w0.102: v1(76.65,6) v3(76.25,6)
I2C_CAM2_SCL: length 18.4
  L5-SIG w0.109: v3(10.92,107.1) 10.71,107.1 6.76,111.05 6.76,121.78 v3(6.85,121.88)
  L6-GND w0.102: v1(11.3,107.1) v3(10.92,107.1) ; v1(6.85,122.25) v3(6.85,121.88)
  BOTTOM w0.31: v1(11.3,107.1) 11.3,106.23 v9(11.23,106.17)
I2C_CAM2_SDA: length 13.7
  L5-SIG w0.109: v3(10.92,107.83) 10.58,107.83 7.15,111.26 v3(7.15,119.01)
  L6-GND w0.102: v1(11.3,107.83) v3(10.92,107.83) ; v1(7.15,119.39) v3(7.15,119.01)
I2C_NFC_SCL: length 106.2
  L7-SIG w0.06: v6(46.63,73.33) 46.36,73.61 42.04,73.61 41.14,74.51 41.02,74.51
  L7-SIG w0.084: 41.02,74.51 40.32,75.21 40.07,75.21 36.81,78.46 36.81,94.05 38.91,96.15 38.91,100.19 38.91,100.47 39.35,100.91 40.73,100.91 43.02,103.19 73.89,103.19 74.93,104.23 77.49,104.23 79.25,102.47 84.16,102.47 v1(84.84,101.79) 87.08,99.55 87.08,99.44 87.24,99.28 87.89,99.28 88.3,98.88 88.3,90.6 88.38,90.51 88.38,86.94 87.9,86.46 85.77,86.46 85.24,87 85.24,87.6 85.5,87.87 v1(85.52,87.87)
  BOTTOM w0.31: v9(86.1,102.55) 85.76,102.55 85,101.79 v1(84.84,101.79)
I2C_NFC_SDA: length 103.2
  L7-SIG w0.06: v6(48.05,73.57) 47.77,73.57 47.57,73.77 47.54,73.77 47.28,74.03 47.05,74.03 46.84,73.82 46.53,73.82 46.46,73.75 45.03,73.75
  L7-SIG w0.084: v1(85.57,87.46) 86.24,86.8 87.76,86.8 87.96,87 87.96,87.74 88.04,87.82 88.04,90.37 87.96,90.46 87.96,98.74 87.75,98.94 87.1,98.94 86.74,99.3 86.74,99.41 v1(85.19,100.97) 84.02,102.14 79.39,102.14 79.03,102.14 77.27,103.9 75.16,103.9 74.12,102.85 43.16,102.85 40.87,100.57 39.49,100.57 39.25,100.33 39.25,95.73 37.41,93.88 37.41,78.35 40.21,75.54 40.24,75.54 40.44,75.35 40.44,75.31 41.02,74.73 41.16,74.73 42.14,73.75 45.03,73.75
  BOTTOM w0.31: v9(85.76,100.81) 85.6,100.97 v1(85.19,100.97)
I2C_PMIC_SCL: length 212.7
  L4-SIG w0.109: v3(72.34,35.32) 73.07,36.04 73.07,36.6 73.8,37.34 73.8,41.37 69.5,45.68 58.65,45.68 58.29,45.32 41.63,45.32 37.17,49.78 37.17,52.6 38.13,53.55 38.13,54.05 36.98,55.2 34.35,55.2 31.78,52.63 v3(31.27,52.63) ; v3(21.74,52.77) 20.8,53.72 20.8,57.88 15.88,62.79 4.67,62.79 2.86,64.6 2.86,67.19 3.79,68.12 10.45,68.12 v3(11.18,68.85) 11.84,68.85 16.35,73.36 16.35,78.77 18.44,80.86 18.44,99.41 18.44,99.78 20.2,101.54 23.24,101.54 25.27,99.51 25.27,99.49 25.5,99.27 25.51,99.27 25.99,98.79 29.6,98.79 34.47,93.92 34.47,93.77 v3(34.56,93.69)
  L5-SIG w0.109: v3(21.74,52.77) 22.49,52.02 30.9,52.02 31.27,52.38 v3(31.27,52.63) ; v6(48.04,71.87) 47.38,71.87 46.74,72.5 43.66,72.5 43.57,72.6 v3(42.14,72.6) 41.9,72.84 41.74,72.84 41.03,73.55 39.68,73.55 37.66,75.57 37.66,76.24 35.19,78.7 34,78.7 31.91,80.79 31.91,82.69 33.22,84 33.22,87.08 32.9,87.4 32.9,91.87 34.56,93.52 v3(34.56,93.69)
  L6-GND w0.06: 62.33,37.4 62.13,37.4 61.49,36.76 60.68,36.76 60.52,36.6 60.52,36.34 v6(60.32,36.14)
  L6-GND w0.102: v4(69.06,37.4) 62.33,37.4 ; v3(42.14,72.6) 42.01,72.47 v1(42.01,72.09) ; v3(72.34,35.32) 71.93,35.72 v4(71.86,35.72) ; v1(10.8,68.85) v3(11.18,68.85)
  L7-SIG w0.084: v4(71.86,35.72) 71.4,36.18 70.51,36.18 70.46,36.23 70.35,36.23 69.18,37.4 v4(69.06,37.4)
  BOTTOM w0.31: v9(11.34,68.01) 10.8,68.56 v1(10.8,68.85)
I2C_PMIC_SDA: length 212.8
  L4-SIG w0.109: v3(21.76,53.48) 21.76,53.47 21.16,54.06 21.16,58.03 16.04,63.16 4.82,63.16 3.22,64.75 3.22,67.04 3.94,67.76 10.66,67.76 11.39,68.49 11.99,68.49 16.71,73.21 16.71,78.62 18.81,80.71 18.81,99.56 20.42,101.18 23.09,101.18 24.91,99.36 24.91,99.34 25.34,98.91 25.36,98.91 25.84,98.43 29.45,98.43 34,93.88 v3(34,93.66) ; v3(72.34,34.53) 73.43,35.62 73.43,36.45 74.16,37.19 74.16,41.52 69.65,46.04 58.5,46.04 58.14,45.69 41.86,45.69 37.54,50.01 37.54,52.45 38.49,53.4 38.49,53.87 38.49,54.2 37.13,55.57 34.2,55.57 31.65,53.02 31.06,53.02 v3(30.71,52.66)
  L5-SIG w0.109: v3(21.76,53.48) 21.76,53.31 22.69,52.38 30.43,52.38 v3(30.71,52.66) ; v3(34,93.66) 32.54,92.2 32.54,87.12 32.83,86.83 32.83,84.15 31.55,82.87 31.55,80.64 33.85,78.34 35.04,78.34 37.29,76.09 37.29,75.49 37.29,75.42 39.53,73.19 40.85,73.19 v3(41.52,72.51) 41.7,72.33 41.86,72.33 41.98,72.21 42.42,72.21 42.54,72.33 46.67,72.33 46.94,72.06 46.94,71.84 v6(46.63,71.52)
  L6-GND w0.06: 62.33,36.48 61.74,36.48 61.2,35.94 60.52,35.94 v6(60.32,35.74)
  L6-GND w0.102: v4(69.03,35.73) 68.28,36.48 62.33,36.48 ; v1(41.53,72.09) 41.53,72.51 v3(41.52,72.51) ; v3(72.34,34.53) 72.21,34.66 v4(71.91,34.66)
  L7-SIG w0.084: v4(71.91,34.66) 71.88,34.68 70.05,34.68 69.22,35.52 69.22,35.54 v4(69.03,35.73)
  BOTTOM w0.31: v9(41.84,73.49) 41.84,72.84 41.53,72.52 v1(41.53,72.09) 41.53,71.5 41.66,71.36 R2667.1
I2C_VIO: length 12
  L6-GND w0.06: 62.33,37.75 62.18,37.75 61.98,37.55 61.98,37.42 61.44,36.88 60.63,36.88 60.32,36.57 v6(60.32,36.54)
  L6-GND w0.102: 62.33,37.75 62.76,37.75 62.79,37.78 68.89,37.78 v4(69.08,37.97)
  L7-SIG w0.102: v4(69.08,37.97) 69.24,37.97 70.03,37.17 70.74,37.17 71.02,36.89 v1(71.17,36.89)
I2CM_SZ_A1: length 10.9
  L6-GND w0.06: 62.33,34.5 62,34.5 61.93,34.58 v6(61.12,34.58)
  L6-GND w0.102: 62.33,34.5 62.74,34.5 63.53,33.72 63.53,33.03 63.99,32.57 67.33,32.57 67.34,32.57 67.52,32.57 68.49,31.61 v4(69.8,31.61)
  L7-SIG w0.102: v4(69.8,31.61) 69.98,31.79 v1(69.98,32.14)
I2S_0_CLK: length 31.9
  L7-SIG w0.06: 43.33,70.9 43.47,70.9 43.51,70.86 45.07,70.86 45.18,70.97 45.69,70.97 45.93,70.73 46.08,70.73 46.29,70.53 46.6,70.53 v6(46.67,70.46)
  L7-SIG w0.084: v1(27.01,72.67) 27.33,72.98 27.33,74.35 25.02,76.66 25.02,77.76 25.22,77.97 26.18,78.92 30.29,78.92 31.95,77.27 33.67,77.27 39.99,70.94 41.51,70.94 41.55,70.9 43.33,70.9
I2S_0_FS: length 33
  L7-SIG w0.06: 43.33,71.29 45.55,71.29 45.99,70.85 46.17,70.85 46.26,70.94 46.45,70.94 46.65,70.74 v6(46.92,70.74)
  L7-SIG w0.084: 43.33,71.29 41.17,71.29 40.47,72 39.45,72 37.07,74.37 37.07,75.52 34.99,77.61 32.23,77.61 32.08,77.61 30.37,79.32 26.07,79.32 25.02,78.27 v1(24.89,78.27)
  BOTTOM w0.31: R1036.2 24.97,73.77 24.97,78.19 v1(24.89,78.27)
I2S_0_FS_R: length 3.5
  L7-SIG w0.084: v1(27.03,70.14) 26.59,70.57 26.59,71.22 v1(26.14,71.68)
  BOTTOM w0.229: U1001.29 26.95,69.76
  BOTTOM w0.31: v1(27.03,70.14) 27.03,69.83 26.95,69.76
I2S_0_RXD: length 32.8
  L7-SIG w0.06: 43.33,70.38 44.13,70.38 44.29,70.54 45.15,70.54 45.34,70.35 45.84,70.35 45.87,70.32 46.18,70.32 46.25,70.39 46.44,70.39 46.57,70.25 46.76,70.25 46.87,70.36 47.04,70.36 47.13,70.28 47.3,70.28 47.48,70.46 v6(47.77,70.46)
  L7-SIG w0.084: v1(29.34,72.6) 28.86,73.08 28.86,73.56 25.55,76.88 25.55,77.55 26.4,78.4 30.07,78.4 31.73,76.75 33.45,76.75 39.82,70.38 41.33,70.38 43.33,70.38
I2S_0_RXD_R: length 4
  L7-SIG w0.084: v1(29.34,71.74) 29.03,71.43 29.03,70.44 v1(29.33,70.14)
  BOTTOM w0.229: 28.52,69.25 28.3,69.25 28.15,69.11 U1001.32
  BOTTOM w0.31: 28.52,69.25 29.33,70.06 v1(29.33,70.14)
I2S_0_TXD: length 30.9
  L7-SIG w0.06: v6(46,70.53) 45.94,70.47 45.42,70.47 45.23,70.66 43.56,70.66 43.47,70.57 43.33,70.57
  L7-SIG w0.084: 43.33,70.57 39.89,70.57 33.53,76.93 31.8,76.93 30.15,78.59 26.32,78.59 25.36,77.63 25.36,76.95 25.36,76.95 25.36,76.8 28.68,73.48 28.68,72.7 v1(28.58,72.6)
I2S_0_TXD_R: length 4.4
  L7-SIG w0.084: v1(27.84,71.74) v1(28.58,71.74) 28.85,71.47 28.85,70.41 v1(28.58,70.14)
  BOTTOM w0.229: U1001.31 27.75,69.27
  BOTTOM w0.31: v1(28.58,70.14) 28.58,70.09 27.75,69.27
I2S_2_CLK: length 45.6
  L7-SIG w0.06: v6(47.77,72.72) 47.56,72.92 47.03,72.92 46.89,72.78 44.72,72.78 44.02,73.49 41.94,73.49 41.24,74.19 41.14,74.19
  L7-SIG w0.084: 41.14,74.19 40.99,74.19 40.32,74.86 40.1,74.86
  L7-SIG w0.102: v1(25.48,74.03) 25.48,74.41 23.84,76.05 23.84,79.56 25.08,80.8 30.98,80.8 32.69,79.09 35.69,79.09 39.92,74.86 40.1,74.86
  BOTTOM w0.102: v1(25.48,74.03) 26.34,74.89 29.95,74.89 30.84,74 32.21,74 v9(34.26,71.96) 34.66,71.55 R1052.2
I2S_2_FS: length 42.6
  L7-SIG w0.06: 40.24,74.66 40.97,73.93 41.23,73.93 41.25,73.9 41.33,73.9 41.88,73.35 43.98,73.35 44.73,72.6 46.18,72.6 v6(46.35,72.44)
  L7-SIG w0.102: v1(25.93,74.03) 25.93,74.41 24.05,76.29 24.05,79.49 25.16,80.6 30.9,80.6 32.61,78.89 35.61,78.89 39.84,74.66 40.24,74.66
  BOTTOM w0.102: v1(25.93,74.03) 26.57,74.66 29.64,74.66 30.79,73.52 v9(31.19,73.52) 32.11,73.52 33.62,72.01 33.62,71.48 R1053.2
I2S_2_RXD: length 39.3
  L7-SIG w0.06: v6(46.92,72.44) 46.73,72.44 46.53,72.23 46.22,72.23 46.02,72.43 44.43,72.43 43.64,73.23 41.79,73.23 41.28,73.74
  L7-SIG w0.102: 41.28,73.74 40.88,73.74 40.18,74.45 39.76,74.45 35.52,78.68 32.52,78.68 30.81,80.4 25.24,80.4 24.25,79.4 24.25,76.5 26.26,74.48 v1(26.26,73.7)
  BOTTOM w0.102: R1050.2 31.16,73.06 30.86,73.06 29.77,74.15 v9(29.21,74.15) 26.72,74.15 v1(26.26,73.7)
I2S_2_TXD: length 40.4
  L7-SIG w0.06: v6(48.05,72.44) 47.94,72.44 47.75,72.25 47.4,72.25 47.31,72.33 47.11,72.33 46.99,72.21 46.69,72.21 46.59,72.11 46.14,72.11 45.93,72.31 44.38,72.31 44.12,72.58 43.57,72.58 43.24,72.91
  L7-SIG w0.102: 43.24,72.91 43.08,73.07 41.7,73.07 41.22,73.54 40.8,73.54 40.09,74.25 39.67,74.25 35.44,78.48 32.44,78.48 30.73,80.19 25.33,80.19 24.45,79.32 24.45,76.74 26.8,74.39 v1(26.8,73.57)
  BOTTOM w0.102: R1051.2 R2550.1 30.43,72.16 30.43,73.11 29.85,73.7 v9(27.38,73.7) 26.92,73.7 v1(26.8,73.57)
I2S_IRQ: length 80.1
  L4-SIG w0.109: v3(69.27,69.17) 68.76,68.67 68.49,68.67 68.04,68.22 68.04,67.71 69.1,66.66 v3(69.39,66.66) 69.39,63.44 71.14,61.7 v3(71.14,59.41) ; v3(64.13,59.01) 64.22,58.93 64.22,57.84 61.58,55.21 58.21,55.21 58.1,55.1 50.14,55.1 49.7,54.67 43,54.67 38.9,58.77 36.04,58.77 35.57,59.23 35.36,59.23 35.05,59.54 v3(35.05,60.33)
  L5-SIG w0.109: v3(64.13,59.01) 64.16,59.01 64.32,59.18 70.91,59.18 v3(71.14,59.41)
  L6-GND w0.102: v4(69.13,66.42) 69.15,66.42 v3(69.39,66.66) ; v3(35.05,60.33) 35.2,60.33 v4(35.7,60.84) ; v4(69.27,68.74) v3(69.27,69.17)
  L7-SIG w0.084: v4(69.27,68.74) 68.59,68.74 67.62,67.77 66.81,67.77 66.73,67.84 65.78,67.84 65.11,67.17 62.05,67.17 61.31,67.91 v6(60.5,67.91) ; v4(35.7,60.84) 35.7,65.32 34.28,66.74 v1(30.4,66.74) ; v4(69.13,66.42) 68.83,66.13 65.71,66.13 v6(64.85,65.26)
ICLK_ICOMP: length 12.8
  L5-SIG w0.127: v5(57.38,62.62) 57.38,62.7 57.59,62.91 57.59,65.68 56.55,66.72 53.54,66.72 v6(53.47,66.79)
  L7-SIG w0.06: 58.6,61.93 58.6,62.24 58.23,62.62 v5(57.38,62.62)
  L7-SIG w0.127: 58.6,61.93 58.6,60.36 58.59,60.35 58.59,60.07 58.68,59.99 v1(58.68,58.6)
ICLK_RCOMP: length 12.7
  L5-SIG w0.127: v6(53.73,66.21) 53.89,66.37 56.64,66.37 57.35,65.65 v5(57.35,63.08)
  L7-SIG w0.06: 59.16,61.93 58.01,63.08 v5(57.35,63.08)
  L7-SIG w0.127: v1(59.78,58.39) 59.84,58.45 59.84,59.63 59.26,60.21 59.26,61.83 59.16,61.93
ICLK_USB_TERMN: length 7.7
  L7-SIG w0.102: v6(59.62,64.83) 59.69,64.76 59.69,63.28 59.82,63.15 60.33,63.15 61.92,61.57 61.92,59.38 62.58,58.72 v1(62.59,58.72)
ICLK_USB_TERMP: length 9.9
  L7-SIG w0.102: v1(64.21,58.81) 63.81,58.41 63.44,58.41 63.25,58.61 62.88,58.61 62.71,58.44 62.06,58.44 61.71,58.79 61.71,61.48 60.25,62.95 59.79,62.95 59.53,63.21 59.53,64.39 v6(59.41,64.51)
ILIM: length 1.5
  BOTTOM w0.102: R8810.1 31.19,23.86 31.38,23.68 U8800.10
